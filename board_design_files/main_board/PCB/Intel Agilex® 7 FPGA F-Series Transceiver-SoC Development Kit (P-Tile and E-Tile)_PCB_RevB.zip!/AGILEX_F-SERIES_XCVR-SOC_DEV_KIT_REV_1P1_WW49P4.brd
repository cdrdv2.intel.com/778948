# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLEARNER_7_1HZ: length 2.7
  TOP w0.109: R475.1 189.51,59.09 189.3,58.88 U38.62
CLEARNER_RECOVERY_N0: length 106.1
  ART16 w0.094: v3(107.86,82.6) 107.46,82.2 107.25,82.2 107.03,81.99 107.03,79.36 117.04,69.35 117.04,66.01 119.13,63.92 119.13,61.84 120.09,60.88 120.09,58.46 124.78,53.77 157.81,53.77 163.18,59.14 175.88,59.14 176.18,59.45 176.7,59.45 177.04,59.78 177.04,62.04 178.7,63.7 183.06,63.7 184.86,65.51 186.35,65.51 186.72,65.14 186.72,64.45 186.62,64.36 v2(186.31,64.36)
CLEARNER_RECOVERY_N1: length 93.6
  ART16 w0.094: v2(179.58,64.36) 179.98,64.76 179.98,64.94 179.8,65.12 178.77,65.12 175.67,62.02 175.67,60.68 175.06,60.07 162.82,60.07 158.4,55.65 133.57,55.65 129.2,60.02 129.2,61.65 129.73,62.19 129.73,65.49 127.96,67.26 122.15,67.26 108.68,80.72 108.68,81.91 108.98,82.2 109.2,82.2 v3(109.6,82.6)
CLEARNER_RECOVERY_N2: length 85.1
  TOP w0.089: v2(182.22,65.65) 182.48,65.39 182.48,64.72 C868.1
  TOP w0.109: v3(162.1,7.37) 162.73,6.73 J29.1
  ART20 w0.094: v3(162.1,7.37) 162.51,6.96 162.98,6.96 163.42,7.4 163.42,8.03 167.65,12.27 172.35,12.27 174.9,14.82 174.9,41.76 176.55,43.42 176.55,45.44 175.81,46.18 174.95,46.18 173.89,47.24 173.89,50.07 175.49,51.67 175.49,61.3 177.21,63.02 181.37,63.02 182.52,64.17 182.52,65.35 v2(182.22,65.65)
CLEARNER_RECOVERY_P0: length 105.7
  ART16 w0.094: v2(187.32,64.36) 187.01,64.36 186.92,64.45 186.92,65.22 186.43,65.71 184.77,65.71 182.97,63.91 178.61,63.91 176.83,62.13 176.83,59.87 176.62,59.65 176.1,59.65 175.79,59.35 163.09,59.35 157.72,53.98 124.86,53.98 120.29,58.54 120.29,60.96 119.33,61.93 119.33,64.01 117.25,66.09 117.25,69.43 107.24,79.44 107.24,81.9 107.33,82 107.46,82 v3(107.86,81.6)
CLEARNER_RECOVERY_P1: length 93.2
  ART16 w0.094: v2(180.59,64.36) 180.19,64.76 180.19,65.02 179.88,65.33 178.69,65.33 175.46,62.1 175.46,60.76 174.97,60.27 162.74,60.27 158.32,55.85 133.65,55.85 129.4,60.11 129.4,61.57 129.93,62.1 129.93,65.57 128.04,67.46 122.23,67.46 108.89,80.81 108.89,81.82 109.06,82 109.2,82 v3(109.6,81.6)
CLEARNER_RECOVERY_P2: length 85.5
  TOP w0.089: v2(183.03,65.65) 182.77,65.39 182.77,64.72 C865.1
  TOP w0.109: v3(162.1,6.35) 161.72,6.73 J27.1
  ART20 w0.094: v2(183.03,65.65) 182.73,65.35 182.73,64.08 181.46,62.81 177.29,62.81 175.69,61.21 175.69,51.59 174.09,49.99 174.09,47.32 175.03,46.38 175.9,46.38 176.76,45.52 176.76,43.33 175.11,41.68 175.11,14.73 172.44,12.06 167.74,12.06 163.62,7.95 163.62,7.31 163.07,6.76 162.51,6.76 v3(162.1,6.35)
CLEARNER_SYSTEM_N: length 123.8
  TOP w0.089: R41.1 C866.2
  ART16 w0.094: v2(105.26,85.1) 105.26,84.8 105.36,84.7 105.82,84.7 106.17,84.35 106.17,78.44 115.75,68.87 115.75,62.87 117.65,60.97 117.65,58.71 123.33,53.04 158.23,53.04 163.62,58.42 170.2,58.42 170.51,58.12 177.2,58.12 177.66,58.57 177.66,59.14 178.12,59.6 178.27,59.6 178.44,59.77 178.44,61.82 179.58,62.97 182.75,62.97 183.49,62.23 184.58,62.23 185.36,63 190,63 191.57,61.44 191.57,57.53 192.48,56.62 193.45,56.62 193.55,56.71 v2(193.55,57.02)
  BOTTOM w0.089: R37.2 106.25,85.04 R39.1
CLEARNER_SYSTEM_P: length 123.8
  TOP w0.089: v2(193.56,56.01) R47.1
  ART16 w0.094: v2(193.56,56.01) 193.55,56.01 193.55,56.32 193.45,56.41 192.4,56.41 191.36,57.45 191.36,61.36 189.92,62.8 185.44,62.8 184.67,62.03 183.41,62.03 182.67,62.76 179.66,62.76 178.64,61.74 178.64,59.68 178.35,59.4 178.2,59.4 177.86,59.06 177.86,58.49 177.29,57.91 170.42,57.91 170.12,58.22 163.7,58.22 158.32,52.83 123.25,52.83 117.45,58.63 117.45,60.88 115.54,62.79 115.54,68.78 105.97,78.36 105.97,84.27 105.74,84.5 105.36,84.5 105.26,84.4 v2(105.26,84.1)
  BOTTOM w0.089: R37.1 106.25,84.16 R45.1
CLK_50M_PWRMAX: length 8.9
  TOP w0.109: U23.M3 v2(41.14,167.12) ; R447.1 v3(45.66,163.15)
  BOTTOM w0.109: v2(41.14,167.12) 41.53,166.73 41.53,166.12 41.68,165.96 44.53,165.96 44.73,165.76 44.73,164.08 v3(45.66,163.15)
CLK_50M_SYSMAX: length 5.2
  TOP w0.109: R441.1 v2(162.42,94.36)
  ART05 w0.114: v2(166.67,94.38) 166.29,94 162.79,94 162.43,94.36 v2(162.42,94.36)
CLKCLEANER_GPIO0: length 70.1
  TOP w0.109: v2(162.41,45.97) 162.89,45.49 164.42,45.49 R999.1 166.24,45.97 U79.A4
  ART03 w0.114: v2(162.41,45.97) 161.03,47.34 161.03,56.46 159.28,58.22 159.28,63.6 151.03,71.86 150.34,71.86 147.06,75.13 140.03,75.13 138.91,76.25 138.91,78.55 138.1,79.36 132.27,79.36 130.81,80.82 130.81,86.89 130.59,87.11 130.12,87.11 129.91,87.32 129.91,88.68 129.99,88.76 129.99,89.22 v2(130.38,89.6)
CLKCLEANER_GPIO1: length 66.2
  TOP w0.109: U40.A1 165.68,49.41 R913.1 164.35,48.08 162.96,48.08 v2(162.41,48.64)
  ART03 w0.114: v2(133.84,89.6) 134.13,89.31 134.13,89.16 134.32,88.96 134.32,88.94 134.55,88.71 134.91,88.71 135.43,88.2 135.87,88.2 136.05,88.01 136.05,87.94 136.28,87.71 136.65,87.71 136.81,87.55 136.82,87.54 137.42,86.94 137.78,86.64 139.59,86.64 141.56,84.68 145.47,84.68 152.22,77.93 152.22,77.24 152.52,76.94 153.16,76.94 153.39,77.16 154.63,77.16 163.55,68.25 163.55,60.1 165.2,58.44 165.2,50.42 163.9,49.12 162.89,49.12 v2(162.41,48.64)
CLKCLEANER_GPIO2: length 63.8
  TOP w0.109: v2(162.41,49.66) 162.89,49.17 163.12,49.17 163.12,49.17 164.22,49.17 164.22,49.17 164.43,49.17 R914.1 165.17,49.92 U40.A2
  ART03 w0.114: v2(162.41,49.66) 162.89,50.14 163.78,50.14 164.74,51.1 164.74,58.27 163.09,59.92 163.09,68.02 154.4,76.71 153.54,76.71 153.34,76.5 152.35,76.5 151.66,77.19 151.66,77.8 145.21,84.25 139.88,84.25 138.57,85.56 138,85.56 136.83,86.73 136.83,87.26 136.57,87.52 136.2,87.52 136.2,87.53 136.11,87.53 135.96,87.67 135.96,87.76 135.74,87.99 135.37,87.99 134.87,88.49 134.37,88.49 134.26,88.6 v2(133.84,88.6)
CLKCLEANER_GPIO3: length 63.8
  TOP w0.109: U40.A3 165.17,50.41 R878.1 164.4,50.16 162.91,50.16 v2(162.41,50.67)
  ART03 w0.114: v2(132.98,90.1) 132.98,89.69 133.45,89.21 133.45,88.47 133.46,88.43 133.7,88.2 133.86,88.2 133.93,88.19 133.94,88.18 134.1,88.16 134.23,88.04 134.32,87.96 134.32,87.94 134.34,87.93 134.35,87.92 134.35,87.91 134.39,87.88 134.39,87.87 134.55,87.71 134.87,87.71 arc(135.02,87.67) 135.13,87.56 135.23,87.39 arc(135.37,87.25) 135.57,87.2 135.58,87.2 arc(135.66,87.19) 135.74,87.17 136.01,86.9 136.01,85.77 136.25,85.53 136.75,85.53 137.26,85.03 137.55,85.03 137.96,84.62 138.51,84.62 139.79,83.34 144.78,83.34 152.67,75.45 154.96,75.45 162.6,67.81 162.6,59.81 164.25,58.16 164.25,51.8 163.65,51.21 162.94,51.21 v2(162.41,50.67)
CLKCLEANER_GPIO4: length 61.7
  TOP w0.109: U40.A4 165.68,50.92 R879.1 164.43,51.21 164.22,51.21 164.22,51.2 163.12,51.2 163.12,51.21 162.89,51.21 v2(162.41,51.69)
  ART03 w0.114: v2(162.41,51.69) 163.14,52.42 163.42,52.42 163.83,52.83 163.83,57.99 162.18,59.64 162.18,67.64 154.79,75.03 152.41,75.03 145.5,81.94 140.08,81.94 138.47,83.55 138.14,83.55 137.64,84.05 137.22,84.05 136.69,84.58 136.33,84.58 135.86,85.05 135.42,85.05 135.1,85.38 135.1,87.24 135.07,87.29 134.87,87.49 134.82,87.49 134.7,87.5 134.4,87.5 134.32,87.58 134.2,87.8 134.01,87.98 133.85,88 133.58,88 133.36,88.23 133.36,88.26 132.98,88.65 v2(132.98,89.1)
CLKCLEANER_GPIO5: length 64.4
  TOP w0.109: v2(180.97,72.07) 182,71.04 U41.A1
  ART03 w0.114: v2(132.11,89.6) 132.11,90.05 132.47,90.41 132.5,90.46 132.5,90.76 132.46,90.8 132.46,91.33 132.72,91.58 133.2,91.58 133.77,91.01 134.09,91.01 134.58,90.51 135.05,90.51 135.5,90.07 135.79,90.07 136.35,89.51 136.72,89.51 137.2,89.03 137.62,89.03 138,88.64 138.81,88.64 141.53,85.93 145.65,85.93 152.42,79.16 153.93,79.16 153.93,79.16 153.97,79.16 155.16,77.97 160.32,77.97 160.43,77.85 160.43,76.47 160.55,76.36 160.82,76.36 160.93,76.47 160.93,77.71 161.05,77.82 161.28,77.82 161.39,77.71 161.39,76.47 161.51,76.36 168.51,76.36 170.19,74.68 178.37,74.68 v2(180.97,72.07)
CLKCLEANER_GPIO6: length 64.2
  TOP w0.109: v2(181.99,72.07) 182.5,71.56 U41.A2
  ART03 w0.114: v2(132.11,88.6) 132.11,89.01 132.63,89.53 132.63,89.92 arc(132.58,90.11) 132.63,90.3 arc(132.69,90.38) 132.76,90.44 132.91,90.59 133.16,90.59 133.75,89.99 134.22,89.99 134.62,89.6 134.92,89.6 135.42,89.1 135.8,89.1 136.28,88.62 136.66,88.62 137.11,88.18 137.49,88.18 138.07,87.6 139.3,87.6 141.4,85.5 145.48,85.5 152.25,78.74 153.79,78.74 154.99,77.55 158.62,77.55 158.82,77.34 158.82,76.07 158.96,75.94 159.22,75.94 159.34,76.05 159.34,76.95 159.45,77.06 159.68,77.06 159.79,76.95 159.79,76.05 159.91,75.94 168.34,75.94 170.06,74.22 177.95,74.22 180.52,71.65 181.57,71.65 v2(181.99,72.07)
CLKCLEANER_INSEL00: length 66.6
  TOP w0.109: v2(162.56,53.26) 163.1,52.73 164.22,52.73 164.22,52.73 164.43,52.73 R895.1 165.68,53.99 U42.A1
  ART03 w0.114: v2(129.51,90.1) 129.93,90.1 130.01,90.02 130.51,90.02 130.77,89.76 130.77,89.44 130.74,89.41 130.74,89.41 130.67,89.34 130.67,88.86 130.67,88.86 130.77,88.76 130.77,87.93 131.01,87.68 131.37,87.68 131.69,87.36 131.69,81.01 132.88,79.82 138.49,79.82 139.42,78.89 139.42,76.58 140.27,75.73 147.08,75.73 150.49,72.31 150.55,72.31 150.56,72.3 151.22,72.3 152.47,71.05 152.63,71.05 153.07,71.48 153.23,71.48 153.39,71.32 153.39,71.16 152.96,70.72 152.96,70.56 153.12,70.4 153.28,70.4 153.71,70.83 153.88,70.83 154.04,70.67 154.04,70.51 153.6,70.08 153.6,69.91 159.76,63.75 159.76,58.37 161.47,56.67 161.47,54.36 v2(162.56,53.26)
CLKCLEANER_INSEL01: length 70.9
  TOP w0.109: v2(162.51,54.28) 163.05,53.74 164.42,53.74 R896.1 165.17,54.49 U42.A2
  ART03 w0.114: v2(162.51,54.28) 161.9,54.89 161.9,56.84 160.22,58.52 160.22,65.53 156.99,68.77 156.82,68.77 156.3,68.24 156.14,68.24 155.98,68.4 155.98,68.57 156.5,69.09 156.5,69.25 156.34,69.41 156.18,69.41 155.65,68.89 155.49,68.89 155.33,69.05 155.33,69.21 155.85,69.74 155.85,69.9 155.69,70.06 155.53,70.06 155.01,69.54 154.84,69.54 154.68,69.7 154.68,69.86 155.21,70.38 155.21,70.54 153.03,72.72 150.73,72.72 147.28,76.17 142.24,76.17 141.68,76.73 140.38,76.73 139.88,77.24 139.88,79.11 138.78,80.2 133.2,80.2 132.52,80.87 132.52,86.92 arc(132.55,87.12) 132.63,87.3 arc(132.71,87.6) 132.63,87.9 arc(132.41,88.12) 132.11,88.2 arc(131.91,88.25) 131.76,88.39 131.76,88.4 131.35,88.71 131.08,88.71 130.86,88.94 130.86,89.26 130.94,89.34 130.96,89.36 130.96,89.84 130.58,90.21 130.22,90.21 130.21,90.22 130.14,90.22 129.68,90.68 129.29,90.68 129.11,90.49 129.11,89.92 129.51,89.51 v2(129.51,89.1)
CLKCLEANER_INSEL10: length 62.9
  TOP w0.109: v2(162.44,55.28) 162.96,54.76 163.12,54.76 163.12,54.76 164.22,54.76 164.22,54.76 164.43,54.76 R897.1 165.17,54.99 U42.A3
  ART03 w0.114: v2(162.44,55.28) 162.82,55.66 162.82,58.36 161.64,59.55 161.64,63.39 161.53,63.51 161.21,63.51 161.1,63.62 161.1,63.85 161.21,63.97 161.53,63.97 161.64,64.08 161.64,64.31 161.53,64.42 161.21,64.42 161.1,64.54 161.1,64.77 161.21,64.88 161.53,64.88 161.64,64.99 161.64,65.22 161.53,65.34 161.21,65.34 161.1,65.45 161.1,65.68 161.21,65.8 161.53,65.8 161.64,65.91 161.64,66.61 157.15,71.1 157.15,71.26 157.43,71.54 157.43,71.7 157.27,71.86 157.1,71.86 156.83,71.58 156.66,71.58 156.5,71.75 156.5,71.91 156.78,72.19 156.78,72.35 156.62,72.51 156.46,72.51 156.18,72.23 156.02,72.23 155.86,72.39 155.86,72.55 156.13,72.83 156.13,73 155.97,73.16 155.81,73.16 155.53,72.88 155.37,72.88 155.21,73.04 155.21,73.2 155.49,73.48 155.49,73.64 155.33,73.8 155.16,73.8 154.89,73.52 154.72,73.52 154.56,73.69 154.56,73.85 154.84,74.13 154.84,74.29 154.68,74.45 154.52,74.45 154.24,74.17 154.08,74.17 153.71,74.54 152.19,74.54 147.64,79.09 146.23,79.09 144.47,80.85 141.88,80.85 141.63,81.09 137.13,81.09 136.63,81.6 136.31,81.6 135.81,82.09 135.34,82.09 134.87,82.57 134.61,82.57 134.32,82.87 134.32,87.13 v2(133.84,87.6)
CLKCLEANER_INSEL11: length 62.6
  TOP w0.109: U42.A4 165.73,56.26 R898.1 164.43,55.78 164.22,55.78 164.22,55.77 163.12,55.77 163.12,55.78 162.89,55.78 v2(162.41,56.26)
  ART03 w0.114: v2(133.84,86.6) 133.4,86.16 133.4,81.33 134.09,80.64 141.4,80.64 141.7,80.34 144.32,80.34 145.99,78.67 147.46,78.67 147.97,78.16 147.97,78 147.72,77.74 147.72,77.58 147.88,77.42 148.04,77.42 148.3,77.67 148.46,77.67 148.62,77.51 148.62,77.35 148.37,77.1 148.37,76.94 148.53,76.77 148.69,76.77 148.94,77.03 149.11,77.03 149.27,76.87 149.27,76.7 149.01,76.45 149.01,76.29 149.18,76.13 149.34,76.13 149.59,76.38 149.75,76.38 149.91,76.22 149.91,76.06 149.66,75.8 149.66,75.64 149.82,75.48 149.98,75.48 150.24,75.73 150.4,75.73 150.56,75.57 150.56,75.41 150.31,75.16 150.31,75 150.47,74.83 150.63,74.83 150.88,75.09 151.05,75.09 151.21,74.93 151.21,74.76 150.95,74.51 150.95,74.35 151.12,74.19 151.28,74.19 151.53,74.44 151.69,74.44 152.02,74.12 153.54,74.12 160.68,66.98 160.68,62.89 160.79,62.77 161.07,62.77 161.19,62.66 161.19,62.43 161.07,62.32 160.79,62.32 160.68,62.2 160.68,61.97 160.79,61.86 161.07,61.86 161.19,61.74 161.19,61.52 161.07,61.4 160.79,61.4 160.68,61.29 160.68,61.06 160.79,60.94 161.07,60.94 161.19,60.83 161.19,60.6 161.07,60.49 160.79,60.49 160.68,60.37 160.68,59.92 162.41,58.19 v2(162.41,56.26)
CLKCLEANER_IO_TSN: length 94.2
  TOP w0.109: v2(166.08,46.89) 165.85,47.12 R479.1
  TOP w0.127: R931.1 167.39,102.92 168.27,102.04 v2(168.27,100.78)
  ART18 w0.114: v2(167,54.99) 167.76,55.75 167.76,58.57 170.81,61.62 175.59,61.62 177.24,63.27 177.24,65.84 177.77,66.37 178.77,66.37 181.48,69.09 182.85,69.09 183.03,69.26 v2(183.03,69.75)
  ART20 w0.114: v2(168.27,100.78) 167.87,100.38 167.87,94.18 167.66,93.98 166.44,93.98 166.27,93.8 166.27,91.75 166.09,91.57 163.73,91.57 163.54,91.76 162.85,91.76 162.42,91.34 161.75,91.34 160.67,90.26 160.67,80.81 167.28,74.19 177.85,74.19 179.56,72.48 179.56,71.49 180.01,71.04 182.62,71.04 183.03,70.64 v2(183.03,69.75) ; v2(166.08,46.89) 165.46,47.51 165.46,49.2 166.7,50.44 v2(167,50.44) 167,50.75 166.52,51.23 166.52,54.69 166.82,54.99 v2(167,54.99)
CLKCLEANER_SCL: length 97.8
  TOP w0.109: v2(183.02,72.06) 183,72.04 U41.A3
  ART16 w0.114: v2(132.11,87.6) 131.12,87.6 130.61,88.11 130.16,88.11 129.74,88.53 129.4,88.53 128.82,89.12 128.56,89.12 128.13,89.55 127.71,89.55 127.2,90.06 126.86,90.06 126.33,90.59 125.87,90.59 125.45,91.01 125.06,91.01 124.57,91.49 124.16,91.49 123.77,91.11 123.33,91.11 123,90.78 123,81.34 124.21,80.14 126.87,80.14 128.14,78.87 131.95,78.87 133.48,77.34 133.48,74.68 140.84,67.31 145.67,67.31 147.45,65.53 148.97,65.53 154.18,70.74 161.93,70.74 162.94,71.75 162.94,73.13 165.56,75.74 180.67,75.74 182.5,73.91 182.5,72.52 182.96,72.06 v2(183.02,72.06)
CLKCLEANER_SDA: length 88.7
  TOP w0.109: v2(184.02,72.07) 183.5,71.55 U41.A4
  ART16 w0.114: v2(184.02,72.07) 183.49,72.61 183.49,73.56 180.85,76.2 165.35,76.2 162.43,73.28 162.43,72.01 161.67,71.25 154.05,71.25 148.84,66.04 147.57,66.04 145.8,67.82 140.97,67.82 133.99,74.8 133.99,77.47 132.08,79.38 128.27,79.38 127.13,80.52 125.48,80.52 124.46,81.53 124.21,81.53 123.84,81.9 123.84,90.37 124.16,90.69 124.49,90.69 125.08,90.1 v2(126.05,90.1)
CLKCLEANER_STATUS0: length 114.4
  TOP w0.109: U79.A1 165.18,44.21 R893.1 164.35,43.38 162.94,43.38 v2(162.38,43.94)
  ART03 w0.114: v2(131.25,90.1) 131.25,90.51 130.76,91 130.76,91.19 130.95,91.38 130.95,91.78 130.76,91.97 130.76,92.33 131.03,92.6 131.42,92.6 131.94,93.12 132.28,93.12 132.85,92.54 135.05,92.54 135.51,92.09 135.86,92.09 136.37,91.58 136.69,91.58 137.21,91.06 137.49,91.06 137.96,90.59 138.65,90.59 140.89,88.34 144.68,88.34 152.78,80.23 154.53,80.23 155.8,78.96 167.94,78.96 169.79,77.11 170.2,77.11 171.12,76.2 178.47,76.2 180.31,74.36 182.31,74.36 183.49,73.18 183.49,71.75 181.89,70.15 179.93,70.15 179.55,69.77 179.55,65.68 175.16,61.29 167.94,61.29 166.17,59.51 166.17,54.28 166.4,54.05 167.18,54.05 167.56,53.67 167.56,51.38 167.08,50.9 166.45,50.9 166.12,50.57 166.12,49.61 165.61,49.1 165.61,46.46 163.58,44.42 162.86,44.42 v2(162.38,43.94)
CLKCLEANER_STATUS1: length 109.1
  TOP w0.109: v2(162.41,44.95) 162.93,44.43 164.22,44.43 164.23,44.42 164.38,44.42 R894.1 165.16,44.71 U79.A2
  ART03 w0.114: v2(162.41,44.95) 162.94,45.49 163.73,45.49 165.18,46.94 165.18,49.35 165.63,49.81 165.63,59.66 167.69,61.72 174.98,61.72 179.1,65.84 179.1,70.33 179.96,71.2 181.86,71.2 182.47,71.8 182.47,73.28 181.81,73.94 180.14,73.94 178.3,75.78 170.94,75.78 170.03,76.69 169.58,76.69 167.74,78.54 155.62,78.54 154.35,79.81 152.58,79.81 145.31,87.07 141.43,87.07 138.91,89.59 138.07,89.59 137.53,90.13 137.22,90.13 136.77,90.59 136.18,90.59 135.69,91.08 135.45,91.08 134.94,91.59 134.63,91.59 134.01,92.21 132.59,92.21 132.45,92.08 131.93,92.08 131.66,91.81 131.66,90.94 131.51,90.79 131.51,90.59 131.8,90.3 131.8,90.07 131.24,89.51 v2(131.24,89.1)
DAOUT0: length 11.1
  TOP w0.199: R5875.1 80.14,211.74 v3(80.14,211.61) 79.83,211.31 79.83,211.08 78.51,209.76 U54.11
  TOP w0.254: v3(84.54,211.43) 84.53,211.43 84.07,210.97 C2118.2
  ART05 w0.199: v3(84.54,211.43) 83.27,210.16 81.59,210.16 v3(80.14,211.61)
DDR4_COMP_A0: length 140.4
  TOP w0.109: v2(89.34,152.16) 89.74,151.76 U3.P3 ; U4.P3 v2(100.77,152.12) ; U5.P3 v2(112.2,152.12) ; U7.P3 v2(77.91,152.12) ; U6.P3 v2(123.63,152.12)
  TOP w0.175: v2(127.28,154.56) 127.78,154.05 128.31,154.05 R1033.1
  ART03 w0.165: v2(99.2,114.6) 99.2,114.85 99.87,115.52 100.32,115.52 100.5,115.69 100.5,117.83 100.81,118.15 100.81,122.78 100.64,122.94 100.49,122.94 100.33,123.11 100.33,123.4 100.49,123.57 100.64,123.57 100.81,123.73 100.81,126.05 99.61,127.24 99.38,127.24 99.01,126.87 98.78,126.87 98.57,127.08 98.57,127.31 98.94,127.68 98.94,127.92 98.73,128.12 98.5,128.12 98.13,127.75 97.9,127.75 97.69,127.96 97.69,128.19 98.06,128.56 98.06,128.8 97.69,129.17 97.69,129.4 98.03,129.75 98.03,129.98 97.82,130.19 97.59,130.19 97.25,129.84 97.01,129.84 96.81,130.05 96.81,130.28 97.15,130.63 97.15,130.86 96.94,131.07 96.71,131.07 96.37,130.72 96.13,130.72 95.93,130.93 95.93,131.16 96.27,131.51 96.27,131.74 96.06,131.95 95.83,131.95 95.49,131.6 95.25,131.6 95.05,131.81 95.05,132.04 95.39,132.39 95.39,132.62 95.18,132.83 94.95,132.83 94.61,132.48 94.37,132.48 94.17,132.69 94.17,132.92 94.51,133.27 94.51,133.5 94.3,133.71 94.07,133.71 93.73,133.36 93.49,133.36 93.29,133.57 93.29,133.8 93.63,134.15 93.63,134.38 93.42,134.59 93.19,134.59 92.85,134.24 92.61,134.24 92.41,134.45 92.41,134.68 92.75,135.03 92.75,135.26 92.54,135.47 92.31,135.47 91.97,135.12 91.73,135.12 91.53,135.33 91.53,135.56 91.87,135.91 91.87,136.14 91.66,136.35 91.43,136.35 91.09,136 90.85,136 90.65,136.21 90.65,136.44 90.99,136.79 90.99,137.02 90.78,137.23 90.55,137.23 90.21,136.88 89.97,136.88 89.77,137.09 89.77,137.32 90.11,137.67 90.11,137.9 89.9,138.11 89.67,138.11 89.33,137.77 89.09,137.77 88.89,137.97 88.89,138.21 89.23,138.55 89.23,138.78 89.02,138.99 88.79,138.99 88.45,138.65 88.21,138.65 88,138.85 88,139.09 88.35,139.43 88.35,139.66 88.14,139.87 87.91,139.87 87.56,139.53 87.33,139.53 86.76,140.09 86.7,140.09 86.69,140.1 84.1,140.1 84.05,140.16 84.03,140.16 83.17,141.02 83.17,142.07 82.03,143.21 82.03,148.72 82.38,149.07 82.38,151.57 80.64,153.31 79.39,153.31 78.55,154.15 77.47,154.15 77.06,153.75 77.06,152.68 77.62,152.12 v2(77.91,152.12)
  ART05 w0.114: v2(77.91,152.12) 78.3,152.51 79.64,152.51 79.9,152.77 79.9,153.07 80.16,153.34 80.52,153.34 80.74,153.57 80.74,153.68 80.86,153.8 81.05,153.8 81.2,153.95 81.2,154.07 81.26,154.13 81.68,154.13 81.76,154.05 81.76,153.92 81.89,153.8 82.12,153.8 82.8,154.48 84.43,154.48 84.76,154.15 86.23,154.15 87.58,152.8 88.39,152.8 88.46,152.74 88.46,152.74 88.68,152.52 88.68,152.52 88.94,152.26 88.97,152.26 89.07,152.16 v2(89.34,152.16) 89.51,152.16 89.7,152.35 90.2,152.35 90.37,152.53 91.14,152.53 91.3,152.69 91.3,153.07 91.51,153.29 93.2,153.29 93.31,153.4 93.31,153.96 93.42,154.08 93.77,154.08 93.88,153.96 93.88,153.42 94,153.3 98.26,153.3 99.57,151.99 100.61,151.99 100.73,152.12 v2(100.77,152.12) 100.97,152.12 101.24,152.4 101.52,152.4 101.64,152.51 103.44,152.51 103.68,152.75 103.68,153.16 103.81,153.29 104.08,153.29 104.19,153.4 104.19,153.69 104.31,153.81 104.65,153.81 104.76,153.69 104.76,153.4 104.88,153.29 105.25,153.29 105.36,153.4 105.36,153.61 105.48,153.72 105.82,153.72 105.94,153.61 105.94,153.44 106.05,153.33 109.71,153.33 111.02,152.01 111.32,152.01 111.43,152.12 v2(112.2,152.12) 112.76,152.12 113.4,152.76 113.4,153.06 113.7,153.36 114.88,153.36 115.07,153.17 115.07,152.87 115.19,152.75 115.53,152.75 115.64,152.87 115.64,153.17 115.76,153.28 116.1,153.28 116.21,153.17 116.21,152.92 116.33,152.81 116.67,152.81 116.79,152.92 116.79,153.17 116.92,153.3 120.74,153.3 121.13,152.91 122.6,152.91 123.39,152.12 v2(123.63,152.12)
  ART05 w0.165: v2(127.28,154.56) 127.28,153.55 126.28,152.55 126.21,152.55 126.19,152.53 125.87,152.53 125.85,152.55 124.89,152.55 124.84,152.5 124.45,152.5 124.07,152.12 v2(123.63,152.12)
DDR4_COMP_A1: length 138.7
  TOP w0.109: U3.P7 86.99,152.17 v2(86.99,152.18) ; U6.P7 v2(121.23,152.12) ; U7.P7 v2(75.51,152.12) ; U4.P7 v2(98.37,152.12) ; U5.P7 v2(109.8,152.12)
  TOP w0.175: R1040.1 v2(122.53,156.34)
  ART05 w0.165: v2(75.51,152.12) 75.51,152.94 75.13,153.31 72.09,153.31 71.73,152.96 71.73,151.72 68.07,148.06 68.07,129.69 71.55,126.21 71.55,124.85 74.81,121.59 76.22,121.59 76.78,121.03 76.78,118.95 77.51,118.22 79.01,118.22 85.15,112.08 85.48,112.08 85.9,111.66 86.31,111.66 86.92,111.05 87.35,111.05 87.88,110.51 88.21,110.51 88.64,110.08 88.92,110.08 89.38,110.54 89.91,110.54 90.27,110.18 90.75,110.18 91.08,110.51 91.59,110.51 92,110.11 92.43,110.11 92.86,110.54 93.24,110.54 93.72,111.02 94.23,111.02 94.61,110.64 95.1,110.64 95.52,111.06 96.34,111.06 98.3,111.84 99.41,112.17 99.64,112.39 99.64,113.16 v2(99.2,113.6)
  ART07 w0.114: v2(121.23,152.12) 120.87,152.48 120.28,152.48 120.28,152.48 120.19,152.48 120.07,152.36 120.07,152.27 120.07,152.27 120.07,152.07 119.76,151.76 119.46,151.76 119.45,151.76 119.36,151.76 119.08,152.04 118.03,152.04 116.75,153.33 114.04,153.33 113.92,153.44 113.92,153.71 113.81,153.82 113.46,153.82 113.35,153.71 113.35,153.39 113.24,153.28 113.15,153.28 113.15,153.28 112.05,153.28 112.05,153.28 111.87,153.28 111.67,153.09 110.77,153.09 v2(109.8,152.12) 109.6,152.12 109.19,151.71 106.09,151.71 104.52,153.29 102.73,153.29 102.61,153.4 102.61,153.63 102.5,153.75 102.16,153.75 102.04,153.63 102.04,153.4 101.93,153.29 100.1,153.29 99.71,152.9 99.55,152.9 99.41,153.04 99.25,153.04 99,152.8 99,152.64 99.15,152.5 99.15,152.34 98.93,152.12 v2(98.37,152.12) 98.09,152.12 97.71,151.74 95.43,151.74 94.6,152.56 94.28,152.56 94.16,152.67 94.16,152.87 94.05,152.98 93.71,152.98 93.59,152.87 93.59,152.56 93.48,152.45 93.14,152.45 93.02,152.56 93.02,152.87 92.91,152.98 92.56,152.98 92.45,152.87 92.45,152.69 92.34,152.58 91.91,152.58 91.89,152.56 90.29,152.56 89.99,152.56 89.97,152.58 89.02,152.58 88.85,152.75 88.21,152.75 88.1,152.87 88.1,152.89 87.98,153.01 87.64,153.01 87.53,152.89 87.53,152.87 87.41,152.75 87.17,152.75 86.99,152.57 v2(86.99,152.18) 86.92,152.1 86.64,152.1 86.29,151.75 86.14,151.75 86.14,151.76 85.99,151.76 85.76,151.99 84.98,151.99 84.94,151.95 84.94,151.95 84.79,151.8 84.28,151.8 83.71,152.37 83.43,152.37 82.94,152.86 81.86,152.86 80.59,154.13 77.29,154.13 76.65,153.49 76.25,153.49 75.51,152.75 v2(75.51,152.12)
  ART07 w0.165: v2(122.53,156.34) 121.26,155.07 121.26,152.15 v2(121.23,152.12)
DDR4_COMP_A2: length 138.3
  TOP w0.109: U7.R3 77.95,152.88 77.95,152.89 v2(77.94,152.9) ; U3.R3 89.74,152.55 v2(89.33,152.95) ; U6.R3 v2(123.63,152.92) ; U4.R3 v2(100.77,152.92) ; U5.R3 v2(112.2,152.92)
  TOP w0.175: R1037.1 v2(126.08,156.34)
  ART03 w0.165: v2(98.34,114.1) 98.78,114.54 98.78,125.5 98.28,126 98.04,126 97.58,125.54 97.34,125.54 97.14,125.74 97.14,125.98 97.6,126.44 97.6,126.68 97.4,126.88 97.16,126.88 96.7,126.42 96.46,126.42 96.26,126.62 96.26,126.86 96.72,127.32 96.72,127.56 96.01,128.26 96.01,128.5 96.52,129 96.52,129.23 96.31,129.44 96.08,129.44 95.57,128.94 95.34,128.94 95.13,129.14 95.13,129.38 95.64,129.88 95.64,130.11 95.43,130.32 95.2,130.32 94.69,129.82 94.46,129.82 94.25,130.02 94.25,130.26 94.76,130.76 94.76,130.99 94.55,131.2 94.32,131.2 93.81,130.7 93.58,130.7 93.37,130.91 93.37,131.14 93.88,131.64 93.88,131.88 93.67,132.08 93.44,132.08 92.93,131.58 92.7,131.58 92.49,131.79 92.49,132.02 93,132.52 93,132.76 92.79,132.96 92.56,132.96 92.05,132.46 91.82,132.46 91.61,132.67 91.61,132.9 92.12,133.4 92.12,133.64 91.91,133.84 91.68,133.84 91.17,133.34 90.94,133.34 90.73,133.55 90.73,133.78 91.24,134.28 91.24,134.52 91.03,134.72 90.8,134.72 90.29,134.22 90.06,134.22 89.85,134.43 89.85,134.66 90.36,135.16 90.36,135.4 90.15,135.6 89.92,135.6 89.41,135.1 89.18,135.1 88.97,135.31 88.97,135.54 89.48,136.04 89.48,136.28 89.27,136.48 89.04,136.48 88.53,135.98 88.3,135.98 88.09,136.19 88.09,136.42 88.6,136.92 88.6,137.16 88.39,137.36 88.16,137.36 87.65,136.86 87.42,136.86 87.21,137.07 87.21,137.3 87.72,137.8 87.72,138.04 87.51,138.24 87.28,138.24 86.77,137.74 86.54,137.74 86.33,137.95 86.33,138.18 86.84,138.68 86.84,138.92 86.63,139.12 86.4,139.12 85.89,138.62 85.66,138.62 84.94,139.34 83.6,139.34 81.28,141.67 81.28,149.01 81.65,149.38 81.65,151.09 80.84,151.89 80.31,151.89 79.68,152.53 79.29,152.53 79.12,152.69 79.12,152.78 79.12,152.78 79.12,153.05 79.1,153.08 79.1,153.08 78.87,153.31 78.87,153.31 78.82,153.35 78.39,153.35 v2(77.94,152.9)
  ART05 w0.114: v2(77.94,152.9) 77.95,152.92 77.95,152.96 79.76,154.77 80.46,154.77 80.65,154.96 81.07,154.96 81.26,154.77 82.1,154.77 82.97,155.64 83.59,155.83 85.56,155.83 85.92,155.63 86.97,154.58 86.97,154.35 87.9,153.42 88.87,153.42 v2(89.33,152.95) 89.69,153.31 90.29,153.31 91.75,154.77 91.75,154.77 91.78,154.8 93.53,154.8 93.61,154.89 96.44,154.89 96.55,155 96.55,155.33 96.67,155.45 96.97,155.45 97.13,155.29 97.13,155 97.24,154.89 98.12,154.89 98.96,154.04 98.96,153.79 99.24,153.51 99.96,153.51 100.54,152.92 v2(100.77,152.92) 100.88,153.03 101.16,153.03 101.36,153.23 101.36,153.23 101.45,153.31 101.8,153.31 103.3,154.81 103.8,154.81 103.91,154.93 103.91,155.23 104.03,155.35 104.37,155.35 104.48,155.23 104.48,154.93 104.6,154.81 107.54,154.81 107.67,154.94 107.94,154.94 108.11,155.12 108.51,155.12 108.69,154.94 109.22,154.94 110.74,153.42 111.51,153.42 112.01,152.92 v2(112.2,152.92) 112.38,152.92 112.97,153.51 112.97,153.51 113.19,153.72 113.19,153.73 113.92,154.46 113.95,154.46 114.05,154.56 116.37,154.56 116.48,154.67 116.48,154.79 116.6,154.9 116.94,154.9 117.05,154.79 117.05,154.67 117.17,154.56 117.51,154.56 117.62,154.67 117.62,154.7 117.74,154.81 118.08,154.81 118.2,154.7 118.2,154.67 118.31,154.56 118.84,154.56 119.22,154.94 120.42,154.94 121.05,154.3 122.43,154.3 122.7,154.03 122.7,153.68 123.46,152.92 v2(123.63,152.92)
  ART05 w0.165: v2(126.08,156.34) 126.08,154.83 124.82,153.56 124.82,153.56 124.59,153.33 124.27,153.33 123.86,152.92 v2(123.63,152.92)
DDR4_COMP_A3: length 140.5
  TOP w0.109: U7.N7 v2(75.51,151.32) ; U3.N7 v2(86.94,151.32) ; U5.N7 v2(109.8,151.32) ; U6.N7 v2(121.23,151.32) ; U4.N7 v2(97.58,150.53)
  TOP w0.175: R1035.1 v2(127.99,152.78)
  ART05 w0.114: v2(121.23,151.32) 120.83,151.71 119.17,151.71 119.06,151.83 119.06,151.9 118.94,152.02 118.5,152.02 118.39,151.9 118.39,151.73 118.27,151.61 118,151.61 117.89,151.73 117.89,151.9 117.77,152.02 117.46,152.02 117.32,151.88 117.32,151.73 117.2,151.61 116.86,151.61 116.75,151.73 116.75,151.9 116.63,152.02 116.31,152.02 116.17,151.88 116.17,151.75 116.06,151.64 115.72,151.64 115.64,151.71 113.49,151.71 113.15,151.38 112.82,151.38 112.36,150.91 111.44,150.91 111.33,150.8 110.74,150.8 110.22,151.32 v2(109.8,151.32) 109.39,151.73 107.81,151.73 106.97,150.89 104.45,150.89 104.41,150.93 102.17,150.93 101.97,151.13 101.97,151.52 101.77,151.71 101.43,151.71 100.95,151.23 100.33,151.23 99.82,150.72 99.18,150.72 98.98,150.93 97.97,150.93 v2(97.58,150.53) ; v2(75.51,151.32) 76.06,151.32 76.32,151.58 76.99,151.58 77.51,151.06 77.93,151.06 78.25,151.39 78.25,151.92 78.46,152.12 78.94,152.12 79.31,151.75 79.92,151.75 80.09,151.92 81.13,151.92 81.24,152.03 81.24,152.21 81.43,152.4 82.92,152.4 83.08,152.23 83.08,151.91 83.22,151.77 83.46,151.77 83.68,151.99 84.02,151.99 84.24,151.77 84.82,151.77 84.99,151.94 85.39,151.94 85.6,151.73 86.27,151.73 86.67,151.32 v2(86.94,151.32)
  ART05 w0.165: v2(98.34,113.1) 98.19,113.24 98.19,113.51 97.63,114.07 97.26,114.07 96.79,113.6 96.43,113.6 95.91,113.08 95.53,113.08 95.05,112.6 94.87,112.6 arc(94.62,112.67) 94.44,112.85 94.44,112.85 arc(94.25,113.03) 94.01,113.1 93.9,113.1 93.32,112.52 93.06,112.52 92.56,113.03 92.17,113.03 91.67,113.54 91.16,113.54 90.78,113.16 90.35,113.16 89.96,113.54 89.43,113.54 89.05,113.16 88.59,113.16 88.12,113.63 87.77,113.63 87.27,114.12 86.92,114.12 86.41,114.63 86,114.63 85.47,115.16 85.06,115.16 83.67,116.56 83.67,118.19 83.33,118.52 83.09,118.52 82.29,117.72 82.05,117.72 81.85,117.92 81.85,118.16 82.65,118.96 82.65,119.2 82.45,119.4 82.21,119.4 81.34,118.53 81.11,118.53 80.9,118.74 80.9,118.97 81.77,119.84 81.77,120.08 81.57,120.28 81.33,120.28 80.6,119.55 80.37,119.55 80.16,119.76 80.16,119.99 80.89,120.72 80.89,120.96 80.69,121.16 80.45,121.16 79.72,120.43 79.49,120.43 79.28,120.64 79.28,120.87 80.01,121.6 80.01,121.84 79.06,122.79 78.38,122.79 76.1,125.07 75.25,125.07 69.76,130.57 69.76,147.95 72.72,150.91 74.85,150.91 75.26,151.32 v2(75.51,151.32)
  ART07 w0.109: v2(86.94,151.32) 87.51,151.32 87.79,151.6
  ART07 w0.114: v2(97.58,150.53) 97.41,150.53 97,150.11 95.83,150.11 95.76,150.19 95.59,150.19 95.22,149.82 95.06,149.82 94.82,150.06 94.82,150.22 95.19,150.59 95.19,150.76 95.02,150.93 94.44,150.93 94.32,151.04 94.32,151.32 94.21,151.43 93.87,151.43 93.75,151.32 93.75,151.04 93.64,150.93 93.16,150.93 93.04,151.04 93.04,151.08 92.93,151.19 92.58,151.19 92.33,150.94 90.74,150.94 90.59,151.09 90.59,151.42 90.34,151.67 90.27,151.67 90.27,151.67 89.93,151.67 89.71,151.46 88.58,151.46 88.4,151.64 87.83,151.64 87.79,151.6
  ART07 w0.165: v2(127.99,152.78) 126.72,152.78 126.45,152.51 125.44,152.51 125.42,152.54 125.1,152.54 125.07,152.51 123.47,152.51 123.46,152.5 123.37,152.5 122.63,151.76 122.07,151.76 121.63,151.32 v2(121.23,151.32)
DDR4_COMP_A4: length 135.7
  TOP w0.109: U4.N3 101.54,151.29 v2(101.56,151.29) ; v2(90.12,151.31) 90.12,151.3 U3.N3 ; U7.N3 v2(77.78,151.44) ; U5.N3 v2(112.2,151.32) ; U6.N3 v2(124.42,151.32)
  ART03 w0.114: v2(90.12,151.31) 90.13,151.31 90.53,151.71 91.11,151.71 91.36,151.97 91.36,152.35 91.54,152.53 91.97,152.53 92.3,152.2 92.54,152.2 92.66,152.31 92.66,152.39 92.77,152.5 93.11,152.5 93.23,152.39 93.23,152.31 93.34,152.2 93.69,152.2 93.8,152.31 93.8,152.41 93.91,152.53 94.26,152.53 94.37,152.41 94.37,152.31 94.49,152.2 95.3,152.2 95.63,152.53 98.88,152.53 99.41,151.99 100.1,151.99 100.43,151.66 101.19,151.66 v2(101.56,151.29) 101.98,151.71 102.49,151.71 102.77,151.99 102.77,152.08 102.77,152.09 102.77,152.27 103.02,152.53 103.48,152.53 103.65,152.35 103.9,152.35 104.01,152.46 104.01,152.84 104.12,152.96 104.47,152.96 104.58,152.84 104.58,152.46 104.7,152.35 105.04,152.35 105.15,152.46 105.15,152.84 105.27,152.96 105.61,152.96 105.72,152.84 105.72,152.46 105.84,152.35 106.68,152.35 106.86,152.53 109.36,152.53 109.56,152.73 109.95,152.73 110.16,152.53 110.34,152.53 111.54,151.32 v2(112.2,151.32) 112.62,151.74 115.16,151.74 115.66,152.23 118.78,152.23 119.3,151.71 121.41,151.71 122.22,150.9 122.92,150.9 123.34,151.32 v2(124.42,151.32)
  ART05 w0.165: v2(127.1,152.34) 126.86,152.34 126.23,151.71 125.87,151.71 125.87,151.71 125.84,151.71 125.44,151.32 v2(124.42,151.32) ; v2(77.78,151.44) 77.31,151.92 75.95,151.92 75.76,151.73 75.26,151.73 75.1,151.89 75.1,152.28 74.85,152.53 72.95,152.53 72.36,151.94 72.36,151.76 68.44,147.84 68.44,130.14 74.39,124.18 74.39,123.72 75.33,122.79 75.99,122.79 77.28,121.5 77.28,119.87 77.82,119.33 78.76,119.33 84.99,113.11 85.54,113.11 86.1,112.55 86.48,112.55 86.92,112.11 87.3,112.11 87.81,111.61 88.16,111.61 88.62,111.15 89.02,111.15 89.41,111.54 89.91,111.54 90.28,111.18 90.74,111.18 91.12,111.56 91.59,111.56 92.04,111.11 92.43,111.11 92.98,111.66 96.55,111.66 98.37,112.42 98.78,112.82 98.78,114.32 98.5,114.6 v2(97.47,114.6)
  ART07 w0.114: v2(77.78,151.44) 77.78,151.5 77.9,151.61 78.27,151.61 78.48,151.83 78.85,151.83 79.07,151.61 79.51,151.61 79.68,151.78 80.69,151.78 80.74,151.84 82.12,151.84 82.54,151.41 83.32,151.41 83.86,150.88 84.39,150.88 84.4,150.88 84.69,150.88 84.69,150.88 85.17,150.88 85.25,150.96 85.49,150.96 85.49,150.96 85.99,150.96 86.02,150.93 87.87,150.93 87.96,150.84 88.26,150.84 88.42,151 89.81,151 v2(90.12,151.31)
  BOTTOM w0.175: v2(127.1,152.34) 128.24,152.34 R1047.1
DDR4_COMP_A5: length 139
  TOP w0.109: U6.P8 v2(120.43,151.32) ; U4.P8 v2(97.57,151.32) ; U7.P8 v2(74.71,151.32) ; U5.P8 v2(109,151.32) ; U3.P8 v2(86.14,151.32)
  ART05 w0.165: v2(97.47,113.6) 97.47,113.22 96.24,111.99 92.84,111.99 92.66,112.16 92.04,112.16 91.56,112.65 91.27,112.65 90.79,112.17 90.29,112.17 89.91,112.55 89.48,112.55 89.05,112.11 88.59,112.11 88.08,112.62 87.72,112.62 87.23,113.11 86.92,113.11 86.48,113.55 86.1,113.55 85.5,114.15 84.68,114.15 79.45,119.38 79.45,119.86 78.81,120.5 78.1,120.5 77.85,120.75 77.85,121.95 75.99,123.8 75.56,123.8 69.39,129.97 69.39,130.65 69.23,130.81 69.07,130.81 68.91,130.98 68.91,131.27 69.07,131.43 69.23,131.43 69.39,131.6 69.39,131.89 69.23,132.06 69.07,132.06 68.91,132.22 68.91,132.51 69.07,132.68 69.23,132.68 69.39,132.84 69.39,133.14 69.23,133.3 69.07,133.3 68.91,133.47 68.91,133.76 69.07,133.92 69.23,133.92 69.39,134.09 69.39,134.38 69.23,134.55 69.07,134.55 68.91,134.71 68.91,135 69.07,135.17 69.23,135.17 69.39,135.33 69.39,135.62 69.23,135.79 69.07,135.79 68.91,135.96 68.91,136.25 69.07,136.41 69.23,136.41 69.39,136.58 69.39,136.87 69.23,137.03 69.07,137.03 68.91,137.2 68.91,137.49 69.07,137.66 69.23,137.66 69.39,137.82 69.39,138.11 69.23,138.28 69.07,138.28 68.91,138.44 68.91,138.74 69.07,138.9 69.23,138.9 69.39,139.07 69.39,139.36 69.23,139.52 69.07,139.52 68.91,139.69 68.91,139.98 69.07,140.15 69.23,140.15 69.39,140.31 69.39,140.6 69.23,140.77 69.07,140.77 68.91,140.93 68.91,141.23 69.07,141.39 69.23,141.39 69.39,141.56 69.39,141.85 69.23,142.01 69.07,142.01 68.91,142.18 68.91,142.47 69.07,142.64 69.23,142.64 69.39,142.8 69.39,143.09 69.23,143.26 69.07,143.26 68.91,143.42 68.91,143.71 69.07,143.88 69.23,143.88 69.39,144.05 69.39,144.34 69.23,144.5 69.07,144.5 68.91,144.67 68.91,144.96 69.07,145.12 69.23,145.12 69.39,145.29 69.39,145.58 69.23,145.75 69.07,145.75 68.91,145.91 68.91,146.2 69.07,146.37 69.23,146.37 69.39,146.53 69.39,146.83 69.23,146.99 69.07,146.99 68.91,147.16 68.91,147.45 69.07,147.61 69.23,147.61 69.39,147.78 69.39,148.1 72.72,151.43 72.72,151.55 72.89,151.73 74.05,151.73 74.46,151.32 v2(74.71,151.32)
  ART07 w0.114: v2(120.43,151.32) 120.33,151.32 119.97,150.96 119.78,150.96 119.78,150.96 119.48,150.96 119.48,150.96 119.33,150.96 119.11,151.19 119.1,151.19 119.09,151.2 118.5,151.2 118.25,151.45 117.97,151.45 116.85,152.56 115.88,152.56 115.77,152.67 115.77,152.85 115.65,152.96 115.31,152.96 115.2,152.85 115.2,152.67 115.06,152.54 113.36,152.54 113.24,152.43 113.24,152.36 113.13,152.25 112.79,152.25 112.67,152.36 112.67,152.45 112.56,152.56 112.35,152.56 112.35,152.56 112.05,152.56 112.05,152.56 111.83,152.56 111.61,152.78 111.02,152.78 109.97,151.73 109.64,151.73 109.32,151.41 109.08,151.41 v2(109,151.32) 108.79,151.32 108.37,150.9 108.04,150.9 107.63,151.31 107.17,151.31 106.75,150.89 106.39,150.89 104.75,152.53 104.33,152.53 104.21,152.64 104.21,152.82 104.1,152.93 103.76,152.93 103.64,152.82 103.64,152.64 103.53,152.53 101.93,152.53 101.81,152.41 101.81,152.31 101.7,152.2 101.36,152.2 101.24,152.31 101.24,152.41 101.13,152.53 100.43,152.53 99.72,151.81 99.06,151.81 98.96,151.71 98.22,151.71 97.83,151.32 v2(97.57,151.32) 97.29,151.32 96.87,150.9 95.7,150.9 94.84,151.76 94.07,151.76 93.95,151.87 93.95,152.02 93.84,152.13 93.5,152.13 93.38,152.02 93.38,151.62 93.27,151.51 92.93,151.51 92.81,151.62 92.81,152.02 92.7,152.13 92.35,152.13 92.24,152.02 92.24,151.87 92.13,151.76 91.89,151.76 91.89,151.76 90.79,151.76 90.79,151.76 90.71,151.76 90.42,152.04 89.78,152.04 89.5,151.77 89.08,151.77 88.85,151.99 87.58,151.99 87.38,151.8 86.98,151.8 86.97,151.79 86.76,151.79 86.29,151.32 v2(86.14,151.32) 86.01,151.45 85.76,151.45 85.53,151.68 85.49,151.68 85.49,151.68 85.19,151.68 85.19,151.68 85.11,151.68 85.02,151.59 85.01,151.59 84.92,151.49 84.15,151.49 84.09,151.56 84.07,151.56 83.58,152.05 83.3,152.05 82.81,152.54 81.67,152.54 80.9,153.31 77.21,153.31 76.75,152.85 76.59,152.85 76.47,152.97 76.29,152.97 76.07,152.75 76.07,152.57 76.19,152.45 76.19,152.29 76.1,152.2 76.1,151.84 75.97,151.71 75.11,151.71 75,151.61 75,151.61 v2(74.71,151.32)
  ART07 w0.165: v2(120.43,151.32) 121.07,150.93 121.31,150.93 122.28,150.93 122.29,150.92 122.61,150.92 122.65,150.96 122.97,151.1 123.11,151.19 124.18,151.66 124.22,151.66 124.26,151.7 124.58,151.7 124.62,151.66 125.82,151.66 125.87,151.71 126.19,151.71 126.24,151.66 126.25,151.66 126.35,151.61 v2(126.85,151.34)
  BOTTOM w0.175: R1034.1 128.24,151.45 127.86,151.45 v2(126.85,151.34)
DDR4_COMP_A6: length 137.1
  TOP w0.109: U5.P2 v2(113.8,152.12) ; U6.P2 v2(125.26,152.15) ; U3.P2 v2(90.94,152.12) ; U4.P2 v2(102.37,152.12) ; U7.P2 v2(79.51,152.12)
  TOP w0.175: R1052.1 v2(127.86,156.34)
  ART03 w0.114: v2(125.26,152.15) 124.81,152.59 124.81,153.14 124.63,153.31 117.47,153.31 117.33,153.46 117.33,154.11 117.22,154.23 116.87,154.23 116.76,154.11 116.76,153.4 116.65,153.29 115.9,153.29 115.11,152.5 114.18,152.5 v2(113.8,152.12) 113.42,152.5 111.86,152.5 111.05,153.31 105.92,153.31 105.81,153.43 105.81,153.63 105.7,153.75 105.35,153.75 105.24,153.63 105.24,153.43 105.12,153.31 104.78,153.31 104.67,153.43 104.67,153.66 104.55,153.77 104.21,153.77 104.1,153.66 104.1,153.43 103.98,153.31 102.92,153.31 102.74,153.14 102.74,152.78 102.46,152.5 102.46,152.21 v2(102.37,152.12) 101.5,152.12 101.09,152.53 100.2,152.53 99.39,153.34 94.33,153.34 94.21,153.45 94.21,153.66 94.1,153.77 93.75,153.77 93.64,153.66 93.64,153.45 93.53,153.34 93.18,153.34 93.07,153.45 93.07,153.66 92.95,153.77 92.61,153.77 92.5,153.66 92.5,153.45 92.38,153.34 91.56,153.34 91.34,153.12 91.34,152.79 90.94,152.38 v2(90.94,152.12)
  ART03 w0.165: v2(79.51,152.12) 80.09,151.54 80.67,151.54 81.28,150.93 81.28,149.53 80.89,149.14 80.89,141.54 84.12,138.3 84.36,138.3 84.71,138.65 84.94,138.65 85.15,138.45 85.15,138.21 84.8,137.86 84.8,137.63 85,137.42 85.24,137.42 85.59,137.77 85.82,137.77 86.03,137.57 86.03,137.33 85.68,136.98 85.68,136.75 85.88,136.54 86.12,136.54 86.47,136.89 86.7,136.89 86.91,136.69 86.91,136.45 86.56,136.1 86.56,135.87 86.76,135.66 87,135.66 87.35,136.01 87.58,136.01 87.79,135.81 87.79,135.57 87.44,135.22 87.44,134.99 87.64,134.78 87.88,134.78 88.23,135.13 88.46,135.13 88.67,134.93 88.67,134.69 88.32,134.34 88.32,134.11 88.52,133.9 88.76,133.9 89.11,134.25 89.34,134.25 89.55,134.05 89.55,133.81 89.2,133.46 89.2,133.23 89.4,133.02 89.64,133.02 89.99,133.37 90.22,133.37 90.43,133.17 90.43,132.93 90.08,132.58 90.08,132.35 90.28,132.14 90.52,132.14 90.87,132.49 91.1,132.49 91.31,132.29 91.31,132.05 90.96,131.7 90.96,131.47 91.16,131.26 91.4,131.26 91.75,131.61 91.98,131.61 92.19,131.41 92.19,131.17 91.84,130.82 91.84,130.59 92.04,130.38 92.28,130.38 92.63,130.73 92.86,130.73 93.07,130.53 93.07,130.29 92.72,129.94 92.72,129.71 92.92,129.5 93.16,129.5 93.51,129.85 93.74,129.85 93.95,129.64 93.95,129.41 93.6,129.06 93.6,128.83 93.8,128.62 94.04,128.62 94.39,128.97 94.62,128.97 94.83,128.76 94.83,128.53 94.48,128.18 94.48,127.95 94.68,127.74 94.92,127.74 95.27,128.09 95.5,128.09 95.71,127.88 95.71,127.65 95.36,127.3 95.36,127.07 95.86,126.56 95.86,126.33 94.88,125.34 94.88,125.11 95.08,124.9 95.32,124.9 96.3,125.89 96.54,125.89 96.74,125.68 96.74,125.45 95.76,124.46 95.76,124.23 95.96,124.02 96.2,124.02 97.18,125.01 97.42,125.01 97.85,124.57 97.85,124.16 97.69,123.99 96.91,123.99 96.75,123.83 96.75,123.54 96.91,123.37 97.69,123.37 97.89,123.17 97.89,114.35 97.64,114.1 v2(96.6,114.1) ; v2(127.86,156.34) 127.55,156.03 127.55,155.87 125.62,153.94 125.62,152.51 v2(125.26,152.15)
  ART05 w0.114: v2(90.94,152.12) 90.53,152.12 90.42,152.02 89.83,152.02 89.55,151.74 88.82,151.74 88.59,151.97 88.16,151.97 87.65,152.48 87.37,152.48 87.21,152.64 87.13,152.64 86.76,153.02 86.76,153.1 86.51,153.34 84.42,153.34 84.24,153.16 84.06,153.16 83.94,153.28 83.94,153.52 83.83,153.64 83.55,153.64 83.44,153.52 83.44,153.5 83.32,153.39 83.07,153.39 82.95,153.5 82.95,153.75 82.84,153.86 82.64,153.86 82.24,153.47 81.1,153.47 80.72,153.09 80.72,152.78 80.44,152.5 80.14,152.5 79.75,152.12 v2(79.51,152.12)
DDR4_COMP_A7: length 135.1
  TOP w0.109: U4.R8 v2(96.77,152.92) ; U3.R8 85.32,152.94 v2(85.32,152.96) ; U6.R8 v2(119.63,152.92) ; U5.R8 v2(108.2,152.92) ; U7.R8 v2(73.91,152.92)
  TOP w0.175: R1051.1 v2(120.75,156.34)
  ART03 w0.165: v2(73.91,152.92) 74.32,153.33 74.32,153.9 74.09,154.13 72.87,154.13 72.35,153.61 71.87,153.61 71.85,153.59 71.84,153.59 71.37,153.11 71.37,152.34 68.41,149.39 68.41,135 68.43,134.99 68.43,130.31 74.8,123.94 74.8,123.62 75.59,122.83 75.59,122.83 75.63,122.79 76.22,122.79 77.19,121.81 78.95,121.81 79.33,121.42 79.57,121.42 80.07,121.93 80.3,121.93 80.51,121.72 80.51,121.49 80.01,120.98 80.01,120.75 80.21,120.54 80.45,120.54 80.95,121.05 81.18,121.05 81.39,120.84 81.39,120.61 80.89,120.1 80.89,119.87 81.09,119.66 81.33,119.66 81.83,120.17 82.06,120.17 82.27,119.96 82.27,119.73 81.77,119.22 81.77,118.49 85.12,115.14 85.59,115.14 86.04,114.69 86.07,114.69 86.21,114.55 86.46,114.55 86.84,114.17 87.22,114.17 87.73,113.66 88.24,113.66 88.62,114.05 89,114.05 89.38,113.66 89.96,113.66 90.35,114.05 90.65,114.05 91.16,114.55 91.67,114.55 92.17,114.05 92.43,114.05 92.94,113.54 93.32,113.54 93.83,114.05 94.23,114.05 94.57,114.39 arc(94.87,114.56) 95.17,114.39 95.4,114.16 95.72,114.01 95.91,114.01 96.15,113.77 96.15,113.7 96.21,113.6 arc(96.4,113.34) v2(96.6,113.1)
  ART07 w0.114: v2(119.63,152.92) 119.53,153.02 119.53,153.29 119.2,153.63 119.2,153.95 118.69,154.46 118.23,154.81 117.75,154.81 117.39,155.03 117.11,154.96 116.77,155.17 116.7,155.44 116.43,155.6 111.4,155.6 109.12,153.31 108.59,153.31 v2(108.2,152.92) 107.76,153.35 107.17,153.35 106.96,153.57 106.96,154.25 106.75,154.46 105.22,154.46 104.39,155.29 99.69,155.29 99.43,155.03 99.27,155.03 99.23,155.07 99.06,155.07 98.82,154.83 98.82,154.67 98.86,154.63 98.86,154.47 97.74,153.34 97.28,153.34 97.17,153.23 97.16,153.23 96.86,152.92 v2(96.77,152.92) 96.64,153.04 96.64,153.29 96.35,153.58 96.35,153.86 95.75,154.46 94.3,154.46 93.8,154.96 91.34,154.96 91.22,154.85 91.22,154.8 91.11,154.69 90.77,154.69 90.65,154.8 90.65,154.85 90.54,154.96 87.37,154.96 86.76,154.35 86.76,153.77 86.31,153.31 85.85,153.31 85.5,152.96 v2(85.32,152.96) 85.32,153.16 84.94,153.54 84.94,153.92 84.4,154.46 82.78,154.46 80.54,155.61 76.55,155.61 74.66,154.29 74.31,153.94 74.31,153.32 v2(73.91,152.92)
  ART07 w0.165: v2(119.63,152.92) 120.02,153.31 120.02,155.61 v2(120.75,156.34)
DDR4_COMP_A8: length 135.4
  TOP w0.109: U5.R2 v2(113,152.92) ; U4.R2 v2(101.57,152.92) ; U3.R2 v2(90.14,152.92) ; U7.R2 v2(78.71,152.92) ; U6.R2 v2(124.43,152.92)
  TOP w0.175: R1050.1 v2(126.97,156.34)
  ART03 w0.165: v2(78.71,152.92) 78.71,152.3 79.73,151.28 79.8,151.28 80.34,150.75 80.34,149.88 79.91,149.45 79.91,140.56 80.16,140.31 81.6,140.31 88.47,133.44 88.47,133.2 87.75,132.49 87.75,132.26 87.96,132.05 88.19,132.05 88.91,132.76 89.14,132.76 89.35,132.56 89.35,132.32 88.63,131.61 88.63,131.38 88.84,131.17 89.07,131.17 89.79,131.88 90.02,131.88 90.23,131.68 90.23,131.44 89.51,130.73 89.51,130.5 89.72,130.29 89.95,130.29 90.67,131 90.9,131 91.27,130.64 91.27,130.4 89.73,128.87 89.73,128.63 89.93,128.43 90.17,128.43 91.71,129.96 91.94,129.96 92.15,129.76 92.15,129.52 90.63,128.01 90.63,127.78 90.84,127.57 91.07,127.57 91.34,127.84 91.57,127.84 92.25,127.16 92.49,127.16 92.69,127.37 92.69,127.6 92.01,128.28 92.01,128.51 92.59,129.08 92.82,129.08 93.13,128.77 93.13,128.54 93.05,128.46 93.05,128.23 93.26,128.02 93.49,128.02 93.57,128.1 93.8,128.1 94.22,127.69 94.22,127.45 93.48,126.72 93.48,126.48 93.68,126.28 93.92,126.28 94.66,127.01 94.89,127.01 95.11,126.8 95.11,126.56 93.89,125.35 93.89,125.11 94.1,124.91 94.5,124.91 97.04,122.36 97.04,114.95 96.69,114.6 v2(95.74,114.6)
  ART05 w0.114: v2(78.71,152.92) 79.1,153.31 79.69,153.31 79.92,153.54 79.92,154.15 80.23,154.46 82.24,154.46 82.67,154.89 84.68,154.89 84.81,155.02 85.8,155.02 86.02,154.8 86.3,154.8 86.58,154.51 86.58,154.23 87.7,153.11 88.63,153.11 89.18,152.57 89.48,152.57 89.61,152.69 89.9,152.69 90.07,152.87 90.09,152.87 v2(90.14,152.92) 90.33,152.92 91.88,154.46 92.18,154.46 92.29,154.35 92.29,153.94 92.41,153.82 92.75,153.82 92.86,153.94 92.86,154.35 92.98,154.46 95.2,154.46 95.5,154.16 96.62,154.16 96.62,154.16 98.13,154.16 99.18,153.11 99.82,153.11 100.39,152.54 100.95,152.54 101.14,152.72 101.29,152.72 101.49,152.92 v2(101.57,152.92) 101.65,153.01 101.93,153.01 102.28,153.36 103.32,153.36 103.32,153.36 103.39,153.36 103.68,153.66 103.68,153.89 103.59,153.98 103.59,154.14 103.83,154.38 104,154.38 104.09,154.29 104.25,154.29 104.42,154.46 105.2,154.46 105.31,154.35 105.31,154.24 105.42,154.13 105.77,154.13 105.88,154.24 105.88,154.35 106,154.46 106.91,154.46 107.22,154.15 108.53,154.15 108.66,154.27 109.11,154.27 109.23,154.15 109.52,154.15 110.56,153.11 111.38,153.11 111.97,152.53 112.6,152.53 v2(113,152.92) 113,153.1 114.05,154.15 115.82,154.15 115.93,154.04 115.93,153.81 116.04,153.69 116.39,153.69 116.5,153.81 116.5,154.04 116.62,154.15 116.94,154.15 117.47,153.62 118.11,153.62 118.64,154.15 120.63,154.15 121.56,153.22 122.73,153.22 123.42,152.53 124,152.53 124.31,152.83 124.34,152.83 v2(124.43,152.92)
  ART05 w0.165: v2(126.97,156.34) 126.59,155.96 126.59,153.67 126.24,153.31 125.26,153.31 124.87,152.92 v2(124.43,152.92)
DDR4_COMP_A9: length 134.2
  TOP w0.109: U3.R7 v2(86.14,152.92) ; U7.R7 v2(74.71,152.92) ; U4.R7 v2(97.57,152.92) ; U6.R7 v2(120.43,152.92) ; U5.R7 v2(109,152.92)
  TOP w0.175: R1038.1 v2(121.64,156.34)
  ART03 w0.165: v2(74.71,152.92) 75.16,153.37 75.16,154.02 74.27,154.91 73.71,154.91 73.3,154.51 72.01,154.51 71.73,154.23 71.73,154 71,153.27 71,152.5 68.04,149.54 68.04,130.17 68.06,130.16 71.68,126.54 71.68,124.81 72.3,124.19 72.54,124.19 72.74,124.38 72.97,124.38 73.18,124.18 73.18,123.94 72.98,123.75 72.98,123.51 73.18,123.31 73.42,123.31 73.62,123.5 73.85,123.5 74.06,123.3 74.06,123.06 73.86,122.87 73.86,122.63 74.9,121.59 76.58,121.59 77.66,120.5 78.79,120.5 78.79,120.5 79.12,120.5 79.58,120.04 79.58,119.62 85.1,114.1 85.52,114.1 85.95,113.66 86.33,113.66 86.84,113.16 87.17,113.16 87.68,112.65 88.11,112.65 88.62,113.16 89,113.16 89.51,112.65 89.89,112.65 90.27,113.03 90.65,113.03 91.16,113.54 91.61,113.54 92.1,113.04 92.41,113.04 92.44,113.01 92.45,113.01 92.81,112.65 93.32,112.65 93.83,113.16 94.21,113.16 94.59,113.54 95.68,113.54 v2(95.74,113.6)
  ART07 w0.114: v2(120.43,152.92) 120.19,152.92 119.83,152.56 119.78,152.56 119.78,152.56 119.48,152.56 119.48,152.56 119.45,152.56 119.37,152.6 119.23,152.75 119.23,153.16 119.06,153.33 118.64,153.33 118.29,153.69 118.29,154.3 118.13,154.46 115.76,154.46 114.95,155.28 112.43,155.28 110.55,154.29 109.18,152.92 v2(109,152.92) 108.74,152.92 108.34,152.53 107.08,152.53 106.96,152.65 106.96,153.03 106.75,153.24 105.71,153.24 103.99,154.96 100.89,154.96 100.77,154.85 100.77,154.77 100.66,154.66 100.31,154.66 100.2,154.77 100.2,154.85 100.09,154.96 99.84,154.96 97.8,152.92 v2(97.57,152.92) 97.29,152.92 96.89,152.51 96.57,152.51 96.34,152.75 96.34,153.11 96.16,153.29 95.81,153.29 95.43,153.67 95.23,153.67 95.2,153.64 94.86,153.64 94.83,153.67 94.61,153.67 93.7,154.58 92.89,154.58 92.78,154.47 92.78,154.39 92.67,154.28 92.32,154.28 92.21,154.39 92.21,154.47 92.09,154.58 91.64,154.58 91.21,154.15 88.9,154.15 88.57,154.48 87.68,154.48 87.27,154.08 87.27,153.82 86.37,152.92 v2(86.14,152.92) 85.91,152.92 85.6,152.6 85.47,152.6 85.47,152.6 85.17,152.6 85.17,152.6 85.12,152.6 84.91,152.81 84.91,153.06 84.69,153.28 84.68,153.28 84.61,153.35 84.39,153.35 84.39,153.36 84.3,153.36 83.98,153.68 83.81,153.68 83.77,153.64 83.43,153.64 83.35,153.72 82.01,153.72 80.44,155.29 76.8,155.29 75.13,153.63 75.13,153.34 v2(74.71,152.92)
  ART07 w0.165: v2(121.64,156.34) 120.88,155.57 120.88,153.14 120.66,152.92 v2(120.43,152.92)
DDR4_COMP_A10: length 134.3
  TOP w0.109: U7.M3 v2(77.91,149.72) ; U5.M3 v2(112.2,149.72) ; U3.M3 v2(89.34,149.72) ; U4.M3 v2(100.77,149.72) ; U6.M3 v2(123.63,149.72)
  ART05 w0.114: v2(123.63,149.72) 123.22,149.72 123.1,149.84 123.1,150.02 122.99,150.14 122.65,150.14 122.53,150.02 122.53,149.84 122.42,149.72 122.07,149.72 121.95,149.84 121.95,150.02 121.84,150.14 121.5,150.14 121.38,150.02 121.38,149.84 121.27,149.72 121.04,149.72 120.64,150.13 118.48,150.13 118.09,150.52 117.68,150.52 117.45,150.29 117.14,150.29 117.03,150.41 117.03,150.52 116.91,150.63 116.57,150.63 116.45,150.52 116.45,150.41 116.34,150.29 116.13,150.29 116.06,150.22 116.05,150.22 115.89,150.06 115.66,150.06 115.54,150.18 115.54,150.3 115.43,150.42 115.12,150.42 115.01,150.3 115.01,150.23 114.89,150.11 112.78,150.11 112.49,149.83 112.49,149.83 112.38,149.72 v2(112.2,149.72) 109.72,149.72 109.29,149.3 106.75,149.3 106.64,149.41 106.64,149.8 106.53,149.91 106.18,149.91 106.07,149.8 106.07,149.44 105.93,149.3 105.61,149.3 105.5,149.41 105.5,149.8 105.38,149.91 105.04,149.91 104.92,149.8 104.92,149.44 104.79,149.3 104.54,149.3 103.73,150.11 101.39,150.11 101,149.72 v2(100.77,149.72) 100.4,149.35 95.68,149.35 94.95,150.08 94.2,150.08 94.08,150.19 94.08,150.47 93.97,150.58 93.63,150.58 93.51,150.47 93.51,150.19 93.4,150.08 93.06,150.08 92.94,150.19 92.94,150.47 92.83,150.58 92.48,150.58 92.37,150.47 92.37,150.24 92.26,150.13 91.38,150.13 91.33,150.08 90.76,150.08 90.54,149.86 90.54,149.57 90.52,149.5 90.35,149.33 89.99,149.33 89.59,149.72 v2(89.34,149.72) 88.75,149.13 86.89,149.13 86.28,148.53 85.69,148.53 85.57,148.41 84.95,148.41 84.82,148.28 84.27,148.28 84.15,148.41 83.67,148.41 83.11,148.97 82.18,148.97 82.07,148.86 82.07,148.47 81.95,148.36 81.61,148.36 81.49,148.47 81.49,148.86 81.38,148.97 80.46,148.97 80.01,149.43 80.01,149.66 79.65,150.02 79.38,150.02 79.3,150.1 78.29,150.1 v2(77.91,149.72)
  ART05 w0.165: v2(94.87,114.1) 94.87,114.18 arc(94.87,114.23) 94.85,114.27 94.48,114.88 94.32,115.04 93.75,115.04 93.39,114.68 92.91,114.68 92.45,115.14 92.02,115.14 91.56,115.59 91.23,115.59 90.78,115.14 90.32,115.14 89.89,115.57 89.48,115.57 89.08,115.16 88.57,115.16 88.15,115.58 87.77,115.58 87.27,116.08 86.94,116.08 86.46,116.56 86.03,116.56 85.52,117.07 85.21,117.07 84.5,117.78 84.5,118.93 81.98,121.45 81.98,122.01 81.41,122.58 81.41,123.64 79.94,125.11 77.52,125.11 76.81,125.83 76.81,126.06 77.29,126.54 77.29,126.77 77.08,126.98 76.85,126.98 76.37,126.5 76.14,126.5 75.93,126.71 75.93,126.94 76.41,127.42 76.41,127.65 76.2,127.86 75.97,127.86 75.49,127.38 75.26,127.38 75.05,127.59 75.05,127.82 75.53,128.3 75.53,128.53 75.32,128.74 75.09,128.74 74.61,128.26 74.38,128.26 74.17,128.47 74.17,128.7 74.65,129.18 74.65,129.41 74.44,129.62 74.21,129.62 73.73,129.14 73.5,129.14 73.29,129.35 73.29,129.58 73.77,130.06 73.77,130.29 73.56,130.5 73.33,130.5 72.85,130.02 72.62,130.02 72.41,130.23 72.41,130.46 72.89,130.94 72.89,131.17 72.68,131.38 72.45,131.38 71.97,130.9 71.74,130.9 71.53,131.11 71.53,131.34 72.01,131.82 72.01,132.05 71.8,132.26 71.57,132.26 71.09,131.78 70.86,131.78 70.5,132.14 70.5,147.07 72.74,149.31 74.85,149.31 75.13,149.6 75.13,149.78 75.43,150.08 75.78,150.08 75.9,149.96 77.67,149.96 v2(77.91,149.72)
  ART07 w0.165: v2(123.63,149.72) 124.04,149.31 126.19,149.31 126.19,149.31 126.28,149.31 126.79,148.8 v2(127.25,148.8)
  BOTTOM w0.175: R1046.1 128.24,148.78 127.27,148.78 v2(127.25,148.8)
