# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VSENSEP_VCCH: length 226
  ART03 w0.254: v4(149.38,176.17) 150.01,175.54 150.01,174.6 150.52,174.09 162.18,174.09 162.76,174.68 162.76,175.59 v4(163.35,176.17)
  BOTTOM w0.254: R96.2 96.72,91.47 96.11,92.08 95.58,92.08 95.3,92.35 arc(95.12,92.53) 94.87,92.6 94.71,92.6 94.37,92.94 94.37,93.31 94.42,93.35 94.44,93.35 arc(94.51,93.6) 94.44,93.85 arc(94.37,94.1) 94.44,94.35 arc(94.51,94.6) 94.44,94.85 94.44,94.85 arc(94.37,95.1) 94.44,95.35 arc(94.51,95.6) 94.44,95.85 94.44,95.85 arc(94.37,96.1) 94.44,96.35 arc(94.51,96.6) 94.44,96.85 arc(94.37,97.1) 94.44,97.35 arc(94.51,97.6) 94.44,97.85 arc(94.37,98.1) 94.44,98.35 arc(94.51,98.6) 94.44,98.85 arc(94.37,99.1) 94.44,99.35 arc(94.51,99.6) 94.44,99.85 arc(94.37,100.1) 94.44,100.35 arc(94.51,100.6) 94.44,100.85 arc(94.37,101.1) 94.44,101.35 arc(94.51,101.6) 94.44,101.85 arc(94.37,102.1) 94.44,102.35 arc(94.51,102.6) 94.44,102.85 arc(94.37,103.1) 94.44,103.35 arc(94.51,103.6) 94.44,103.85 arc(94.37,104.1) 94.44,104.35 arc(94.51,104.6) 94.44,104.85 arc(94.37,105.1) 94.44,105.35 arc(94.51,105.6) 94.44,105.85 arc(94.37,106.1) 94.44,106.35 arc(94.51,106.6) 94.44,106.85 arc(94.37,107.1) 94.44,107.35 94.44,107.35 arc(94.51,107.6) 94.44,107.85 arc(94.37,108.1) 94.44,108.35 94.44,108.35 arc(94.51,108.6) 94.44,108.85 arc(94.37,109.1) 94.44,109.35 arc(94.51,109.6) 94.44,109.85 arc(94.37,110.1) 94.44,110.35 arc(94.51,110.6) 94.44,110.85 arc(94.37,111.1) 94.44,111.35 94.44,111.35 arc(94.51,111.6) 94.44,111.85 94.44,111.85 arc(94.37,112.1) 94.44,112.35 arc(94.51,112.6) 94.44,112.85 arc(94.37,113.1) 94.44,113.35 arc(94.51,113.6) 94.44,113.85 arc(94.37,114.1) 94.44,114.35 arc(94.51,114.6) 94.44,114.85 arc(94.37,115.1) 94.44,115.35 arc(94.51,115.6) 94.44,115.85 arc(94.37,116.1) 94.44,116.35 arc(94.51,116.6) 94.44,116.85 arc(94.37,117.1) 94.44,117.35 arc(94.51,117.6) 94.44,117.85 arc(94.37,118.1) 94.44,118.35 arc(94.51,118.6) 94.44,118.85 arc(94.37,119.1) 94.44,119.35 arc(94.51,119.6) 94.44,119.85 arc(94.37,120.1) 94.44,120.35 arc(94.51,120.6) 94.44,120.85 arc(94.37,121.1) 94.44,121.35 arc(94.51,121.6) 94.44,121.85 arc(94.37,122.1) 94.44,122.35 94.44,122.35 arc(94.51,122.6) 94.44,122.85 94.44,123.17 93.65,123.95 82.6,123.95 79.45,127.1 70.48,127.1 66.83,123.44 63.96,123.44 62.84,124.56 62.84,141.17 61.9,142.11 61.9,153.02 65.27,156.39 97.24,156.39 97.89,155.73 104.75,155.73 107.74,158.72 128.67,158.72 132.99,163.05 132.99,165.77 135.18,167.95 135.18,175.19 136.75,176.76 141.83,176.76 143.07,177.99 145.02,177.99 C1960.1 146.14,177.97 147.21,177.97 147.8,177.37 147.8,176.54 148.62,175.72 148.97,175.72 149.38,176.12 v4(149.38,176.17) ; v4(163.35,176.17) 163.86,175.67 164.47,175.67 164.8,176 165.53,176 C2101.1
VTT_DDR4_COMP_0.6V: length 9.6
  TOP w0.254: 141.12,145.95 141.48,145.59 U69.3 ; R5388.1 v2(137.81,144.11)
  ART03 w0.254: v2(137.81,144.11) 137.81,148.6 v3(139.95,150.75)
  vias: v3(131.16,154.69) v3(131.16,153.8) v3(131.19,152.37) v3(131.19,151.48) v3(131.19,150.06) v3(131.16,147.95) v3(131.16,146.94) v3(131.16,145.8) v3(131.29,144.27) v3(133.32,155.57) v3(139.95,149.86) v3(140.72,150.75) v3(140.72,149.86) v3(141.48,150.75) v3(141.48,149.86)
VTT_SODIMM_0.6V: length 9.7
  TOP w0.254: 80.49,50.88 U67.3 ; CON1.258 90.57,51.8 90.81,51.56 90.81,50.83 v2(90.84,50.87)
  BOTTOM w0.254: v3(79.1,54.11) 83.12,54.11 v2(84.3,52.93)
  vias: v2(84.3,52.3) v2(84.3,51.66) v2(84.94,52.93) v2(84.94,52.3) v2(84.94,51.66) v2(87.86,50.42) v2(88.49,50.9) v2(88.49,50.01) v2(90.22,50.8) v2(90.84,49.61) v2(90.84,48.51)
ZQSFP_RXN0: length 77.8
  TOP w0.091: J12.18 43.99,87.14 43.09,87.14
  ART05 w0.097: 85.04,105.19 85.05,105.19 85.07,105.17 85.43,105.17 arc(85.69,105.1) 85.89,104.9 arc(86.04,104.75) 86.24,104.7 86.26,104.7 arc(86.54,104.62) 86.74,104.42 86.75,104.4 arc(86.9,104.25) 87.1,104.2 87.12,104.2 arc(87.38,104.13) 87.57,103.94 87.6,103.89 arc(87.74,103.75) 87.94,103.69 87.95,103.69 arc(88.16,103.75) 88.31,103.9 88.31,103.91 arc(88.52,104.12) 88.81,104.19 arc(89.11,104.12) 89.32,103.9 89.33,103.89 arc(89.48,103.75) 89.68,103.69 arc(89.85,103.74) 89.98,103.87 89.99,103.9 arc(90.21,104.11) 90.51,104.19 90.55,104.19 arc(90.8,104.14) 91,103.98 arc(91.01,103.97) 91.01,103.96 91.12,103.93 U1.AU8
  ART05 w0.109: 85.04,105.19 84.86,105.19 arc(84.61,105.14) 84.4,105 83.97,104.57 arc(83.77,104.44) 83.54,104.39 79.6,104.39 arc(78.9,104.53) 78.3,104.93 77.69,105.54 arc(76.85,106.1) 75.87,106.3 73.6,106.3 arc(72.86,106.15) 72.22,105.73 72.01,105.51 arc(71.33,105.06) 70.53,104.9 57.57,104.9 arc(56.31,105.15) 55.24,105.87 54.78,106.33 arc(53.69,107.06) 52.4,107.31 49.38,107.31 arc(48.72,107.18) 48.16,106.81 47.69,106.34 arc(47.11,105.95) 46.44,105.82 41.07,105.82 arc(40.16,105.64) 39.39,105.12 38.77,104.5 arc(38.34,103.87) 38.19,103.12 38.19,96.49 arc(38.24,96.07) 38.36,95.67 arc(38.42,95.57) 38.49,95.48 arc(38.76,95.04) 38.85,94.54 38.85,90.64 arc(38.97,90.07) 39.29,89.59 41.25,87.64 arc(41.48,87.48) 41.76,87.42 42.8,87.42 43.09,87.14
ZQSFP_RXN1: length 51.8
  TOP w0.091: 47.4,87.54 47.4,87.54 J12.21
  ART05 w0.097: 85.05,98.98 85.07,98.98 85.1,99.01 85.35,99.01 arc(85.55,98.95) 85.7,98.8 arc(85.91,98.59) 86.21,98.51 86.21,98.51 arc(86.51,98.58) 86.72,98.8 86.75,98.85 arc(86.87,98.96) 87.03,99.01 87.08,99.01 arc(87.37,99.08) 87.59,99.3 87.62,99.35 arc(87.74,99.47) 87.89,99.51 87.94,99.51 arc(88.24,99.58) 88.46,99.8 88.49,99.85 arc(88.6,99.96) 88.76,100.01 88.81,100.01 arc(89.11,100.09) 89.33,100.3 89.33,100.31 arc(89.48,100.45) 89.68,100.51 arc(89.97,100.58) 90.19,100.8 90.22,100.85 arc(90.33,100.96) 90.49,101.01 90.55,101.01 arc(90.84,101.09) 91.06,101.3 arc(91.13,101.55) 91.1,101.81 arc(91.1,101.82) 91.09,101.82 91.12,101.93 U1.BA8
  ART05 w0.109: 47.4,87.54 47.68,87.82 48.18,87.82 arc(48.82,87.95) 49.37,88.31 50.51,89.44 50.96,89.9 arc(51.56,90.79) 51.77,91.85 arc(51.91,92.55) 52.31,93.15 52.47,93.32 arc(53.51,94.01) 54.73,94.25 58.84,94.25 arc(59.78,94.44) 60.59,94.98 62.09,96.48 arc(62.72,96.9) 63.46,97.05 76.27,97.05 arc(77.42,97.28) 78.39,97.93 78.64,98.17 arc(79.54,98.77) 80.6,98.98 85.05,98.98
ZQSFP_RXN2: length 60.3
  TOP w0.091: J12.15 43.99,89.54 43.09,89.54
  ART07 w0.097: 85.17,103.01 85.41,103.01 arc(85.61,102.95) 85.76,102.8 arc(85.97,102.59) 86.27,102.51 86.27,102.51 arc(86.47,102.45) 86.62,102.31 86.62,102.3 arc(86.84,102.09) 87.14,102.01 87.14,102.01 arc(87.34,101.95) 87.49,101.81 87.52,101.75 arc(87.7,101.57) 87.95,101.51 87.96,101.51 arc(88.25,101.58) 88.46,101.79 88.46,101.8 arc(88.61,101.95) 88.81,102 88.82,102 arc(89.09,102.07) 89.3,102.26 89.34,102.31 arc(89.35,102.33) 89.37,102.34 arc(89.48,102.41) 89.61,102.48 arc(89.65,102.5) 89.7,102.51 arc(89.71,102.51) 89.72,102.51 arc(89.98,102.6) 90.18,102.8 90.18,102.8 arc(90.33,102.95) 90.53,103.01 90.55,103.01 arc(90.75,102.95) 90.89,102.81 90.89,102.8 arc(90.9,102.8) 90.9,102.8 arc(91.11,102.58) 91.41,102.51 91.51,102.51 arc(91.63,102.47) 91.71,102.39 91.76,102.3 arc(91.87,102.17) 92.01,102.07 arc(92.14,102.02) 92.27,102.01 arc(92.55,102.07) 92.76,102.26 arc(92.79,102.29) 92.82,102.33 arc(92.95,102.42) 93.1,102.49 arc(93.15,102.5) 93.19,102.51 arc(93.38,102.56) 93.54,102.66 arc(93.55,102.67) 93.56,102.68 arc(93.61,102.72) 93.67,102.75 arc(93.71,102.76) 93.76,102.74 U1.AY11
  ART07 w0.109: 85.17,103.01 85.14,102.98 84.34,102.98 arc(84.25,102.97) 84.17,102.94 arc(83.75,102.77) 83.31,102.72 79.28,102.72 arc(78.85,102.75) 78.43,102.85 78.39,102.87 arc(77.96,103.07) 77.59,103.36 77.09,103.86 arc(76.61,104.18) 76.04,104.29 75.05,104.29 arc(74.26,104.13) 73.58,103.68 73.21,103.31 71.32,101.42 arc(70.11,100.61) 68.68,100.32 65.35,100.32 arc(63.57,99.98) 62.05,99.01 arc(62.05,99.01) 62.05,99.01 61.96,98.92 arc(60.28,97.8) 58.3,97.4 53.32,97.4 arc(50.98,96.94) 49.01,95.62 47.25,93.86 arc(46.53,92.78) 46.28,91.52 46.28,91.36 arc(46.19,90.82) 45.93,90.34 arc(45.92,90.33) 45.91,90.31 45.79,90.19 arc(45.38,89.92) 44.9,89.82 43.37,89.82 43.09,89.54
ZQSFP_RXN3: length 53
  TOP w0.091: J12.24 47.4,89.94 47.4,89.94
  ART07 w0.097: 85.14,101.01 85.41,101.01 arc(85.6,100.96) 85.73,100.82 arc(85.95,100.6) 86.25,100.52 86.25,100.52 arc(86.45,100.47) 86.6,100.32 86.6,100.31 arc(86.82,100.1) 87.11,100.02 87.11,100.02 arc(87.32,99.97) 87.46,99.82 87.5,99.76 arc(87.68,99.57) 87.93,99.51 87.95,99.51 arc(88.23,99.58) 88.44,99.79 arc(88.57,99.92) 88.74,99.96 88.83,99.96 arc(89.1,100.04) 89.3,100.23 89.35,100.33 arc(89.5,100.48) 89.71,100.53 89.71,100.53 arc(90,100.61) 90.22,100.82 arc(90.35,100.96) 90.53,101.01 90.55,101.01 arc(90.75,100.95) 90.89,100.81 90.89,100.8 arc(91.11,100.59) 91.41,100.51 arc(91.61,100.45) 91.76,100.31 91.76,100.3 arc(92.28,100.01) 92.79,100.3 92.79,100.31 arc(92.94,100.45) 93.14,100.51 93.14,100.51 arc(93.4,100.57) 93.61,100.74 93.72,100.77 U1.BD11
  ART07 w0.109: 47.4,89.94 47.68,90.22 48.21,90.22 arc(48.47,90.27) 48.69,90.42 49.34,91.07 50.83,92.56 arc(52.4,93.61) 54.25,93.98 58.01,93.98 arc(59.53,94.28) 60.82,95.14 62,96.32 arc(63.14,97.08) 64.49,97.35 69.25,97.35 arc(69.96,97.48) 70.58,97.84 arc(70.58,97.85) 70.59,97.85 70.61,97.87 arc(70.94,98.09) 71.33,98.17 74.97,98.17 arc(76.15,98.4) 77.15,99.07 78.8,100.72 arc(79.09,100.92) 79.43,100.98 85.12,100.98 85.14,101.01
ZQSFP_RXP0: length 77.8
  TOP w0.091: J12.17 43.09,87.94 43.09,87.94
  ART05 w0.097: 85.02,104.96 85.05,104.96 85.07,104.98 85.43,104.98 arc(85.6,104.93) 85.73,104.81 arc(85.94,104.59) 86.24,104.51 86.26,104.51 arc(86.44,104.46) 86.58,104.32 86.59,104.31 arc(86.81,104.09) 87.1,104.01 87.12,104.01 arc(87.28,103.97) 87.4,103.85 87.43,103.8 arc(87.65,103.58) 87.94,103.51 87.95,103.51 arc(88.25,103.58) 88.47,103.8 88.48,103.81 arc(88.62,103.95) 88.81,104.01 arc(89.01,103.95) 89.16,103.81 89.16,103.8 arc(89.16,103.8) 89.17,103.8 arc(89.38,103.58) 89.68,103.51 arc(89.94,103.58) 90.14,103.77 90.16,103.8 arc(90.31,103.95) 90.51,104.01 90.54,104.01 arc(90.72,103.97) 90.86,103.86 90.83,103.77 U1.AV7
  ART05 w0.109: 43.09,87.94 42.8,87.66 41.76,87.66 arc(41.57,87.69) 41.41,87.8 41.26,87.96 41.26,88.13 41.1,88.28 40.93,88.28 40.78,88.44 40.78,88.61 40.62,88.76 40.45,88.76 40.29,88.92 40.29,89.09 40.14,89.25 39.97,89.25 39.45,89.76 arc(39.18,90.16) 39.09,90.64 39.09,94.54 arc(38.98,95.13) 38.66,95.64 arc(38.64,95.66) 38.61,95.68 arc(38.47,96.07) 38.43,96.49 38.43,103.12 arc(38.56,103.78) 38.93,104.34 39.55,104.96 arc(40.25,105.42) 41.07,105.59 41.68,105.59 41.8,105.46 42.02,105.46 42.14,105.59 42.36,105.59 42.48,105.46 42.7,105.46 42.82,105.59 43.04,105.59 43.16,105.46 43.38,105.46 43.5,105.59 46.44,105.59 arc(47.2,105.74) 47.85,106.17 48.32,106.64 arc(48.81,106.97) 49.38,107.08 52.4,107.08 arc(53.6,106.84) 54.62,106.16 55.08,105.7 arc(56.22,104.94) 57.57,104.67 70.53,104.67 arc(71.42,104.84) 72.17,105.35 72.39,105.56 arc(72.94,105.93) 73.6,106.06 75.87,106.06 arc(76.76,105.89) 77.52,105.38 78.13,104.77 arc(78.81,104.32) 79.6,104.16 81.5,104.16 81.62,104.04 81.84,104.04 81.96,104.16 82.18,104.16 82.3,104.04 82.52,104.04 82.64,104.16 82.86,104.16 82.98,104.04 83.2,104.04 83.32,104.16 83.54,104.16 arc(83.86,104.22) 84.14,104.41 84.57,104.84 arc(84.7,104.93) 84.86,104.96 85.02,104.96
ZQSFP_RXP1: length 51.8
  TOP w0.091: J12.22 47.4,88.34 47.4,88.34
  ART05 w0.097: 85.05,99.22 85.07,99.22 85.1,99.19 85.35,99.19 arc(85.64,99.11) 85.86,98.9 85.86,98.89 arc(86.01,98.75) 86.21,98.69 arc(86.41,98.75) 86.56,98.89 86.59,98.94 arc(86.77,99.13) 87.03,99.19 87.08,99.19 arc(87.28,99.25) 87.43,99.39 87.46,99.45 arc(87.64,99.63) 87.89,99.69 87.95,99.69 arc(88.15,99.75) 88.29,99.89 88.32,99.94 arc(88.51,100.13) 88.76,100.19 88.81,100.19 arc(89.01,100.25) 89.16,100.39 89.16,100.4 arc(89.38,100.61) 89.67,100.69 89.68,100.69 arc(89.88,100.75) 90.03,100.89 90.06,100.95 arc(90.24,101.13) 90.49,101.19 90.54,101.19 arc(90.74,101.25) 90.89,101.39 90.89,101.4 arc(90.95,101.57) 90.92,101.74 90.83,101.77 U1.BB7
  ART05 w0.109: 85.05,99.22 84.69,99.22 84.56,99.34 84.35,99.34 84.22,99.22 84.01,99.22 83.88,99.34 83.67,99.34 83.54,99.22 83.32,99.22 83.2,99.34 82.98,99.34 82.86,99.22 82.64,99.22 82.52,99.34 82.3,99.34 82.18,99.22 80.6,99.22 arc(79.45,98.99) 78.47,98.34 78.23,98.09 arc(77.33,97.49) 76.27,97.28 63.46,97.28 arc(62.63,97.12) 61.92,96.65 60.42,95.14 arc(59.69,94.66) 58.84,94.49 54.73,94.49 arc(53.42,94.23) 52.31,93.48 52.14,93.32 arc(51.69,92.64) 51.53,91.85 arc(51.34,90.88) 50.8,90.07 50.34,89.61 49.2,88.47 arc(48.74,88.16) 48.18,88.05 47.69,88.05 47.4,88.34
ZQSFP_RXP2: length 60.3
  TOP w0.091: J12.14 43.09,90.34 43.09,90.34
  ART07 w0.097: 85.17,103.19 85.41,103.19 arc(85.7,103.11) 85.92,102.9 arc(86.07,102.75) 86.27,102.7 86.27,102.7 arc(86.57,102.62) 86.78,102.4 86.79,102.4 arc(86.93,102.25) 87.14,102.2 87.14,102.2 arc(87.43,102.12) 87.65,101.9 87.68,101.85 arc(87.79,101.73) 87.94,101.69 87.96,101.69 arc(88.16,101.75) 88.3,101.89 88.3,101.9 arc(88.52,102.11) 88.81,102.19 88.82,102.19 arc(89,102.24) 89.15,102.37 89.19,102.42 arc(89.22,102.46) 89.26,102.49 arc(89.39,102.57) 89.52,102.65 arc(89.52,102.65) 89.52,102.65 arc(89.6,102.68) 89.68,102.69 arc(89.88,102.77) 90.03,102.92 arc(90.24,103.12) 90.53,103.19 90.55,103.19 arc(90.84,103.11) 91.06,102.9 91.06,102.89 arc(91.21,102.75) 91.41,102.69 91.51,102.69 arc(91.72,102.64) 91.87,102.48 91.93,102.39 arc(92.07,102.25) 92.28,102.19 arc(92.46,102.24) 92.61,102.37 arc(92.65,102.42) 92.7,102.47 arc(92.86,102.59) 93.04,102.67 arc(93.11,102.69) 93.18,102.7 arc(93.3,102.73) 93.41,102.8 arc(93.44,102.88) 93.4,102.95 93.14,103.1
  ART07 w0.109: 43.09,90.34 43.37,90.06 44.9,90.06 arc(45.29,90.13) 45.63,90.36 arc(45.69,90.42) 45.74,90.49 arc(45.97,90.9) 46.04,91.36 46.04,91.52 arc(46.31,92.87) 47.08,94.02 47.5,94.44 48.84,95.78 arc(50.9,97.15) 53.32,97.64 58.3,97.64 arc(60.19,98.01) 61.8,99.08 arc(63.43,100.17) 65.35,100.56 68.68,100.56 arc(70.02,100.82) 71.15,101.58 72.27,102.7 73.41,103.85 arc(74.17,104.35) 75.05,104.53 76.04,104.53 arc(76.7,104.4) 77.25,104.02 77.75,103.53 arc(78.08,103.27) 78.46,103.09 78.5,103.08 arc(78.89,102.98) 79.28,102.95 80.57,102.95 80.69,103.07 80.91,103.07 81.03,102.95 81.25,102.95 81.37,103.07 81.59,103.07 81.71,102.95 83.31,102.95 arc(83.69,103) 84.06,103.15 arc(84.19,103.2) 84.34,103.22 85.14,103.22 85.17,103.19
ZQSFP_RXP3: length 53
  TOP w0.091: 47.4,90.74 47.4,90.74 J12.25
  ART07 w0.097: 85.14,101.19 85.41,101.19 arc(85.69,101.12) 85.9,100.91 arc(86.04,100.76) 86.25,100.71 86.25,100.71 arc(86.54,100.63) 86.76,100.41 86.76,100.41 arc(86.91,100.26) 87.11,100.21 87.11,100.21 arc(87.41,100.13) 87.63,99.91 87.66,99.85 arc(87.78,99.74) 87.93,99.69 87.95,99.69 arc(88.14,99.75) 88.28,99.89 arc(88.47,100.08) 88.74,100.15 88.83,100.15 arc(89.01,100.2) 89.13,100.33 89.19,100.42 arc(89.41,100.64) 89.71,100.72 89.71,100.72 arc(89.91,100.77) 90.06,100.92 arc(90.26,101.12) 90.53,101.19 90.55,101.19 arc(90.84,101.11) 91.06,100.9 91.06,100.89 arc(91.21,100.75) 91.41,100.69 91.41,100.69 arc(91.71,100.61) 91.92,100.4 91.93,100.39 arc(92.28,100.19) 92.63,100.4 arc(92.84,100.61) 93.14,100.69 93.14,100.69 arc(93.31,100.73) 93.45,100.84 93.43,100.93 93.14,101.1
  ART07 w0.109: 47.4,90.74 47.68,90.46 48.21,90.46 arc(48.38,90.49) 48.52,90.59 49.17,91.24 50.3,92.37 50.66,92.73 arc(52.31,93.83) 54.25,94.21 58.01,94.21 arc(59.44,94.5) 60.66,95.31 61.83,96.48 arc(63.05,97.3) 64.49,97.59 69.25,97.59 arc(69.88,97.7) 70.43,98.02 arc(70.44,98.03) 70.44,98.03 arc(70.85,98.31) 71.33,98.4 74.97,98.4 arc(76.06,98.62) 76.98,99.24 78.63,100.89 arc(79,101.13) 79.43,101.22 81.96,101.22 82.09,101.34 82.3,101.34 82.43,101.22 83.06,101.22 83.18,101.34 83.4,101.34 83.52,101.22 85.12,101.22 85.14,101.19
ZQSFP_T_INITMODE: length 20.8
  TOP w0.109: v2(53.66,92.46) 53.66,91.98 53.77,91.87 54.28,91.87 54.97,91.17 U14.C1
  ART16 w0.114: v2(53.66,92.46) 52.9,93.22 51.28,93.22 50.85,92.79 47.01,92.79 45.79,94 42.62,94 42.21,94.41 42.21,95.1 42.62,95.5 43.41,95.5 43.48,95.58 44.57,95.58 44.68,95.48 46,95.48 46.05,95.53 v2(47.34,95.53)
ZQSFP_T_INTN: length 24.6
  TOP w0.109: v2(47.75,93.22) 47.67,93.14 J12.28 ; U13.C4 65.54,89.35 v2(64.58,88.39)
  ART16 w0.114: v2(47.75,93.22) 47.74,93.23 47.74,93.67 48.44,94.36 56.23,94.36 56.61,93.98 57.76,93.98 60.69,91.05 60.8,90.93 61.08,90.93 61.87,90.14 64.79,90.14 65.12,89.81 65.12,88.94 v2(64.58,88.39)
ZQSFP_T_MODPRSN: length 22.5
  TOP w0.109: J12.27 47.66,92.34 48.36,93.04 48.36,93.12 v2(48.46,93.22) ; U13.C3 65.35,90.17 v2(64.58,89.41)
  ART16 w0.114: v2(48.46,93.22) 49.22,93.98 55.98,93.98 56.36,93.6 57.5,93.6 60.02,91.08 60.02,91.01 61.44,89.58 62.51,89.58 63.23,88.86 64.03,88.86 v2(64.58,89.41)
ZQSFP_T_MODSELN: length 27.1
  TOP w0.109: v2(65.28,91.74) 65.28,91.44 U13.C1 ; J12.8 42.94,95.14 v2(42.85,95.05)
  ART16 w0.114: v2(42.85,95.05) 47.62,95.05 47.7,95.12 56.74,95.12 57,94.87 62.15,94.87 v2(65.28,91.74)
  BOTTOM w0.109: R218.2 64.36,92.66 v2(65.28,91.74)
ZQSFP_T_RESETN: length 25.9
  TOP w0.109: U13.C2 65.21,90.67 65.11,90.77 65.11,90.78 v2(64.55,91.34)
  ART16 w0.114: v2(44.6,94.46) 47.88,94.46 48.16,94.74 56.49,94.74 56.87,94.36 58.65,94.36 61.19,91.82 64.07,91.82 v2(64.55,91.34)
  BOTTOM w0.254: v2(64.55,91.34) 64.07,91.34 64.02,91.29 R223.2 R219.2
ZQSFP_T_SCL: length 11.5
  TOP w0.109: v2(54.17,90.04) 54.3,90.17 U14.C3
  ART16 w0.114: v2(44.68,92.71) 46.5,92.71 46.83,92.37 50.6,92.37 52.17,90.8 53.4,90.8 v2(54.17,90.04)
ZQSFP_T_SDA: length 12.5
  TOP w0.109: v2(54.17,89.03) 54.81,89.67 U14.C4
  ART16 w0.114: v2(54.17,89.03) 54.17,88.86 53.57,88.26 52.8,88.26 49.12,91.95 47.21,91.95 45.43,91.95 45.42,91.95 v2(44.68,91.95)
ZQSFP_TXN0: length 42.3
  TOP w0.091: J12.37 46.5,100.34 47.4,100.34
  ART07 w0.097: U1.AU2 85.93,103.93 85.82,103.96 arc(85.61,104.13) 85.35,104.19 84.86,104.19
  ART07 w0.109: 84.86,104.19 84.84,104.22 83.96,104.22 arc(83.84,104.24) 83.73,104.3 arc(83.49,104.44) 83.21,104.5 79.33,104.5 arc(78.73,104.61) 78.23,104.95 77.89,105.29 arc(77.31,105.68) 76.63,105.82 74.57,105.82 arc(73.63,105.63) 72.84,105.1 70.78,103.04 arc(69.52,102.2) 68.04,101.9 53.46,101.9 arc(52.31,101.68) 51.34,101.03 51.2,100.89 arc(50.28,100.27) 49.18,100.05 47.69,100.05 47.4,100.34
ZQSFP_TXN1: length 50.3
  TOP w0.091: 43.09,99.94 43.99,99.94 J12.2
  ART05 w0.097: 84.95,100.98 84.97,100.98 84.99,101.01 85.35,101.01 arc(85.83,101.26) 85.9,101.81 arc(85.9,101.82) 85.9,101.82 85.93,101.93 U1.BA2
  ART05 w0.109: 43.09,99.94 42.79,99.64 42.41,99.64 arc(42.3,99.67) 42.2,99.73 arc(42.12,99.86) 42.09,100 42.09,100.3 arc(42.18,100.76) 42.44,101.14 42.77,101.48 arc(42.77,101.48) 42.78,101.49 42.95,101.62 arc(43.27,101.79) 43.63,101.85 45.26,101.85 45.38,101.73 45.6,101.73 45.72,101.85 45.94,101.85 46.06,101.73 46.28,101.73 46.4,101.85 46.62,101.85 46.74,101.73 46.96,101.73 47.08,101.85 59.89,101.85 arc(60.97,101.64) 61.88,101.03 arc(62.21,100.81) 62.6,100.73 68.19,100.73 arc(69.37,100.49) 70.38,99.82 70.75,99.46 arc(71.72,98.81) 72.87,98.58 75.46,98.58 arc(76.38,98.76) 77.15,99.28 77.2,99.33 78.1,100.23 arc(78.94,100.79) 79.93,100.98 84.95,100.98
ZQSFP_TXN2: length 52.6
  TOP w0.091: 47.4,97.94 46.5,97.94 J12.34
  ART07 w0.097: 84.94,105.01 85.35,105.01 arc(85.55,104.95) 85.7,104.81 85.7,104.8 arc(85.91,104.59) 86.21,104.51 86.21,104.51 arc(86.41,104.45) 86.56,104.31 86.56,104.3 arc(86.62,104.1) 86.56,103.9 arc(86.49,103.6) 86.56,103.3 86.62,103.21 arc(86.77,103.06) 86.97,103.01 87.08,103.01 arc(87.28,102.95) 87.43,102.8 87.43,102.8 arc(87.43,102.8) 87.43,102.8 87.45,102.78 arc(87.65,102.58) 87.92,102.51 87.95,102.51 arc(88.21,102.57) 88.41,102.74 88.52,102.77 U1.AY5
  ART07 w0.109: 84.94,105.01 84.91,104.98 84.38,104.98 84.25,104.98 arc(84.05,105.02) 83.89,105.13 83.87,105.15 arc(83.7,105.26) 83.51,105.3 83.29,105.3 83.17,105.18 82.95,105.18 82.83,105.3 82.61,105.3 82.49,105.18 82.27,105.18 82.15,105.3 81.93,105.3 81.81,105.18 81.59,105.18 81.47,105.3 81.06,105.3 arc(80.96,105.31) 80.87,105.33 arc(80.58,105.47) 80.32,105.68 arc(79.81,106.02) 79.2,106.14 79.04,106.14 arc(78.69,106.2) 78.39,106.38 arc(78.38,106.38) 78.38,106.38 78.31,106.44 arc(78,106.65) 77.63,106.72 73.99,106.72 arc(73.21,106.57) 72.55,106.13 71.62,105.2 arc(71.03,104.81) 70.33,104.67 65.06,104.67 arc(64.32,104.52) 63.68,104.1 63.54,103.95 arc(62.14,103.02) 60.5,102.69 50.13,102.69 50.01,102.57 49.79,102.57 49.67,102.69 49.45,102.69 49.33,102.57 49.11,102.57 48.99,102.69 48.77,102.69 48.65,102.57 48.43,102.57 48.31,102.69 47.93,102.69 arc(47.65,102.63) 47.4,102.47 46.87,101.94 arc(46.47,101.34) 46.33,100.62 46.33,98 46.61,97.71 47.18,97.71 47.4,97.94
ZQSFP_TXN3: length 59.1
  TOP w0.091: 43.09,97.54 43.99,97.54 J12.5
  ART05 w0.097: 84.92,102.98 84.95,102.98 84.97,103.01 85.35,103.01 arc(85.55,102.95) 85.7,102.8 85.7,102.8 arc(85.92,102.59) 86.21,102.51 86.23,102.51 arc(86.41,102.46) 86.54,102.34 86.55,102.32 arc(86.6,102.26) 86.66,102.21 86.72,102.16 arc(86.83,102.08) 86.95,102.03 arc(86.99,102.02) 87.03,102.01 87.11,102.01 arc(87.44,101.79) 87.43,101.4 87.43,101.4 arc(87.35,101.1) 87.43,100.8 87.43,100.8 arc(87.65,100.58) 87.94,100.51 87.95,100.51 arc(88.2,100.56) 88.4,100.72 arc(88.41,100.73) 88.41,100.74 88.52,100.77 U1.BD5
  ART05 w0.109: 43.09,97.54 42.8,97.25 42.26,97.25 arc(41.87,97.33) 41.54,97.55 41.21,97.87 arc(41.07,98.04) 40.97,98.24 40.97,98.24 arc(40.91,98.45) 40.88,98.67 40.88,100.39 arc(41.07,101.32) 41.59,102.11 41.84,102.35 arc(42.41,102.73) 43.09,102.87 43.63,102.87 43.76,102.75 43.98,102.75 44.1,102.87 44.32,102.87 44.44,102.75 44.66,102.75 44.78,102.87 45,102.87 45.12,102.75 45.34,102.75 45.46,102.87 45.68,102.87 45.8,102.75 46.02,102.75 46.14,102.87 46.36,102.87 46.48,102.75 46.7,102.75 46.82,102.87 61.45,102.87 arc(62.03,102.75) 62.52,102.42 62.73,102.21 arc(62.97,102.06) 63.24,102 69.47,102 arc(70.87,102.28) 72.06,103.07 72.43,103.44 72.62,103.63 arc(73.66,104.33) 74.88,104.57 75.33,104.57 arc(76.18,104.4) 76.89,103.92 77.25,103.57 77.51,103.31 arc(78.4,102.72) 79.45,102.51 83.18,102.51 arc(83.44,102.56) 83.65,102.7 arc(83.96,102.91) 84.33,102.98 84.92,102.98
ZQSFP_TXP0: length 42.3
  TOP w0.091: 47.4,99.54 46.5,99.54 J12.36
  ART07 w0.097: 84.89,104.01 85.35,104.01 arc(85.52,103.97) 85.66,103.86 85.63,103.77 U1.AV1
  ART07 w0.109: 47.4,99.54 47.68,99.82 49.18,99.82 arc(50.37,100.05) 51.37,100.72 51.51,100.86 arc(52.4,101.46) 53.46,101.67 68.04,101.67 arc(69.61,101.98) 70.94,102.87 72.65,104.58 73,104.93 arc(73.72,105.41) 74.57,105.58 76.63,105.58 arc(77.22,105.46) 77.72,105.13 78.07,104.78 arc(78.64,104.4) 79.33,104.26 81.85,104.26 81.97,104.14 82.19,104.14 82.31,104.26 82.53,104.26 82.65,104.14 82.87,104.14 82.99,104.26 83.21,104.26 arc(83.41,104.23) 83.58,104.12 arc(83.76,104.02) 83.96,103.98 84.86,103.98 84.89,104.01
ZQSFP_TXP1: length 50.3
  TOP w0.091: J12.3 43.09,99.14
  ART05 w0.097: U1.BB1 85.63,101.77 85.73,101.74 arc(85.68,101.37) 85.35,101.19 84.99,101.19 84.97,101.22 84.95,101.22
  ART05 w0.109: 43.09,99.14 42.86,99.37 42.82,99.4 arc(42.79,99.41) 42.76,99.41 42.41,99.41 arc(42.21,99.45) 42.03,99.57 arc(41.9,99.77) 41.85,100 41.85,100.3 arc(41.96,100.85) 42.27,101.31 42.6,101.64 arc(42.62,101.66) 42.64,101.67 42.8,101.8 arc(43.2,102.01) 43.63,102.09 59.89,102.09 arc(61.06,101.85) 62.05,101.19 arc(62.3,101.02) 62.6,100.96 68.19,100.96 arc(69.46,100.71) 70.55,99.99 70.91,99.62 arc(71.81,99.02) 72.87,98.81 75.46,98.81 arc(76.29,98.97) 76.99,99.44 77.04,99.49 77.94,100.39 arc(78.85,101) 79.93,101.22 84.95,101.22
ZQSFP_TXP2: length 52.6
  TOP w0.091: J12.33 47.4,97.14
  ART07 w0.097: 87.94,103.1 88.23,102.93 88.26,102.84 arc(88.12,102.73) 87.95,102.69 87.92,102.69 arc(87.74,102.74) 87.61,102.87 87.59,102.9 arc(87.38,103.11) 87.08,103.19 86.97,103.19 arc(86.86,103.22) 86.78,103.31 86.73,103.4 arc(86.67,103.6) 86.73,103.8 arc(86.81,104.1) 86.73,104.4 arc(86.73,104.4) 86.72,104.4 arc(86.51,104.62) 86.22,104.69 86.21,104.69 arc(86.01,104.75) 85.86,104.89 85.86,104.9 arc(85.65,105.11) 85.35,105.19 84.89,105.19
  ART07 w0.109: 84.89,105.19 84.86,105.22 84.25,105.22 arc(84.14,105.24) 84.05,105.3 84.03,105.32 arc(83.79,105.48) 83.51,105.54 81.06,105.54 arc(81,105.54) 80.95,105.55 arc(80.7,105.67) 80.49,105.84 arc(79.9,106.24) 79.2,106.37 79.04,106.37 arc(78.77,106.42) 78.54,106.56 arc(78.51,106.58) 78.48,106.61 arc(78.09,106.87) 77.63,106.96 73.99,106.96 arc(73.12,106.79) 72.38,106.29 71.46,105.37 arc(70.94,105.02) 70.33,104.9 65.06,104.9 arc(64.23,104.73) 63.52,104.26 63.37,104.11 arc(62.05,103.23) 60.5,102.92 47.93,102.92 arc(47.56,102.85) 47.24,102.64 46.71,102.11 arc(46.25,101.43) 46.09,100.62 46.09,97.9 46.51,97.48 47.06,97.48 47.4,97.14
ZQSFP_TXP3: length 59.1
  TOP w0.091: J12.6 43.09,96.74
  ART05 w0.097: 84.92,103.22 84.95,103.22 84.97,103.19 85.35,103.19 arc(85.64,103.11) 85.86,102.9 85.86,102.89 arc(86.01,102.75) 86.21,102.69 86.24,102.69 arc(86.5,102.63) 86.7,102.44 86.71,102.43 arc(86.74,102.39) 86.77,102.36 86.84,102.3 arc(86.92,102.25) 87.02,102.2 arc(87.03,102.2) 87.04,102.2 87.12,102.19 arc(87.6,101.88) 87.6,101.31 87.59,101.3 arc(87.54,101.1) 87.59,100.9 87.6,100.89 arc(87.74,100.75) 87.94,100.69 87.95,100.69 arc(88.12,100.73) 88.26,100.84 88.23,100.93 87.94,101.1
  ART05 w0.109: 84.92,103.22 84.33,103.22 arc(83.87,103.13) 83.49,102.87 arc(83.35,102.78) 83.18,102.74 79.45,102.74 arc(78.49,102.93) 77.67,103.48 77.12,104.02 77.06,104.09 arc(76.27,104.62) 75.33,104.8 74.88,104.8 arc(73.57,104.54) 72.45,103.8 71.89,103.24 arc(70.78,102.5) 69.47,102.23 63.24,102.23 arc(63.06,102.27) 62.9,102.38 62.68,102.59 arc(62.12,102.97) 61.45,103.1 43.09,103.1 arc(42.32,102.95) 41.68,102.52 41.43,102.27 arc(40.85,101.41) 40.65,100.39 40.65,98.67 arc(40.68,98.4) 40.75,98.15 arc(40.88,97.91) 41.05,97.71 41.37,97.38 arc(41.78,97.11) 42.26,97.02 42.81,97.02 43.09,96.74
ZQSFP_VCCR:
  vias: v3(41.76,93.8) v3(42.54,93.42) v3(43.38,93.5) v3(44.57,93.5)
N23911: length 3.9
  TOP w0.109: R469.1 184.34,49.12 R472.2 184.31,49.74 184.76,50.2 U38.43
N23923: length 2.3
  TOP w0.109: U39.3 184.36,44.59 184.34,44.6 R915.1
N23931: length 10.8
  TOP w0.508: U39.4 182.41,44.45 C884.1 179.74,42.8 R476.1 C885.2 175.49,42.73 C883.1 174.06,42.74 L20.2
N23977: length 2.2
  TOP w0.279: U38.7 184.27,62.41 v2(184,62.68)
N23983: length 4.9
  TOP w0.279: v2(187.55,50.93) 187.54,50.93 187.27,51.21 U38.48
  BOTTOM w0.279: v2(187.55,50.93) 188.19,50.29 188.19,47.56 C855.1
N23993: length 1.4
  TOP w0.109: U38.47 v2(186.76,50.95)
  BOTTOM w0.109: C857.2 186.41,51.31 v2(186.76,50.95)
N23999: length 1.5
  TOP w0.109: U38.39 182.76,50.96 v2(182.85,50.88)
  BOTTOM w0.109: C858.2 182.98,51 v2(182.85,50.88)
N24063: length 2.8
  TOP w0.109: U38.6 v2(184.76,61.59)
  BOTTOM w0.109: C1327.1 185.58,62.79 185.01,62.23 185.01,61.85 184.76,61.6 v2(184.76,61.59)
N24075: length 3.9
  TOP w0.109: C1336.1 R478.2 C895.1 C896.2
N24081: length 4.6
  TOP w0.109: C895.2 175.25,58.8 176.01,59.56 177.52,59.56 177.7,59.38 U38.18
N31156: length 1.3
  TOP w0.109: R74.2 C8.1
N125826: length 37.6
  TOP w0.254: 156.44,75.31 156.45,75.31 ; 156.44,75.31 153.39,75.31 153.13,75.06 153.13,67.31 153.39,67.06 156.82,67.06 157.07,67.31 157.07,75.08 156.84,75.31 156.44,75.31
  TOP w0.508: FB1.1 155,78.45 R5286.1 155.06,79.96 R1004.1 157.52,79.96 R856.2 ; FB1.1 C1600.1 156.25,76.97 C1.1 156.25,75.5 156.45,75.31 D1.6 ; FB1.1 155.11,78.12 R15.1
N130133: length 78.1
  TOP w0.109: J11.58 192.02,118.52 192.25,118.75 193.84,118.75 194.15,118.44 194.15,117.41 195.86,115.7 v2(196.98,115.7)
  ART20 w0.114: v2(196.98,115.7) 196.47,115.18 196.47,87.02 193.44,83.99 193.44,80.93 192.36,79.86 190.91,79.86 189.51,78.45 187.54,78.45 187.37,78.62 183.22,78.62 182.74,79.09 175.09,79.09 173.67,80.52 167.59,80.52 v2(165.75,82.36)
  BOTTOM w0.109: v2(165.75,82.36) 165.3,81.92 164.85,81.92 164.59,82.17 164.59,83.22 R179.1
N132125: length 62.8
  TOP w0.109: J10.58 192.4,93.12 ; v2(160.18,85.16) 160.82,85.8 R178.1
  TOP w0.114: v2(197.84,84.96) 195.68,87.12 195.68,90.42 192.99,93.12 192.4,93.12
  ART18 w0.114: v2(160.18,85.16) 160.18,84.79 159.61,84.22 159.61,82.17 162.03,79.75 171.63,79.75 172.39,79 181.45,79 184.63,75.82 191.49,75.82 193.52,77.85 193.52,80.64 v2(197.84,84.96)
N275652: length 15.1
  TOP w0.109: v2(52.7,70.28) 52.7,70.84 53,71.14 U12.69
  BOTTOM w0.109: R191.2 54.48,59.64 53.44,60.68 53.44,69.54 v2(52.7,70.28)
N275658: length 12.2
  TOP w0.109: U12.66 52.87,68.74 v2(52.85,68.73)
  BOTTOM w0.109: v2(52.85,68.73) 53.11,68.48 53.11,57.95 R192.2
N275660: length 13.4
  TOP w0.109: U12.50 51.56,67.54 52.12,68.1 v2(52.12,68.63)
  BOTTOM w0.109: R204.2 51.13,58.66 51.13,67.11 52.12,68.1 v2(52.12,68.63)
N275666: length 12.2
  TOP w0.109: U12.49 50.2,68.34 v2(49.93,68.07)
  BOTTOM w0.109: R205.2 48.23,57.94 49.55,59.26 49.55,67.41 49.93,67.79 v2(49.93,68.07)
N275672: length 14.3
  TOP w0.109: U12.47 50.35,69.94 v2(49.98,70.31)
  BOTTOM w0.109: v2(49.98,70.31) 49.98,69.81 50.52,69.28 50.52,67.94 49.91,67.33 49.91,58.25 R206.2
N275674: length 16.6
  TOP w0.109: v2(49.27,70.46) 49.56,70.74 U12.46
  BOTTOM w0.109: v2(49.27,70.46) 49.71,70.89 50.44,70.89 51,70.33 51,67.89 50.67,67.56 R208.2
N275700: length 14.4
  TOP w0.109: U12.65 54.76,67.94 55.12,68.3 v2(55.12,68.68)
  BOTTOM w0.109: v2(55.12,68.68) 54.15,68.68 53.79,68.33 53.79,61.72 55.75,59.76 R193.2
N396676: length 2.1
  TOP w0.508: U50.4 56.85,203.54 R534.2
N396772: length 20.7
  TOP w0.254: R535.2 51.53,191.26 52.39,190.41 U51.5
  TOP w0.508: v2(49.63,190.37) 50.2,190.37 50.71,190.88 R535.2
  ART05 w0.508: v2(49.63,190.37) 49.63,191.06 54.68,196.11 54.68,200.5 57.38,203.2 v2(58.07,203.2)
N396880: length 3
  TOP w0.254: U51.3 55.69,189.61 R539.2 56.9,189.8 R533.2
N396890: length 5.2
  TOP w0.254: R537.1 R536.1 R538.2 50.71,188.04 51.28,188.61 U51.8
N397044: length 3
  TOP w0.254: U51.2 55.68,189.11 R539.1 56.9,188.91 R540.1
N3916294: length 9.9
  ART03 w0.508: v2(37.06,203.54) 36.8,203.28 36.8,195.01 v2(35.91,194.12)
N3918231: length 1
  TOP w0.508: C958.2 R518.2
N3967240: length 1.3
  TOP w0.508: R535.1 C970.1
N16786734: length 4.4
  TOP w0.163: R249.2 23.62,20.52 23.69,20.45 U15.17 U15.19 22.99,19.24 22.99,19.05 22.79,18.86 U15.20 U15.18
N16786764: length 5.6
  TOP w0.163: U15.11 25.32,19.17 25.32,19.02 25.19,18.89 U15.12 U15.14 U15.16 ; U15.11 25.53,19.38 26.05,19.38 U15.9 U15.7 ; U15.11 25.49,21.75 R250.2
N16787300:
  vias: v2(25.59,8.76)
N16787302:
  vias: v2(36,8.76)
N16787306:
  vias: v2(39.18,8.76)
N16787308:
  vias: v2(32.83,8.76)
N16787759: length 3.5
  ART03 w0.508: v2(17.08,11.18) v2(17.08,9.91)
  BOTTOM w0.254: v2(17.08,9.91) 17.64,9.35 18.22,9.35 C636.2
N16787774: length 3
  ART03 w0.508: v2(17.08,14.99) v2(17.08,16.26)
  BOTTOM w0.254: C634.2 17.72,14.35 v2(17.08,14.99)
N16787789: length 2.2
  ART03 w0.508: v2(17.08,17.53) v2(17.08,18.8)
  BOTTOM w0.508: C633.2 v2(17.08,17.53)
N16787795: length 3
  ART03 w0.508: v2(17.08,13.72) v2(17.08,12.45)
  BOTTOM w0.254: v2(17.08,13.72) 17.69,13.11 C635.2
N17395836: length 2.2
  TOP w0.089: R462.2 177.71,52.05 178.01,52.05 178.41,52.45 178.79,52.45 178.85,52.38 U38.32
N17488683:
  vias: v2(29.65,8.76)
N17488777: length 0.8
  TOP w0.109: v2(20.12,11.94) 20.42,12.24 U15.47
N17498635: length 4.8
  BOTTOM w0.254: C1858.2 R5287.2 22.78,56.25 22.78,55.93 23.26,55.45 24.25,55.45 24.63,55.07 U33.8
N17498650: length 4.9
  BOTTOM w0.254: C1859.2 R5288.2 23.51,56.53 23.29,56.3 23.29,55.96 23.42,55.83 24.41,55.83 25.13,55.11 25.13,54.23 U33.9
N17498657: length 4.5
  BOTTOM w0.254: U33.10 25.63,54.73 26.44,55.55 26.77,55.55 27.18,55.96 27.18,56.27 26.92,56.53 R5289.2 C1860.2
N17498664: length 3.5
  BOTTOM w0.254: U33.29 22.13,48.8 21.23,47.9 19.75,47.9 C806.2
N17498668: length 4.3
  BOTTOM w0.254: U33.11 26.13,54.7 26.6,55.17 26.93,55.17 27.56,55.8 27.56,56.25 R5290.2 C1861.2
N17498677: length 7.9
  BOTTOM w0.254: U33.12 27.05,54.15 29.61,56.01 30.44,56.01 C1862.2 31.05,56.48 31.52,56.01 32.47,56.01 R5291.2
N17498690: length 7.7
  BOTTOM w0.254: R5292.2 32.47,55.63 31.5,55.63 31.05,55.18 C1863.2 30.44,55.63 29.73,55.63 27.38,53.92 U33.13
N17498697: length 6.9
  BOTTOM w0.254: R5293.2 32.45,53.31 31.55,53.31 31.05,53.81 C1864.2 30.37,53.26 28.42,53.26 27.97,52.82 U33.14
N17498704: length 6.9
  BOTTOM w0.254: U33.15 27.29,52.31 28.03,52.31 28.15,52.42 28.15,52.45 28.58,52.88 30.52,52.88 C1865.2 31.05,52.51 31.47,52.93 32.5,52.93 R5294.2
N17498716: length 1.5
  BOTTOM w0.109: U33.26 23.63,48.98 23.47,48.82 23.29,48.82 23.13,48.98 U33.27
N17498720: length 1.3
  BOTTOM w0.109: U33.24 24.63,49.04 24.51,48.92 24.24,48.92 24.13,49.03 U33.25
N17498798: length 8.5
  ART05 w0.381: v1(20.04,46.84) 19.08,47.8 19.08,49.43 18.35,50.15 v3(18.35,52.32)
  BOTTOM w0.254: 21.54,47.52 22.63,48.61 U33.28
N17552728: length 2.8
  TOP w0.109: X3.1 54.36,167.45 R446.1
N17552752: length 2.8
  TOP w0.109: R447.2 46.6,162.36 X3.3
N17579378: length 7
  TOP w0.109: J24.1 C811.1
N17579380: length 7
  TOP w0.109: J25.1 C813.1
N17579486: length 1.6
  BOTTOM w0.089: U34.5 87.23,37.71 87.12,37.81 87.12,38.31 R421.2
N17579627: length 7.1
  ART07 w0.094: v2(97.58,34.04) 97.58,33.65 97.31,33.38 96.47,33.38 96.27,33.18 96.12,33.18 95.99,33.05 95.99,32.9 95.86,32.77 95.29,32.77 95.18,32.87 95,32.87 94.89,32.77 94.7,32.77 94.59,32.87 94.41,32.87 94.3,32.77 93.91,32.77 93.77,32.9 93.77,33.11 93.88,33.21 93.88,33.4 93.77,33.51 93.77,33.7 94.01,33.93 94.56,33.93 94.65,33.84 v2(94.65,33.53)
N17579701: length 7.1
  ART07 w0.094: v2(97.58,32.77) 97.18,33.17 96.55,33.17 95.94,32.56 93.83,32.56 93.57,32.82 93.57,33.78 93.93,34.14 94.56,34.14 94.65,34.23 v2(94.65,34.54)
N17585195: length 2.3
  BOTTOM w0.089: U34.32 84.28,36.75 84.17,36.64 83.97,36.64 83.53,37.08 83.12,37.08 R418.2
N17585196: length 2.3
  BOTTOM w0.089: R416.2 83.09,36.8 83.41,36.8 83.85,36.36 84.14,36.36 84.25,36.25 U34.31
N17585199: length 2.6
  BOTTOM w0.089: R414.2 83.11,34.81 83.28,34.81 83.51,35.04 83.51,35.27 83.88,35.64 84.17,35.64 84.28,35.75 U34.30
N17585200: length 2.6
  BOTTOM w0.089: R413.2 83.11,34.53 83.4,34.53 83.79,34.92 83.79,35.15 83.99,35.36 84.14,35.36 84.25,35.25 U34.29
N17645458: length 4.7
  TOP w0.508: X1.4 v2(20.52,9.27)
  BOTTOM w0.508: v2(20.52,9.27) X1.4 20.53,8.19 FB15.1
N17645502:
  vias: v2(20.52,6.29)
N17771286: length 27.8
  TOP w0.089: C871.2 179.72,48.05 179.72,46.97 v2(180.08,46.61)
  ART20 w0.094: v2(177.67,22.61) 177.23,22.61 177.14,22.7 177.14,39.12 179.68,41.66 179.68,46.2 v2(180.08,46.61)
N17771287: length 2.9
  TOP w0.089: C871.1 179.72,49.48 179.72,49.95 180.16,50.39 180.16,50.9 180.27,51.01 U38.34
N17771288: length 27.8
  TOP w0.089: C872.2 179.44,48.05 179.44,46.97 v2(179.07,46.61)
  ART20 w0.094: v2(176.4,22.61) 176.84,22.61 176.94,22.7 176.94,39.2 179.47,41.74 179.47,46.2 v2(179.07,46.61)
N17771289: length 2.9
  TOP w0.089: C872.1 179.44,49.48 179.44,50.07 179.87,50.51 179.87,50.9 179.76,51.01 U38.33
N17771290: length 3.6
  TOP w0.089: U38.51 188.14,53.38 188.14,53.44 188.96,53.44 189.3,53.09 189.3,52.73 189.85,52.18 190.32,52.18 R465.2
N17771292: length 3.7
  TOP w0.089: U38.52 188.02,53.85 188.31,53.85 188.44,53.72 189.08,53.72 189.58,53.21 189.58,52.85 189.97,52.47 190.32,52.47 R466.2
N17958439: length 23.1
  TOP w0.109: U23.G9 v2(36.33,171.92) ; R337.1 v2(23.01,160.98)
  ART07 w0.114: v2(36.33,171.92) 35.94,171.53 35.94,165.35 34.33,163.74 31.97,163.74 31.75,163.96 29.54,163.96 29.28,163.7 25.73,163.7 v2(23.01,160.98)
N17958472: length 24.7
  TOP w0.109: U23.H9 v2(37.13,171.92) ; R338.1 v2(26.57,161.04)
  ART07 w0.114: v2(26.57,161.04) 26.9,161.37 31.67,161.37 32.51,160.53 34.8,160.53 35.81,161.54 35.81,162.94 36.07,163.19 36.45,163.19 36.77,163.51 36.77,164.02 37.47,164.72 37.47,166.37 37.79,166.7 38.28,166.7 38.55,166.98 38.55,171.14 38.15,171.55 37.51,171.55 37.14,171.92 v2(37.13,171.92)
N17958492: length 22.2
  TOP w0.109: R335.1 v2(25.37,161.01) ; U23.H8 v2(37.13,171.12)
  ART07 w0.114: v2(37.13,171.12) 37.54,170.71 37.54,166.9 37.08,166.45 37.08,165.23 35.43,163.58 35.43,162.31 35.08,161.96 33.56,161.96 33.4,161.8 32.77,161.8 32.51,162.05 32.13,162.05 31.98,161.9 26.26,161.9 v2(25.37,161.01)
N17958512: length 21.8
  TOP w0.109: R336.1 v2(24.18,161.01) ; U23.G8 v2(36.33,171.12)
  ART07 w0.114: v2(36.33,171.12) 36.73,170.73 36.73,165.38 34.2,162.85 31.28,162.85 30.86,162.43 25.6,162.43 v2(24.18,161.01)
N18010178: length 107.7
  TOP w0.109: R493.1 R491.1 v2(181.2,93.73)
  TOP w0.127: U43.3 180.47,123.73 R483.2 180.88,122.59 v2(180.71,122.41)
  ART03 w0.114: v2(180.71,122.41) 180.71,122.52 180.16,123.06 175.64,123.06 173.42,120.84 v2(172.72,120.84)
  ART05 w0.114: v2(151.56,104.77) 152.14,105.36 160.96,105.36 163.71,102.62 164.82,102.62 165.89,101.55 178.38,101.55 181.84,98.09 181.84,94.94 181.2,94.31 v2(181.2,93.73)
  ART16 w0.114: v2(181.2,93.73) 181.84,94.36 181.84,97.54 180.19,99.19 180.19,110.82 183.16,113.79 184,113.79 184.63,114.43 184.63,119.28 183.46,120.45
  ART16 w0.127: 183.46,120.45 181.5,122.41 v2(180.71,122.41)
  ART20 w0.114: v2(151.56,104.77) 151.56,103.76 150.59,102.8 150.59,100.71 148.18,98.3 148.18,94.36 146.53,92.71 v2(144.63,92.71)
  BOTTOM w0.109: R488.1 144.33,94.85 144.55,94.85 145.32,94.07 R481.1 v2(144.63,92.71) R482.1
N18012016: length 2.5
  BOTTOM w0.109: R4.1 144.79,81.28 Q2.C
N18012042: length 1.6
  BOTTOM w0.109: Q2.B R6.1
N18012643: length 5
  BOTTOM w0.109: R3.1 144.43,86.87 144.73,86.87 145.54,87.68 145.54,88.93 146.52,89.92 Q1.C
N18012671: length 2.1
  BOTTOM w0.109: R5.1 149.99,90.87 Q1.B
N18013119: length 2.5
  BOTTOM w0.109: R8.1 144.79,85.09 Q3.C
N18013147: length 1.6
  BOTTOM w0.109: Q3.B R13.1
N18020316:
  vias: v2(139.45,214.44)
N18020362:
  vias: v2(136.4,214.44)
N18020410:
  vias: v2(142.49,214.44)
N18020456:
  vias: v2(145.54,214.44)
N18023785:
  vias: v3(154.69,214.44)
N18023927:
  vias: v3(157.73,214.44)
N18024322:
  vias: v3(148.54,214.42)
N18024422:
  vias: v3(151.64,214.44)
N18053910: length 1.2
  TOP w0.109: R356.2 C686.1
N18056724: length 101.6
  TOP w0.109: v2(181.2,95) R490.1 R494.1
  TOP w0.127: U43.2 180.07,123.64 R485.2 179.74,122.49 v2(179.82,122.41)
  ART03 w0.114: v2(179.82,122.41) 179.55,122.68 175.87,122.68 173.61,120.42 171.74,120.42 v2(171.32,120.84)
  ART05 w0.114: v2(152.37,104.77) 152.65,105.05 160.84,105.05 163.8,102.09 163.8,101.85 164.44,101.22 177.95,101.22 181.2,97.96 v2(181.2,95)
  ART16 w0.114: 183.15,120 184.25,118.9 184.25,114.58 183.84,114.17 183.08,114.17 179.8,110.9 179.8,99.03 181.46,97.38 181.46,95.25 v2(181.2,95)
  ART16 w0.127: 183.15,120 182.23,120 v2(179.82,122.41)
  ART20 w0.114: v2(152.37,104.77) 151.86,104.27 151.86,103.63 150.9,102.67 150.9,100.58 148.49,98.17 148.49,94.23 145.69,91.44 v2(144.63,91.44)
  BOTTOM w0.109: R487.1 v2(144.63,91.44) R480.1
N18062592: length 16.5
  TOP w0.109: v2(165.01,82.41) 164.1,83.31 R371.2
  ART03 w0.114: v2(169.87,91.98) 169.58,91.69 169.58,91.68 169.47,91.57 167.28,91.57 167.07,91.35 167.07,84.52 165.01,82.46 v2(165.01,82.41)
N18062696: length 12.5
  TOP w0.109: v2(163.25,89.66) 163.25,88.27 162.89,87.91 162.35,87.91 161.73,87.29 R375.1
  ART05 w0.114: v2(169.87,92.78) 169.47,92.38 169.47,90.17 169.26,89.97 163.55,89.97 v2(163.25,89.66)
N18062710: length 13
  TOP w0.109: v2(163.19,90.93) 162.68,90.42 159.44,90.42 159.03,90.83 R376.1
  ART05 w0.114: v2(169.07,92.78) 169.07,92.52 168.68,92.12 168.68,90.92 168.54,90.78 163.34,90.78 v2(163.19,90.93)
N18062736: length 10
  TOP w0.109: R377.1 162.46,96.29 163.42,95.33 v6(163.42,93.3)
  ART05 w0.114: v2(169.07,93.58) 168.81,93.58 168.4,93.17 163.55,93.17 v6(163.42,93.3)
N18062750: length 13
  TOP w0.109: R378.1 159.16,91.85 160.1,92.79 161.97,92.79 v2(162.48,92.28)
  ART05 w0.114: v2(169.87,93.58) 169.48,93.19 168.88,93.19 168.67,92.98 168.67,92.55 168.49,92.37 162.98,92.37 162.89,92.28 v2(162.48,92.28)
N18126676: length 1.7
  BOTTOM w0.109: R423.1 Y2.2
N18127220: length 7
  TOP w0.109: J22.1 C809.2
N18127283: length 7
  TOP w0.109: C810.2 J23.1
N18127388: length 1.6
  BOTTOM w0.089: R420.2 86.84,38.31 86.84,37.85 86.73,37.74 U34.4
N18128409: length 9.5
  TOP w0.254: U35.5 164.85,138.91 164.44,139.32 v2(164.44,139.39)
  TOP w0.508: v2(159.04,140.89) 158.39,140.89 158.13,140.63 FB7.2
  ART07 w0.508: v2(159.04,140.89) 160.53,139.39 v2(164.44,139.39)
N18128416: length 5.3
  TOP w0.254: U35.6 164.35,138.64 v2(164.31,138.68)
  TOP w0.508: FB8.2 162.49,140.63 v2(162.5,140.64)
  BOTTOM w0.508: v2(164.31,138.68) 164.18,138.68 162.5,140.37 v2(162.5,140.64)
N18128423: length 2.4
  TOP w0.254: C827.1 169.14,137.03 168.86,136.76 U35.31
N18128430: length 23.8
  TOP w0.254: v2(169.33,131.38) C1592.1 166.85,133.03 U35.24 ; C828.1 161.27,134.26 U35.15
  TOP w0.508: v2(157.58,131.19) 158.28,131.89 FB10.2 160.35,132.87 C828.1
  ART07 w0.508: v2(169.33,131.38) 168.59,131.38 166.88,133.1 163.62,133.1 162.81,133.91 160.3,133.91 v2(157.58,131.19)
N18161324: length 1
  BOTTOM w0.089: R443.1 v2(161.45,27.94)
N18161585: length 2.4
  TOP w0.109: X2.1 154.36,101.85 R438.1
N18161617: length 2.3
  TOP w0.109: R441.2 X2.3
N18161939: length 6
  BOTTOM w0.089: v2(56.83,110.06) 56.83,110.3 56.69,110.44 56.32,110.44 56.24,110.36 56.24,109.33 56.94,108.63 56.94,107.31 56.42,106.79 56.13,106.79 R451.1
N18163063: length 3
  TOP w0.109: R515.2 R514.1 32.36,192.72 U48.13
N18164181: length 56.6
  ART03 w0.114: v2(11.53,181.95) 13.79,179.69 13.79,171.07 11.45,168.73 11.45,138.45 13.31,136.6 17.64,136.6 SW8.4 SW8.1
N18167209: length 2.1
  TOP w0.109: D38.2 190.88,215.49 v2(190.93,215.54)
  BOTTOM w0.109: v2(190.93,215.54) 190.98,215.5 R541.1
N18195244:
  vias: v2(174.34,148.14)
N18195269:
  vias: v2(177.39,148.14)
N18195294:
  vias: v2(180.44,148.14)
N18195319:
  vias: v2(183.49,148.14)
N18195394:
  vias: v2(189.61,148.14)
N18195419:
  vias: v2(192.66,148.14)
N18253290: length 7.3
  BOTTOM w0.254: U33.16 27.74,51.82 27.86,51.69 28.5,51.69 29.52,50.67 30.43,50.67 30.51,50.74 30.51,50.74 C1866.2 31.05,50.91 31.34,50.62 32.42,50.62 R5295.2
N18253296: length 8.5
  BOTTOM w0.254: R5297.2 32.45,47.96 31.55,47.96 31.05,48.45 C1868.2 30.44,47.98 29.64,47.98 28.5,49.12 28.5,50.19 27.87,50.82 U33.18
N18253303: length 3.9
  BOTTOM w0.254: U33.20 26.63,48.81 27.69,47.75 27.69,47.41 C1870.2 28.02,47.08 28.02,46.19 R5299.2
N18253309: length 4.4
  BOTTOM w0.254: U33.22 25.63,49.4 25.63,48.72 25.51,48.6 25.5,48.6 24.94,48.03 24.46,48.03 24.13,47.7 24.13,47.41 C1872.2 24.43,47.08 R5301.2
N18253428: length 7
  BOTTOM w0.254: R5296.2 32.52,50.24 31.45,50.24 31.05,49.85 C1867.2 30.44,50.29 29.36,50.29 28.35,51.31 27.29,51.31 U33.17
N18253441: length 8.4
  BOTTOM w0.254: U33.19 27.29,50.31 27.84,50.31 28.12,50.03 28.12,48.97 29.48,47.6 30.44,47.6 C1869.2 31.05,47.16 31.47,47.57 32.5,47.57 R5298.2
N18253449: length 3.9
  BOTTOM w0.254: R5300.2 27.13,46.22 27.13,47.08 C1871.2 27.28,47.23 27.28,47.62 26.12,48.78 26.12,49.41 U33.21
N18253452: length 4.3
  BOTTOM w0.254: U33.23 25.13,48.76 24.78,48.41 24.3,48.41 23.75,47.86 23.75,47.31 C1873.2 23.52,47.08 R5302.2
N18402226: length 1.2
  BOTTOM w0.109: R408.2 19.25,52.32 U33.36
N18402261: length 2
  TOP w0.109: U31.11 171.69,109.22 171.61,109.14 171.27,109.14 171.19,109.22 U31.10
N18402270: length 2.2
  TOP w0.109: U31.13 173.06,110.64 173.17,110.53 173.17,110.08 172.69,109.6 172.3,109.6 172.19,109.71 U31.12
N18402344: length 1.3
  BOTTOM w0.089: C815.1 86.84,40.21 86.84,39.93 R420.1
N18402365: length 1.3
  BOTTOM w0.089: R421.1 87.12,39.93 87.12,40.21 C816.1
N18403594: length 47.7
  ART20 w0.094: v2(177.67,20.83) 177.23,20.83 177.14,20.73 177.14,19.94 177.52,19.56 178.15,19.56 179.04,20.45 179.04,38.94 180.49,40.39 187.29,40.39 189.46,42.55 189.46,48.42 190.55,49.51 190.55,54.37 190.76,54.58 191.08,54.58 v2(191.49,54.99)
N18403603: length 48
  ART20 w0.094: v2(191.49,53.98) 191.08,54.38 190.85,54.38 190.75,54.29 190.75,49.43 189.66,48.34 189.66,42.47 187.37,40.18 180.57,40.18 179.25,38.85 179.25,20.36 178.24,19.35 177.43,19.35 176.94,19.85 176.94,20.73 176.84,20.83 v2(176.4,20.83)
N18514026: length 1.3
  TOP w0.109: R469.2 R915.2
N18524153: length 3.1
  TOP w0.089: C875.1 190.42,54.63 188.78,54.63 188.67,54.74 188.41,54.74 188.27,54.88 U38.54
N18524156: length 3
  TOP w0.089: U38.53 188.34,54.38 188.4,54.45 188.55,54.45 188.66,54.34 190.42,54.34 C876.1
N18602357: length 1.4
  BOTTOM w0.089: R414.1 81.49,34.81 81.07,34.81 v2(80.71,35.18)
N18602360: length 1.4
  BOTTOM w0.089: R413.1 81.49,34.53 81.07,34.53 v2(80.71,34.16)
N18602409: length 1
  BOTTOM w0.089: R439.1 v2(161.45,34.29)
N18602412: length 1
  BOTTOM w0.089: R440.1 v2(161.45,33.02)
N18606410: length 1
  BOTTOM w0.089: R442.1 v2(161.45,29.21)
N18606472: length 6.1
  BOTTOM w0.089: v2(56.83,111.33) 56.83,111.11 56.45,110.73 56.21,110.73 55.95,110.47 55.95,109.21 56.65,108.51 56.65,107.43 56.31,107.08 56.13,107.08 R450.1
N18609511: length 31.7
  TOP w0.109: R909.2 173.58,61.47 v2(172.92,60.81)
  BOTTOM w0.109: v2(172.92,60.81) 169.36,60.81 167.87,59.31 167.87,53.34 169.75,51.46 169.75,35.64 v2(169.54,35.43)
N18623017: length 8.1
  TOP w0.089: R44.1 R38.2
  TOP w0.109: R38.2 J4.1
N18624288: length 7
  TOP w0.109: J3.1 v2(131.64,6.73)
N18624358: length 7
  TOP w0.109: J2.1 v2(132.52,6.73)
N18624759: length 8.1
  TOP w0.089: R35.1 R38.1
  TOP w0.109: R38.1 J1.1
N18630621: length 3.7
  BOTTOM w0.109: R502.2 R505.1 U44.7
N18669847: length 7.1
  TOP w0.109: J31.1 R463.1 R467.2
N18693741: length 4.1
  BOTTOM w0.114: v2(171.47,95.18) 171.04,95.61 171.04,98.59 R981.1
N18765279: length 12.6
  TOP w0.254: U48.12 32.86,192.03 32.74,192.15 32.74,193.1 v2(32.87,193.23)
  TOP w0.508: R519.2 v2(36.42,185.99)
  BOTTOM w0.381: v2(32.87,193.23) 34.45,193.23 34.83,192.85 34.83,192.2 36.42,190.61 v2(36.42,185.99)
N18905531:
  vias: v2(184.28,214.44)
N18905534: length 0.1
  TOP w0.109: D8.2 v2(180.97,214.55)
  BOTTOM w0.109: v2(180.97,214.55) R285.2
N18905537: length 0.1
  TOP w0.109: D9.2 v2(177.67,214.55)
  BOTTOM w0.109: v2(177.67,214.55) R286.2
N18905540: length 0.1
  TOP w0.109: D10.2 v2(174.37,214.55)
  BOTTOM w0.109: v2(174.37,214.55) R287.2
N18905543:
  vias: v2(171.07,214.44)
N18905546:
  vias: v2(167.77,214.44)
N18905549:
  vias: v2(164.47,214.44)
N18905552:
  vias: v2(161.16,214.44)
N18905648: length 17.1
  TOP w0.109: U18.A7 168.85,209.42 176.78,209.42 177.55,210.19 182.94,210.19 D7.1
N18905651: length 14.3
  TOP w0.109: D8.1 179.9,210.44 177.29,210.44 176.53,209.68 176.53,209.68 168.6,209.68 U18.A5
N18905652: length 11.5
  TOP w0.109: U18.A3 168.35,209.93 176.09,209.93 D9.1
N18905655: length 8.7
  TOP w0.109: U18.A1 168.11,210.19 173.04,210.19 D10.1
N18905658: length 10.9
  TOP w0.109: D11.1 169.99,210.44 167.13,210.44 166.5,209.8 161.8,209.8 161.53,209.54 U19.A7
N18905661: length 8.3
  TOP w0.109: D12.1 166.31,210.06 161.29,210.06 161.03,209.8 U19.A5
N18905664: length 5.6
  TOP w0.109: U19.A3 160.53,210.06 160.91,210.44 163.39,210.44 D13.1
N18905667: length 3
  TOP w0.109: D14.1 160.03,210.39 U19.A1
N18946338: length 1.6
  TOP w0.089: R461.1 175.87,52.26 175.52,52.26 C869.1
N18946341: length 1.6
  TOP w0.089: C870.1 175.49,51.98 175.93,51.98 R462.1
N18946378: length 1.5
  TOP w0.089: C874.1 192.47,52.48 191.93,52.48 R466.1
N18946381: length 1.6
  TOP w0.089: R465.1 191.96,52.2 192.44,52.2 C873.1
N18946492: length 7
  TOP w0.109: J6.1 70.71,36.73 C9.2
N18946522: length 7
  TOP w0.109: C10.2 55.78,36.73 J7.1
N18947324: length 1.3
  BOTTOM w0.089: C817.1 93.11,34.18 93.4,34.18 R427.1
N18947380: length 1.3
  BOTTOM w0.089: R426.1 93.4,33.89 93.11,33.89 C818.1
N18990186: length 4.1
  BOTTOM w0.109: J20.4 191.3,137.22 192.61,137.22 192.76,137.07 R401.2
N18990548: length 6
  BOTTOM w0.109: R402.1 188.21,137.77 J20.3
N18990901: length 6.1
  BOTTOM w0.109: R404.1 14.39,114.89 13.58,115.7 13.58,115.83 13.59,115.83 13.59,118.26 J21.3
N18990913: length 5.3
  BOTTOM w0.109: J21.4 12.67,114.72 R403.2
N18991424: length 1.7
  BOTTOM w0.254: U32.29 42.06,48.22 C802.2
N19408572: length 3.2
  TOP w0.305: V2.2 28.93,192.79 29.56,192.15 30.58,192.15 30.86,191.87 U48.16
N19408581: length 3.1
  TOP w0.305: V3.2 29.69,192.84 29.87,192.66 30.96,192.66 31.36,192.26 U48.15
N19408803: length 9.7
  TOP w0.305: 30.58,202.83 29.87,202.83 29.69,202.65 V3.1
  vias: v5(32.36,212.09) v5(32.36,209.55) v5(32.36,207.26) v5(32.36,205.1) v5(32.36,202.69) v5(32.36,200.02) v5(32.36,197.74) v5(32.36,195.58) v5(35.53,212.09) v5(35.53,209.55) v5(35.53,207.26) v5(35.53,205.1) v5(35.53,200.02) v5(35.53,197.74) v5(35.53,195.58)
N19548147: length 28.9
  ART16 w0.114: v2(188.4,62.23) 189.36,62.23 190.63,60.96 190.63,57.29 190.92,57 190.92,44.11 190.5,43.69 190.5,40.04 191.35,39.19 v2(191.35,35.43)
N19604200: length 8.3
  TOP w0.279: U38.38 v2(182.27,50.34)
  BOTTOM w0.508: C854.1 179.74,45.4 180.69,46.35 180.69,48.18 182.27,49.75 v2(182.27,50.34)
N19604697: length 2.2
  TOP w0.089: R461.2 177.57,52.33 177.89,52.33 178.29,52.73 178.67,52.73 178.82,52.88 U38.31
N19994036: length 67
  TOP w0.109: R1053.2 191.93,57.63 193.25,57.63 v2(193.66,58.04)
  ART20 w0.114: v2(193.66,58.04) 194.28,57.42 194.28,43.05 190.6,39.37 181.46,39.37 180.31,38.23 180.31,15.75 184.53,11.53 v2(184.53,6.73)
N19994522: length 1.8
  TOP w0.109: C896.1 174.34,60.51 174.34,61.02 R909.1
N20035658: length 13
  TOP w0.508: L40.2 C1334.1 C1333.1 C1335.2 ; U80.4 172.18,72.14 170.53,73.79 C1335.2 ; C1335.2 R916.1
N20035742: length 5.2
  TOP w0.508: R919.1 R916.2 167.93,70.59 U80.1
N20035757: length 3.7
  TOP w0.109: U80.3 172.5,64.71 R917.2
N20035759: length 1.4
  TOP w0.109: R917.1 C1336.2
N20209521: length 1.7
  BOTTOM w0.109: R918.1 Y2.1
N20307193: length 3.7
  BOTTOM w0.109: C1409.2 R294.2 ; R294.2 33.26,154.51 U22.3 ; R294.2 R922.1
N20316908: length 3.8
  TOP w0.109: R236.2 211.98,20.65 v2(211.3,20.65) J14.B6
  BOTTOM w0.109: R236.2 211.98,20.65 v2(211.3,20.65)
N20316912: length 3.7
  TOP w0.109: R235.2 212.06,19.65 v2(211.3,19.65) J14.B5
  BOTTOM w0.109: R235.2 212.06,19.65 v2(211.3,19.65)
N20436774:
  vias: v2(186.54,148.14)
N20439947: length 6.9
  TOP w0.109: J28.1 R941.1
N20439969: length 6.9
  TOP w0.109: J30.1 R942.1
N20550259: length 1.5
  TOP w0.089: R458.1 191.78,56.36 192.32,56.36 v2(192.67,56.01)
N20550288: length 2.8
  TOP w0.089: R458.2 190.03,56.51 188.57,56.51 188.44,56.38 U38.57
N20550319: length 2.7
  TOP w0.089: U38.58 188.45,56.88 188.57,56.77 190.28,56.77 R459.2
N20550321: length 1.6
  TOP w0.089: v2(192.69,57.02) 192.31,56.64 191.81,56.64 R459.1
