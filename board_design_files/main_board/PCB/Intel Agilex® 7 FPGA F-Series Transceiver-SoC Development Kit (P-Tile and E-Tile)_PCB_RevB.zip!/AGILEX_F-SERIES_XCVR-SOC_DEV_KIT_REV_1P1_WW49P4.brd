# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MXP_RXP1: length 66.4
  ART05 w0.097: 84.93,109.98 84.95,109.98 84.98,110.01 85.43,110.01 arc(85.58,109.94) 85.7,109.81 85.7,109.8 arc(85.92,109.58) 86.21,109.51 86.22,109.51 arc(86.42,109.45) 86.56,109.3 86.57,109.3 arc(86.78,109.08) 87.08,109.01 87.08,109.01 arc(87.28,108.95) 87.43,108.8 87.43,108.8 arc(87.65,108.58) 87.95,108.51 87.95,108.51 arc(88.15,108.45) 88.3,108.3 88.3,108.3 arc(88.52,108.08) 88.81,108.01 arc(89.01,107.95) 89.16,107.8 89.16,107.8 arc(89.38,107.58) 89.68,107.51 arc(89.88,107.45) 90.03,107.3 90.03,107.3 arc(90.25,107.08) 90.54,107.01 arc(90.74,106.95) 90.89,106.81 90.9,106.8 arc(91.11,106.58) 91.41,106.51 arc(91.7,106.58) 91.92,106.8 91.92,106.8 arc(92.07,106.95) 92.27,107.01 92.28,107.01 arc(92.57,107.08) 92.79,107.3 92.79,107.31 arc(92.94,107.45) 93.14,107.51 arc(93.34,107.45) 93.49,107.31 93.49,107.3 arc(93.55,107.13) 93.52,106.96 93.43,106.93 93.14,107.1
  ART05 w0.109: 41.15,123.34 40.94,123.55 40.94,123.94 arc(41.01,124.28) 41.21,124.57 41.32,124.69 arc(41.51,124.82) 41.74,124.86 42.11,124.86 42.23,124.74 42.45,124.74 42.57,124.86 43.08,124.86 43.2,124.74 43.42,124.74 43.54,124.86 43.76,124.86 43.88,124.74 44.1,124.74 44.22,124.86 44.44,124.86 44.56,124.74 44.78,124.74 44.9,124.86 60.14,124.86 arc(62.73,124.35) 64.92,122.88 70.14,117.66 arc(70.67,116.87) 70.86,115.93 70.86,113.81 arc(71.02,113) 71.48,112.31 71.51,112.28 arc(71.92,112) 72.41,111.91 77.96,111.91 78.08,111.78 78.3,111.78 78.42,111.91 78.64,111.91 78.76,111.78 78.98,111.78 79.1,111.91 79.32,111.91 79.44,111.78 79.66,111.78 79.78,111.91 80.13,111.91 arc(81.03,111.73) 81.79,111.22 82.04,110.97 arc(83.13,110.24) 84.43,109.98 84.93,109.98
  ART05 w0.122: J13.5 41.15,123.34
MXP_RXP2: length 56.7
  ART07 w0.097: 84.97,108.98 85,108.98 85.02,109.01 85.46,109.01 arc(85.6,108.93) 85.7,108.81 85.7,108.8 arc(85.92,108.58) 86.21,108.51 86.22,108.51 arc(86.42,108.45) 86.56,108.3 86.57,108.3 arc(86.78,108.08) 87.08,108.01 arc(87.37,108.08) 87.59,108.3 87.59,108.3 arc(87.74,108.45) 87.94,108.51 87.95,108.51 arc(88.15,108.45) 88.3,108.3 88.3,108.3 arc(88.52,108.08) 88.81,108.01 arc(89.01,107.95) 89.16,107.8 89.16,107.8 arc(89.22,107.6) 89.16,107.4 89.16,107.4 arc(89.08,107.1) 89.16,106.8 89.16,106.8 arc(89.38,106.58) 89.68,106.51 89.68,106.51 arc(89.88,106.45) 90.03,106.3 90.03,106.3 arc(90.25,106.08) 90.54,106.01 arc(90.72,105.97) 90.86,105.86 90.83,105.77 U1.AP7
  ART07 w0.109: 84.97,108.98 84.75,108.98 84.63,108.86 84.41,108.86 84.29,108.98 84.07,108.98 83.95,108.86 83.73,108.86 83.61,108.98 82.29,108.98 arc(81.97,109.05) 81.7,109.22 80.76,110.17 arc(79.96,110.7) 79.02,110.89 74.84,110.89 arc(73.35,111.19) 72.1,112.03 71.54,112.58 71.03,113.09 arc(70.72,113.56) 70.6,114.12 70.6,116.02 arc(70.31,117.51) 69.47,118.77 64.67,123.56 arc(62.7,124.88) 60.36,125.35 52.07,125.35 51.94,125.23 51.73,125.23 51.6,125.35 51.39,125.35 51.26,125.23 51.05,125.23 50.92,125.35 50.7,125.35 50.58,125.23 50.36,125.23 50.24,125.35 50.02,125.35 arc(49.66,125.28) 49.35,125.07 arc(49.03,124.59) 48.92,124.03 48.92,123.6 49.18,123.34
  ART07 w0.122: J13.3 49.18,123.34
MXP_RXP3: length 48.9
  ART05 w0.097: 93.14,105.1 93.43,104.93 93.45,104.84 arc(93.31,104.73) 93.14,104.69 93.1,104.69 arc(92.93,104.74) 92.81,104.86 92.79,104.9 arc(92.57,105.11) 92.28,105.19 arc(91.99,105.12) 91.79,104.91 91.78,104.9 arc(91.63,104.75) 91.43,104.69 91.41,104.69 arc(91.21,104.75) 91.06,104.89 91.06,104.9 arc(91.06,104.9) 91.05,104.9 arc(90.84,105.12) 90.54,105.19 90.46,105.19 arc(90.34,105.23) 90.24,105.31 90.16,105.44 arc(90.05,105.55) 89.91,105.63 arc(89.84,105.65) 89.77,105.66 89.66,105.67 arc(89.48,105.73) 89.34,105.87 89.32,105.9 89.32,105.9 arc(89.32,105.91) 89.31,105.92 89.31,105.93 arc(89.09,106.12) 88.81,106.19 88.8,106.19 arc(88.5,106.11) 88.29,105.9 88.28,105.89 arc(88.14,105.75) 87.95,105.69 arc(87.74,105.75) 87.6,105.89 87.57,105.94 arc(87.53,106.1) 87.57,106.26 87.59,106.3 arc(87.67,106.6) 87.59,106.9 arc(87.54,107.1) 87.59,107.3 87.6,107.31 arc(87.67,107.6) 87.59,107.9 87.59,107.9 arc(87.37,108.12) 87.08,108.19 arc(86.88,108.25) 86.73,108.39 86.67,108.5 arc(86.53,108.64) 86.33,108.69 86.21,108.69 arc(86.01,108.75) 85.86,108.89 85.86,108.9 arc(85.65,109.11) 85.35,109.19 85.27,109.19 85.24,109.22
  ART05 w0.109: 57.22,123.34 56.97,123.09 56.97,122.63 arc(56.99,122.56) 57.03,122.5 58.18,121.34 arc(58.24,121.3) 58.32,121.29 58.72,121.29 arc(59.77,121.08) 60.67,120.48 60.88,120.27 61.06,120.27 61.21,120.11 61.21,119.94 61.37,119.78 61.54,119.78 61.69,119.63 61.69,119.46 61.85,119.3 62.02,119.3 62.17,119.15 62.17,118.98 68.45,112.7 69.07,112.14 arc(70.57,111.22) 72.3,110.9 78.34,110.9 78.46,111.02 78.68,111.02 78.8,110.9 79.02,110.9 79.14,111.02 79.36,111.02 79.48,110.9 79.7,110.9 79.82,111.02 80.04,111.02 80.16,110.9 80.4,110.9 arc(80.85,110.81) 81.24,110.55 81.86,109.93 arc(82.65,109.4) 83.58,109.22 85.24,109.22
  ART05 w0.122: J13.1 57.22,123.34
MXP_TXN0: length 63
  ART07 w0.097: 84.97,108.22 85,108.22 85.02,108.19 85.35,108.19 arc(85.6,108.14) 85.8,107.98 arc(85.81,107.97) 85.82,107.96 85.93,107.93 U1.AJ2
  ART07 w0.109: 32.44,119.34 32.71,119.61 32.71,120.62 arc(32.78,120.92) 32.95,121.19 arc(33.18,121.34) 33.44,121.39 34.93,121.39 arc(35,121.4) 35.05,121.44 35.93,122.32 arc(36.33,122.59) 36.8,122.68 37.01,122.68 arc(37.4,122.6) 37.74,122.38 38.12,122 arc(38.77,121.56) 39.53,121.41 42.2,121.41 arc(43.08,121.24) 43.83,120.74 44.46,120.1 arc(44.81,119.58) 44.93,118.97 arc(45,118.64) 45.18,118.37 45.41,118.13 arc(46.03,117.72) 46.75,117.58 58.17,117.58 arc(61.68,116.88) 64.65,114.9 66.07,113.48 arc(66.85,112.96) 67.76,112.78 68.58,112.78 arc(69.49,112.59) 70.27,112.07 71.28,111.06 arc(72.62,110.17) 74.2,109.85 78.74,109.85 arc(79.49,109.7) 80.12,109.28 80.41,108.99 80.98,108.43 arc(81.37,108.13) 81.83,107.96 arc(81.89,107.95) 81.94,107.95 83.66,107.95 arc(83.72,107.96) 83.77,107.98 arc(83.82,108.01) 83.87,108.05 arc(84.05,108.17) 84.27,108.22 84.97,108.22
  ART07 w0.122: J13.9 32.44,119.34
MXP_TXN1: length 55.8
  ART07 w0.097: 84.97,106.98 85,106.98 85.02,107.01 85.35,107.01 arc(85.49,106.98) 85.61,106.91 arc(85.66,106.86) 85.7,106.81 85.7,106.8 arc(85.91,106.59) 86.21,106.51 86.22,106.51 arc(86.51,106.59) 86.73,106.8 86.73,106.81 arc(87.08,107.01) 87.43,106.81 87.43,106.8 arc(87.65,106.59) 87.94,106.51 87.95,106.51 arc(88.2,106.56) 88.4,106.72 arc(88.41,106.73) 88.41,106.74 88.52,106.77 U1.AM5
  ART07 w0.109: 40.51,119.34 40.74,119.11 40.74,118.46 arc(40.87,117.81) 41.24,117.26 41.59,116.91 arc(42.65,116.2) 43.9,115.95 56.59,115.95 arc(59.36,115.4) 61.7,113.83 62.27,113.27 62.84,112.7 arc(64.02,111.91) 65.41,111.63 68.3,111.63 arc(68.46,111.6) 68.6,111.5 70.33,109.78 arc(71.91,108.72) 73.78,108.35 78.8,108.35 arc(79.41,108.23) 79.92,107.88 81,106.81 arc(81.04,106.77) 81.09,106.73 arc(81.11,106.72) 81.14,106.7 arc(81.14,106.7) 81.14,106.7 arc(81.36,106.61) 81.6,106.58 83.95,106.58 arc(84.09,106.6) 84.22,106.67 84.62,106.95 arc(84.67,106.97) 84.72,106.98 84.97,106.98
  ART07 w0.122: J13.11 40.51,119.34
MXP_TXN2: length 48.6
  ART05 w0.097: 84.92,106.22 84.95,106.22 84.97,106.19 85.35,106.19 arc(85.6,106.14) 85.8,105.98 arc(85.81,105.97) 85.82,105.96 85.93,105.93 U1.AN2
  ART05 w0.109: 84.92,106.22 82.26,106.22 arc(82.02,106.26) 81.81,106.4 80.34,107.87 arc(79.92,108.16) 79.42,108.25 70.14,108.25 arc(69.71,108.17) 69.34,107.92 arc(68.95,107.66) 68.48,107.57 65.76,107.57 arc(64.47,107.82) 63.37,108.56 53.28,118.65 arc(53.12,118.9) 53.06,119.19 53.06,120.48 arc(53.05,120.6) 53.03,120.72 arc(53,120.87) 52.91,121.01 52.75,121.16 arc(52.53,121.31) 52.27,121.36 49.5,121.36 arc(49.22,121.31) 48.98,121.15 arc(48.8,120.87) 48.74,120.56 48.74,119.57 48.51,119.34
  ART05 w0.122: J13.13 48.51,119.34
MXP_TXN3: length 42.7
  ART05 w0.097: U1.AT5 88.52,104.77 88.41,104.74 arc(88.41,104.73) 88.4,104.72 arc(88.2,104.56) 87.95,104.51 87.93,104.51 arc(87.67,104.57) 87.47,104.74 87.42,104.82 arc(87.29,104.93) 87.13,104.99 87.04,104.99 arc(86.82,105.06) 86.64,105.2 86.62,105.22 arc(86.57,105.29) 86.54,105.38 86.51,105.49 arc(86.5,105.55) 86.51,105.6 86.52,105.72 arc(86.53,105.76) 86.54,105.8 arc(86.55,105.86) 86.58,105.93 arc(86.56,106.32) 86.22,106.51 86.21,106.51 arc(85.92,106.58) 85.7,106.8 85.7,106.81 arc(85.55,106.95) 85.35,107.01 85.08,107.01 85.06,106.98 85.05,106.98
  ART05 w0.109: 56.43,119.34 56.69,119.08 56.69,116.93 arc(56.8,116.35) 57.13,115.87 64.03,108.96 arc(64.73,108.49) 65.56,108.33 67.88,108.33 arc(68.55,108.46) 69.11,108.84 arc(69.39,109.02) 69.71,109.09 79.97,109.09 arc(80.32,109.02) 80.61,108.82 82.28,107.15 arc(82.47,107.03) 82.69,106.98 85.05,106.98
  ART05 w0.122: 56.43,119.34 J13.15
MXP_TXP0: length 63
  ART07 w0.097: U1.AK1 85.63,107.77 85.66,107.86 arc(85.52,107.97) 85.35,108.01 85.02,108.01 85,107.98 84.97,107.98
  ART07 w0.109: 84.97,107.98 84.27,107.98 arc(84.14,107.96) 84.03,107.89 arc(83.96,107.82) 83.88,107.77 arc(83.78,107.73) 83.66,107.72 83.45,107.72 83.32,107.59 83.11,107.59 82.98,107.72 82.76,107.72 82.64,107.59 82.42,107.59 82.3,107.72 81.94,107.72 arc(81.86,107.72) 81.78,107.73 arc(81.26,107.93) 80.81,108.26 79.96,109.11 arc(79.4,109.49) 78.74,109.62 74.2,109.62 arc(72.53,109.95) 71.12,110.9 70.43,111.58 70.1,111.91 arc(69.4,112.38) 68.58,112.54 67.76,112.54 arc(66.76,112.74) 65.91,113.31 65.28,113.94 64.49,114.73 arc(61.59,116.67) 58.17,117.35 46.75,117.35 arc(45.94,117.51) 45.25,117.97 45.02,118.2 arc(44.78,118.55) 44.7,118.97 arc(44.59,119.49) 44.3,119.93 44.05,120.18 43.66,120.57 arc(42.99,121.02) 42.2,121.18 39.53,121.18 arc(38.68,121.35) 37.96,121.83 37.74,122.05 37.58,122.21 arc(37.31,122.39) 37.01,122.45 36.8,122.45 arc(36.42,122.37) 36.1,122.16 35.7,121.76 35.7,121.58 35.55,121.43 35.37,121.43 35.22,121.28 arc(35.09,121.19) 34.93,121.16 34.13,121.16 34,121.04 33.78,121.04 33.66,121.16 33.44,121.16 arc(33.27,121.12) 33.12,121.02 arc(32.99,120.84) 32.95,120.62 32.95,120.46 33.07,120.34 33.07,120.12 32.95,120 32.95,119.59 33.2,119.34
  ART07 w0.122: J13.10 33.2,119.34
MXP_TXP1: length 55.8
  ART07 w0.097: 87.94,107.1 88.23,106.93 88.26,106.84 arc(88.12,106.73) 87.94,106.69 arc(87.74,106.75) 87.6,106.89 87.59,106.9 arc(87.38,107.11) 87.08,107.19 87.08,107.19 arc(86.78,107.11) 86.56,106.9 86.56,106.89 arc(86.41,106.75) 86.21,106.69 arc(86.01,106.75) 85.86,106.89 85.86,106.9 arc(85.8,106.98) 85.73,107.05 arc(85.55,107.16) 85.35,107.19 85.02,107.19 85,107.22 84.97,107.22
  ART07 w0.109: 84.97,107.22 84.72,107.22 arc(84.6,107.2) 84.48,107.14 84.09,106.86 arc(84.02,106.82) 83.95,106.81 83.73,106.81 83.61,106.93 83.39,106.93 83.27,106.81 83.05,106.81 82.93,106.93 82.71,106.93 82.59,106.81 82.35,106.81 82.23,106.93 82.01,106.93 81.89,106.81 81.6,106.81 arc(81.42,106.83) 81.26,106.9 81.25,106.9 arc(81.24,106.91) 81.22,106.92 arc(81.19,106.95) 81.17,106.97 80.09,108.05 arc(79.5,108.44) 78.8,108.58 73.78,108.58 arc(72,108.94) 70.5,109.94 68.77,111.67 arc(68.55,111.81) 68.3,111.87 65.41,111.87 arc(64.11,112.13) 63,112.86 61.97,113.89 61.87,114 arc(59.45,115.62) 56.59,116.18 45.99,116.18 45.87,116.31 45.65,116.31 45.53,116.18 45.31,116.18 45.19,116.31 44.97,116.31 44.85,116.18 44.63,116.18 44.51,116.31 44.29,116.31 44.17,116.18 43.9,116.18 arc(42.74,116.41) 41.76,117.07 41.4,117.42 arc(41.09,117.9) 40.97,118.46 40.97,119.08 41.23,119.34
  ART07 w0.122: J13.12 41.23,119.34
MXP_TXP2: length 48.6
  ART05 w0.097: 84.92,105.98 84.95,105.98 84.97,106.01 85.35,106.01 arc(85.52,105.97) 85.66,105.86 85.63,105.77 U1.AP1
  ART05 w0.109: 49.22,119.34 48.97,119.58 48.97,120.56 arc(49.02,120.79) 49.15,120.98 arc(49.31,121.09) 49.5,121.13 49.72,121.13 49.85,121.01 50.06,121.01 50.19,121.13 50.4,121.13 50.53,121.01 50.74,121.01 50.87,121.13 51.08,121.13 51.21,121.01 51.42,121.01 51.55,121.13 52.27,121.13 arc(52.44,121.09) 52.59,121 52.63,120.95 arc(52.73,120.82) 52.8,120.66 arc(52.82,120.57) 52.82,120.48 52.82,119.19 arc(52.9,118.81) 53.12,118.48 55.14,116.46 62.96,108.63 63.21,108.39 arc(64.38,107.61) 65.76,107.33 68.48,107.33 arc(69.03,107.44) 69.5,107.76 arc(69.79,107.95) 70.14,108.02 79.42,108.02 arc(79.83,107.94) 80.17,107.71 81.65,106.24 arc(81.93,106.05) 82.26,105.98 82.88,105.98 83,105.86 83.22,105.86 83.34,105.98 83.56,105.98 83.68,105.86 83.9,105.86 84.02,105.98 84.24,105.98 84.36,105.86 84.58,105.86 84.7,105.98 84.92,105.98
  ART05 w0.122: J13.14 49.22,119.34
MXP_TXP3: length 42.7
  ART05 w0.097: 87.94,105.1 88.23,104.93 88.26,104.84 arc(88.12,104.73) 87.95,104.69 87.93,104.69 arc(87.76,104.73) 87.62,104.85 87.57,104.93 arc(87.39,105.1) 87.15,105.17 87.05,105.18 arc(86.9,105.23) 86.78,105.32 86.77,105.34 arc(86.74,105.38) 86.72,105.43 86.69,105.54 arc(86.69,105.56) 86.69,105.58 86.71,105.69 arc(86.71,105.72) 86.72,105.76 arc(86.73,105.8) 86.75,105.85 arc(86.72,106.42) 86.22,106.69 86.21,106.69 arc(86.01,106.75) 85.86,106.89 85.86,106.9 arc(85.64,107.12) 85.35,107.19 85.1,107.19 85.07,107.22 85.05,107.22
  ART05 w0.109: 57.23,119.34 56.92,119.02 56.92,116.93 arc(57.02,116.44) 57.29,116.04 57.68,115.64 57.86,115.64 58.01,115.49 58.01,115.32 58.16,115.16 58.34,115.16 58.49,115.01 58.49,114.83 58.65,114.68 58.82,114.68 58.97,114.53 58.97,114.35 64.2,109.13 arc(64.82,108.71) 65.56,108.56 67.88,108.56 arc(68.46,108.68) 68.95,109 arc(69.3,109.24) 69.71,109.32 79.97,109.32 arc(80.41,109.23) 80.78,108.99 80.95,108.81 82.45,107.31 arc(82.56,107.24) 82.69,107.22 83.49,107.22 83.61,107.34 83.83,107.34 83.95,107.22 84.17,107.22 84.29,107.34 84.51,107.34 84.64,107.22 85.05,107.22
  ART05 w0.122: 57.23,119.34 J13.16
Net_2:
  vias: v1(209.17,188.72)
Net_144: length 0.6
  TOP w0.109: v2(34.73,165.52) 35.14,165.92
Net_456:
  vias: v2(125.18,116.6)
Net_457:
  vias: v2(125.18,115.6)
Net_498:
  vias: v2(169.07,91.98)
Net_506:
  vias: v2(131.25,114.1)
Net_515:
  vias: v2(113.92,116.1)
Net_523:
  vias: v2(120.85,117.1)
Net_524:
  vias: v2(120.85,116.1)
Net_525:
  vias: v2(114.79,116.6)
Net_526:
  vias: v2(114.79,115.6)
Net_527:
  vias: v2(121.72,116.6)
Net_528:
  vias: v2(121.72,115.6)
Net_529:
  vias: v2(131.25,86.1)
Net_530:
  vias: v2(131.25,87.1)
Net_531:
  vias: v2(132.11,86.6)
Net_532:
  vias: v2(130.38,88.6)
Net_533:
  vias: v2(100.07,84.1)
Net_534:
  vias: v2(100.07,85.1)
Net_537:
  vias: v2(87.95,82.1)
Net_538:
  vias: v2(85.35,83.6)
Net_539:
  vias: v2(91.41,84.1)
Net_540:
  vias: v2(131.25,116.1)
Net_556:
  vias: v2(135.57,114.6)
Net_557:
  vias: v2(134.71,113.1)
Net_558:
  vias: v2(134.71,114.1)
Net_559:
  vias: v2(133.84,114.6)
Net_560:
  vias: v2(132.98,113.1)
Net_561:
  vias: v2(132.98,114.1)
Net_562:
  vias: v2(132.11,113.6)
Net_563:
  vias: v2(132.11,114.6)
Net_564:
  vias: v2(131.25,113.1)
Net_565:
  vias: v2(135.57,115.6)
Net_566:
  vias: v2(135.57,116.6)
Net_567:
  vias: v2(134.71,116.1)
Net_1275:
  vias: v2(91.41,87.1)
Net_1276:
  vias: v2(91.41,86.1)
Net_1277:
  vias: v2(93.14,84.1)
Net_1278:
  vias: v2(91.41,82.1)
Net_1279:
  vias: v2(91.41,81.1)
Net_1282:
  vias: v2(95.74,84.6)
Net_1283:
  vias: v2(95.74,83.6)
Net_1285:
  vias: v2(96.6,84.1)
Net_1288:
  vias: v2(93.14,82.1)
Net_1289:
  vias: v2(93.14,81.1)
Net_1292:
  vias: v2(94.87,82.1)
Net_1293:
  vias: v2(94.87,81.1)
Net_1294:
  vias: v2(95.74,82.6)
Net_1295:
  vias: v2(95.74,81.6)
Net_1296:
  vias: v2(96.6,82.1)
Net_1300:
  vias: v2(87.08,89.6)
Net_1301:
  vias: v2(87.08,88.6)
Net_1302:
  vias: v2(87.95,90.1)
Net_1303:
  vias: v2(87.95,89.1)
Net_1304:
  vias: v2(88.81,89.6)
Net_1305:
  vias: v2(88.81,88.6)
Net_1306:
  vias: v2(89.68,90.1)
Net_1307:
  vias: v2(89.68,89.1)
Net_1308:
  vias: v2(90.54,89.6)
Net_1309:
  vias: v2(90.54,88.6)
Net_1310:
  vias: v2(91.41,90.1)
Net_1311:
  vias: v2(91.41,89.1)
Net_1312:
  vias: v2(87.08,87.6)
Net_1313:
  vias: v2(87.08,86.6)
Net_1314:
  vias: v2(87.95,87.1)
Net_1315:
  vias: v2(87.95,86.1)
Net_1316:
  vias: v2(88.81,87.6)
Net_1317:
  vias: v2(88.81,86.6)
Net_1318:
  vias: v2(90.54,87.6)
Net_1319:
  vias: v2(94.01,89.6)
Net_1321:
  vias: v2(88.81,83.6)
Net_1322:
  vias: v2(95.74,89.6)
Net_1323:
  vias: v2(95.74,88.6)
Net_1328:
  vias: v2(93.14,87.1)
Net_1329:
  vias: v2(93.14,86.1)
Net_1332:
  vias: v2(94.87,87.1)
Net_1334:
  vias: v2(95.74,87.6)
Net_1335:
  vias: v2(95.74,86.6)
Net_1336:
  vias: v2(96.6,87.1)
Net_1340:
  vias: v2(87.08,82.6)
Net_1341:
  vias: v2(88.81,81.6)
Net_1342:
  vias: v2(94.87,90.1)
Net_1343:
  vias: v2(94.87,89.1)
Net_1344:
  vias: v2(89.68,87.1)
Net_1345:
  vias: v2(89.68,86.1)
Net_1347:
  vias: v2(94.87,84.1)
Net_1348:
  vias: v2(89.68,82.1)
Net_1349:
  vias: v2(89.68,81.1)
Net_1350:
  vias: v2(90.54,86.6)
Net_1351:
  vias: v2(90.54,81.6)
Net_1423:
  vias: v2(127.78,90.1)
Net_1424:
  vias: v2(129.51,87.1)
Net_1425:
  vias: v2(130.38,87.6)
Net_1426:
  vias: v2(126.92,89.6)
Net_1427:
  vias: v2(126.92,88.6)
Net_1429:
  vias: v2(125.18,89.6)
Net_1430:
  vias: v2(125.18,88.6)
Net_1431:
  vias: v2(124.32,89.1)
Net_1435:
  vias: v2(126.92,87.6)
Net_1437:
  vias: v2(126.05,86.1)
Net_1438:
  vias: v2(125.18,87.6)
Net_1439:
  vias: v2(125.18,86.6)
Net_1443:
  vias: v2(126.05,89.1)
Net_1444:
  vias: v2(126.05,85.1)
Net_1445:
  vias: v2(130.38,86.6)
Net_1446:
  vias: v2(96.6,121.1)
Net_1447:
  vias: v2(90.54,113.6)
Net_1448:
  vias: v2(90.54,118.6)
Net_1449:
  vias: v2(94.87,117.1)
Net_1450:
  vias: v2(96.6,116.1)
Net_1451:
  vias: v2(97.47,115.6)
Net_1452:
  vias: v2(90.54,120.6)
Net_1453:
  vias: v2(96.6,118.1)
Net_1557:
  vias: v2(124.32,108.1)
Net_1590:
  vias: v2(85.35,86.6)
Net_1591:
  vias: v2(137.31,87.6)
Net_1592:
  vias: v2(85.35,87.6)
Net_1593:
  vias: v2(85.35,88.6)
Net_1594:
  vias: v2(85.35,89.6)
Net_1595:
  vias: v2(91.41,91.1)
Net_1596:
  vias: v2(127.78,91.1)
Net_1600:
  vias: v2(86.21,91.1)
Net_1604:
  vias: v2(90.54,91.6)
Net_1605:
  vias: v2(128.65,91.6)
Net_1611:
  vias: v2(95.74,91.6)
Net_1612:
  vias: v2(85.35,91.6)
Net_1626:
  vias: v2(95.74,93.6)
OPT_FAN_RPM: length 317.6
  ART03 w0.114: v2(165.07,89.58) 165.47,89.18 165.47,86.58 163.95,85.06 163.95,80.78 164.37,80.37 168.96,80.37 172.06,77.27 179.11,77.27 180.94,75.44 182.6,75.44 184.25,73.79 192.76,73.79 194.03,72.51 194.03,70.41 193.87,70.25 193.87,69.55 194.03,69.39 194.03,66.22 193.24,65.43 193.24,57.76 193.49,57.5 193.65,57.5 194.05,57.1 194.05,42.62 187.78,36.35 179.3,36.35 176.02,39.62 127.51,39.62 126.29,40.84 103.28,40.84 95.38,48.74 93.42,48.74 92,50.16 91.56,50.16 91.29,50.44 91.29,51.03 90.55,51.76 90.55,53.75 87.86,56.44 87.86,58.86 86.36,60.35 86.36,69.15 80.4,75.11 77.37,75.11 72.95,79.52 63.89,79.52 60.92,82.49 60.92,86.12 58.52,88.52 56.9,88.52 56.49,88.93 56.49,99.85 54.35,101.99 54.35,107.63 54,107.97 54,113.49 52.3,115.19 v2(33.78,115.19)
  BOTTOM w0.109: R403.1 12.57,112.9 13.49,111.99 14.58,111.99 16.26,110.31 26.34,110.31 31.21,115.19 v2(33.78,115.19)
OV_12V_DCIN: length 4.5
  TOP w0.109: v2(32.36,187.71) 32.36,187.71 U48.4
  BOTTOM w0.109: C955.1 R524.2 33.31,186.69 R521.1 32.17,187.13 32.36,187.32 v2(32.36,187.71)
OVERTEMPN: length 93.2
  TOP w0.109: v3(174.82,112.01) 173.84,112.01 173.71,112.14 U31.16
  ART05 w0.114: v3(174.82,112.01) 175.45,111.38 180.34,111.38 181.49,112.53 183.78,112.53 184,112.32 188.24,112.32 188.95,113.03 190.65,113.03 191.24,112.44 v2(197.89,112.44)
  ART18 w0.114: v2(165.87,90.38) 165.45,89.97 165.45,87.78 165.25,87.58 164.92,87.58 164.68,87.34 164.68,84.72 165.45,83.95 170.35,83.95 170.63,83.66 173.26,83.66 175.63,81.29 180.53,81.29 181.41,82.17 183.94,82.17 184.68,82.9 184.68,84.33 185.52,85.17 186.23,85.17 187.4,86.33 190.55,86.33 191.15,86.93 191.15,88.48 191.84,89.18 192.81,89.18 194.61,90.98 194.61,96.16 196.87,98.42 196.87,109.27 198.52,110.92 198.52,111.81 v2(197.89,112.44)
PCIE_EP_PERSTN: length 119.1
  TOP w0.109: R234.1 R238.2 199.96,26.8 v2(200.38,26.8) 201.52,25.65 J14.A11
  ART20 w0.114: v2(200.38,26.8) 203.05,26.8 204.95,28.7 204.95,66.45 204.52,66.88 200.68,66.88 199.9,67.66 199.9,69.32 199.21,70 198.17,70 195.15,73.02 187.4,73.02 185.9,71.53 180.54,71.53 180.19,71.88 180.19,72.85 178.25,74.78 167.46,74.78 161.08,81.15 161.08,90.08 161.92,90.92 162.6,90.92 163.02,91.34 163.36,91.34 163.93,90.78 166.89,90.78 167.08,90.97 167.08,93.17 v2(166.67,93.58)
PCIE_JTAG_BYPASSN: length 187.9
  TOP w0.109: U23.R17 v2(43.54,179.12)
  ART03 w0.114: v2(43.54,179.12) 43.94,179.53 45.52,179.53 46.35,178.69 48.01,178.69 52.96,183.64 62.48,183.64 64.64,185.8 75.56,185.8 78.23,183.13 78.23,175.9 78.74,175.39 78.74,173.35 80.14,171.96 133.95,171.96 135.71,173.72 135.71,188.58 140.46,193.33 140.46,194.85 142.21,196.6 165.29,196.6 165.54,196.34 170.05,196.34 171.45,194.94 174.5,194.94 178.05,191.39 178.59,191.39 179.22,190.75 179.22,188.7 183.77,184.15 187.86,184.15 v2(189.41,182.6)
PCIE_RC_JTAG_TCK: length 333.2
  TOP w0.109: v2(200.63,20.07) 201.05,19.65 J14.A5 ; U23.N15 v2(41.93,177.52)
  ART07 w0.114: v2(200.63,20.07) 202.05,20.07 209.34,27.35 212.65,27.35 215.16,29.87 215.16,97.41 200.26,112.31 200.26,116.6 198.33,118.53 195.94,118.53 194.82,119.65 194.82,135.66 193.6,136.88 193.6,152.86 192.53,153.92 191.64,153.92 186.56,159 164.89,159 161.64,162.25 149.53,162.25 148.39,163.4 147.65,163.4 146.41,164.64 146.41,166.51 144.52,168.4 136.53,168.4 135.64,169.29 135.64,176.66 135.25,177.04 79.25,177.04 77.19,179.1 75.03,179.1 74.42,178.49 73.36,178.49 70.43,181.41 60.25,181.41 59.69,180.85 46.88,180.85 46.58,181.15 40.23,181.15 39.11,180.03 39.11,178.96 39.31,178.76 39.38,178.76 39.39,178.76 39.67,178.76 39.94,178.49 39.94,178.14 40.14,177.94 41.51,177.94 v2(41.93,177.52)
  BOTTOM w0.109: v2(200.63,20.07) 201.46,19.24 R230.1
PCIE_RC_JTAG_TDI: length 331.5
  TOP w0.109: J14.A6 200.81,20.65 v2(200.63,20.83) ; U23.M16 v2(41.14,178.32)
  ART07 w0.114: v2(41.14,178.32) 40.95,178.32 40.56,178.71 40.16,178.71 39.93,178.95 39.93,180.19 40.49,180.75 46.3,180.75 46.78,180.26 47.7,180.26 49.28,178.69 57.76,178.69 59.33,180.26 68.04,180.26 68.5,180.72 70.31,180.72 72.14,178.89 72.14,177.42 73.66,175.9 77.47,175.9 78.11,176.53 134.75,176.53 135.13,176.15 135.13,168.15 135.66,167.61 144.3,167.61 145.03,166.88 145.03,163.45 145.57,162.92 148.23,162.92 149.31,161.84 161.13,161.84 164.47,158.5 186.31,158.5 193.18,151.63 193.18,134.05 193.6,133.63 193.6,127.32 192.52,126.24 192.52,125.82 192.68,125.66 192.68,121.8 194.16,120.32 194.16,119.75 194.41,119.51 194.41,119.48 195.77,118.11 198.16,118.11 199.84,116.42 199.84,112.12 214.74,97.23 214.74,30.84 213.23,29.34 211.58,29.34 210.16,27.91 209.3,27.91 202.22,20.83 v2(200.63,20.83)
  BOTTOM w0.109: v2(200.63,20.83) 200.76,20.83 200.94,20.65 201.13,20.65 R231.1
PCIE_RC_JTAG_TDO: length 330.2
  TOP w0.109: v2(200.61,21.64) 202.13,21.64 J14.A7 ; U23.N16 v2(41.93,178.32)
  ART07 w0.114: v2(200.61,21.64) 201.19,21.64 201.31,21.53 201.31,21.36 201.42,21.25 201.65,21.25 201.76,21.36 201.76,21.53 201.88,21.64 202.44,21.64 210.01,29.21 210.69,29.21 211.33,29.84 211.33,32.91 211.44,33.02 212.72,33.02 214.32,34.61 214.32,97.06 199.43,111.95 199.43,116.25 198.1,117.58 195.64,117.58 194.05,119.17 193.56,119.17 192.65,120.08 192.65,120.51 192.1,121.06 192.1,126.42 193.07,127.38 193.07,127.97 193.07,127.98 193.07,128.41 193.07,128.41 193.07,128.42 192.5,128.99 192.5,129.97 193.05,130.51 193.05,131.31 192.46,131.9 192.46,136.62 192.76,136.92 192.76,141.13 191.87,142.02 191.87,152.3 187.07,157.1 179.45,157.1 178.56,157.99 172.97,157.99 171.96,156.97 165.4,156.97 160.96,161.42 149.1,161.42 149,161.52 148.02,162.5 143.45,162.5 143.13,162.81 143.13,164.72 142.98,164.87 142.46,164.87 142.09,165.24 142.09,166.7 141.59,167.2 135.06,167.2 134.62,167.64 134.62,175.9 134.49,176.02 78.36,176.02 77.72,175.39 73.53,175.39 70.87,178.05 70.87,179.07 70.23,179.71 68.71,179.71 67.97,178.97 65.1,178.97 64.47,178.33 58.24,178.33 57.96,178.05 49.28,178.05 47.5,179.83 46.61,179.83 46.02,180.42 41.04,180.42 40.74,180.11 40.74,178.99 41.02,178.71 41.4,178.71 41.8,178.32 v2(41.93,178.32)
  BOTTOM w0.109: R232.1 200.66,21.59 v2(200.61,21.64)
PCIE_RC_JTAG_TMS: length 336.9
  TOP w0.109: J14.A8 v2(200.59,22.65) ; U23.M15 v2(41.14,177.52)
  ART07 w0.114: v2(200.59,22.65) 200.19,22.26 200.19,19.91 200.46,19.65 202.23,19.65 202.24,19.66 202.26,19.66 209.52,26.92 212.85,26.92 215.59,29.66 215.59,97.59 200.68,112.5 200.68,116.77 198.5,118.95 196.14,118.95 195.24,119.84 195.24,135.83 194.06,137.02 194.06,153.04 187.58,159.51 173.61,159.51 173.1,160.02 164.64,160.02 161.99,162.67 150.73,162.67 149.83,163.58 149.83,163.78 149.3,164.31 147.85,164.31 146.84,165.33 146.84,166.67 144.69,168.82 137.5,168.82 136.14,170.18 136.14,177.04 135.64,177.55 79.63,177.55 77.39,179.78 73.2,179.78 71.12,181.86 46.61,181.86 46.23,181.48 40.01,181.48 38.78,180.26 38.78,178.87 39.14,178.16 40.16,177.14 40.75,177.14 v2(41.14,177.52)
  BOTTOM w0.109: v2(200.59,22.65) 201.25,22.65 R233.1
PCIE_RC_JTAG_TRSTN: length 332
  TOP w0.109: J14.B9 212.13,23.65 R237.2 212.79,24.26 213.97,24.26 v2(214.6,23.62) ; U23.P15 v2(42.73,177.52)
  ART07 w0.114: v2(42.73,177.52) 42.72,177.52 42.34,177.14 42.34,176.48 42.15,176.29 39.15,176.29 38.43,177.01 38.43,180.41 40.01,181.99 43.05,181.99 43.94,182.88 68.71,182.88 69.22,183.39 73.79,183.39 76.96,180.21 77.72,180.21 79.88,178.05 136.02,178.05 136.65,177.42 136.65,170.41 137.79,169.27 145.21,169.27 146.33,168.15 149.2,168.15 150.11,167.23 150.11,164.94 150.98,164.08 150.98,163.69 151.47,163.19 162.35,163.19 163.93,161.62 168.4,161.62 169.34,160.68 174.27,160.68 174.93,160.02 189.1,160.02 194.44,154.69 194.44,153.25 194.48,153.21 194.48,138.32 195.66,137.13 195.66,136.63 195.67,136.62 195.67,136.28 195.66,136.27 195.66,120.21 196.27,119.61 198.44,119.61 201.83,116.22 201.83,111.99 216.05,97.76 216.05,25.07 v2(214.6,23.62)
PCIE_RC_PERSTN: length 81.9
  ART16 w0.114: v2(134.71,94.1) 134.71,93.81 135.39,93.13 135.74,93.13 136.23,93.62 136.61,93.62 137.11,93.13 137.48,93.13 137.95,92.66 139.37,92.66 141.25,90.78 141.25,80.97 141.8,80.42 141.8,79.28 142.19,78.89 142.19,78.76 v2(142.34,78.61) 142.38,78.57 142.38,77.39 143.01,76.76 153.43,76.76 155.02,78.35 161.08,78.35 163.05,80.33 177.61,80.33 180.29,83.01 180.29,88.67 179.04,89.92 178.66,89.92 178.56,90.02 177.62,90.02 177.47,90.17 177.47,90.55 177.24,90.78 176.88,90.78 176.68,90.98 176.68,94.79 v2(177.07,95.18)
  BOTTOM w0.114: v2(142.34,78.61) R89.1 143.67,79.25 145.76,79.25 145.93,79.42 R88.1
PCIE_RC_PRSNTN: length 411.9
  TOP w0.109: v2(203.86,97.08) 204.67,97.08 205.24,97.65 J14.B81 v2(210.75,97.65) ; U23.P18 v2(42.74,179.92) 42.74,181.99 42.29,182.44 R351.1 R240.2
  TOP w0.254: J14.B48 v2(210.75,64.65) ; v2(210.75,47.65) J14.B31 ; J14.B17 v2(210.75,33.65)
  ART07 w0.114: v2(42.74,179.92) 43.13,179.53 43.74,179.53 43.91,179.35 43.91,178.97 44.14,178.74 45.51,178.74 45.95,178.31 46.35,178.31 47.37,177.29 47.37,176.4 47.88,175.9 50.42,175.9 51.21,176.68 65.61,176.68 65.96,177.04 65.96,177.65 66.42,178.1 69.42,178.1 73.6,173.93 77.91,173.93 79.12,172.72 128.52,172.72 129.79,171.45 129.79,168.28 132.46,165.61 135.92,165.61 136.93,164.59 139.11,164.59 140.46,163.24 140.46,162.18 141.03,161.61 147.51,161.61 148.63,160.49 160.41,160.49 165.83,155.07 171.7,155.07 173.1,156.46 175.13,156.46 175.9,155.7 177.29,155.7 178.23,154.76 187.76,154.76 191.03,151.49 191.03,141.67 191.92,140.78 191.92,137.4 190.55,136.03 190.55,129.27 190.83,128.99 190.83,127.62 191.23,127.22 191.23,127.15 191.25,127.14 191.25,117.97 193.98,115.24 197.64,115.24 198.53,114.35 198.53,110.44 200,108.97 201.65,108.97 210.75,99.86 v2(210.75,97.65) 212.74,97.65 213.84,96.55 213.84,65.66 213.46,65.28 211.38,65.28 v2(210.75,64.65) 211.39,64.01 213.21,64.01 213.71,63.5 213.71,48.89 213.08,48.26 211.36,48.26 v2(210.75,47.65) 212.05,46.35 213.59,46.35 213.84,46.1 213.84,34.9 212.59,33.65 v2(210.75,33.65)
  ART18 w0.114: v2(203.86,97.08) 202.82,97.08 201.12,95.38 200.38,95.38 198.25,93.25 198.25,84.79 198.25,84.79 198.25,82.02 191.41,75.18 184.24,75.18 180.74,78.68 172.22,78.68 171.47,79.43 161.46,79.43 158.24,82.65 158.24,90.93 160.02,92.71 163.52,92.71 163.8,92.43 164.43,92.43 164.67,92.19 164.67,91 164.45,90.78 164.16,90.78 164.12,90.74 164.12,90.74 163.91,90.53 163.91,90.21 164.13,89.98 164.48,89.98 164.66,89.8 164.66,89.19 v2(165.07,88.78)
PCIE_RC_REFCLKN: length 138.7
  TOP w0.089: R969.1 166.1,130.13 166.1,129.93 v2(166.36,129.67) ; J14.A14 202.05,30.56 v2(200.73,30.56)
  ART07 w0.094: v2(166.36,129.67) 166.06,129.36 166.06,128.55 168.93,125.68 168.93,123.52 170.48,121.97 175.21,121.97 181.13,116.05 184.27,116.05 185.65,114.68 187.08,114.68 187.25,114.5 189.68,114.5 190.29,113.89 190.29,107.92 192.22,105.99 194.49,105.99 200.87,99.62 203.96,99.62 205.56,98.02 205.56,29.51 204.06,28.02 200.07,28.02 199.67,28.41 199.67,29.9 200.03,30.25 200.43,30.25 v2(200.73,30.56)
PCIE_RC_REFCLKP: length 138.7
  TOP w0.089: v2(200.73,29.74) 202.05,29.74 J14.A13 ; v2(165.56,129.67) 165.82,129.93 165.82,130.13 R968.1
  ART07 w0.094: v2(200.73,29.74) 200.43,30.05 200.11,30.05 199.87,29.81 199.87,28.5 200.15,28.22 200.48,28.22 200.56,28.3 200.81,28.3 200.89,28.22 201.07,28.22 201.15,28.3 201.4,28.3 201.48,28.22 201.66,28.22 201.77,28.33 201.96,28.33 202.06,28.22 202.25,28.22 202.36,28.33 202.55,28.33 202.65,28.22 203.98,28.22 205.36,29.6 205.36,29.9 205.25,30.01 205.25,30.19 205.36,30.3 205.36,30.49 205.25,30.59 205.25,30.78 205.36,30.89 205.36,31.08 205.25,31.18 205.25,31.37 205.36,31.48 205.36,31.67 205.25,31.77 205.25,31.96 205.36,32.07 205.36,95.44 205.25,95.55 205.25,95.74 205.36,95.84 205.36,96.03 205.25,96.14 205.25,96.32 205.36,96.43 205.36,96.62 205.25,96.73 205.25,96.91 205.36,97.02 205.36,97.21 205.25,97.32 205.25,97.5 205.36,97.61 205.36,97.93 203.88,99.41 200.78,99.41 194.41,105.79 192.14,105.79 190.09,107.84 190.09,113.81 189.6,114.3 187.17,114.3 186.99,114.48 185.56,114.48 184.19,115.85 181.05,115.85 175.13,121.77 170.4,121.77 168.73,123.44 168.73,125.59 165.86,128.46 165.86,129.36 v2(165.56,129.67)
PCIE_RC_RXN0: length 104.2
  TOP w0.097: 200.73,33.56 200.78,33.61 arc(200.83,33.64) 200.88,33.65 J14.A17
  ART07 w0.114: U1.BR62 137.89,95.26 137.79,95.23 arc(137.77,95.06) 137.82,94.9 arc(137.9,94.6) 137.82,94.31 137.82,94.3 arc(137.77,94.1) 137.82,93.9 137.82,93.89 arc(137.97,93.75) 138.17,93.7 138.48,93.7 arc(138.51,93.7) 138.54,93.72 138.54,93.73 138.57,93.73
  ART07 w0.135: 200.73,33.56 200.45,33.28 200.28,33.28 arc(200.13,33.31) 200.01,33.39 196.86,36.53 arc(196.63,36.89) 196.54,37.31 196.54,42.04 arc(196.44,42.55) 196.15,42.99 191.02,48.12 arc(190.58,48.41) 190.07,48.51 184.79,48.51 arc(184.53,48.54) 184.29,48.61 arc(183.82,48.75) 183.33,48.79 177.52,48.79 arc(177.46,48.8) 177.39,48.81 arc(176.73,49.06) 176.16,49.49 175.83,49.82 arc(175.39,50.11) 174.88,50.21 171.7,50.21 arc(171.28,50.3) 170.92,50.53 168.24,53.22 arc(168,53.58) 167.92,53.99 167.92,55.52 arc(167.81,56.04) 167.52,56.48 166.97,57.03 arc(166.58,57.29) 166.12,57.38 166,57.38 arc(165.64,57.45) 165.33,57.66 162.22,60.77 arc(161.98,61.12) 161.9,61.54 161.9,68.22 arc(161.79,68.74) 161.5,69.18 155.41,75.27 arc(155.17,75.62) 155.09,76.04 155.09,76.71 arc(154.99,77.22) 154.7,77.66 153.68,78.67 arc(153.24,78.97) 152.73,79.07 151.94,79.07 arc(151.52,79.15) 151.16,79.39 146.55,84.01 arc(146.31,84.36) 146.23,84.78 146.23,86.79 arc(146.12,87.31) 145.83,87.74 145.61,87.96 arc(145.17,88.26) 144.66,88.36 142.27,88.36 arc(141.6,88.49) 141.02,88.87 140.52,89.38 140.52,89.54 140.33,89.73 140.17,89.73 139.98,89.92 139.98,90.08 139.79,90.27 139.63,90.27 139.31,90.59 arc(139.24,90.69) 139.22,90.82 139.22,91.56 139.33,91.67 139.33,91.94 139.22,92.06 139.22,92.33 139.33,92.44 139.33,92.71 139.22,92.82 139.22,93.09 arc(139.03,93.54) 138.58,93.73 138.57,93.73
PCIE_RC_RXN1: length 103.7
  TOP w0.097: J14.A22 200.88,38.65 arc(200.83,38.64) 200.78,38.61 200.73,38.56
  ART07 w0.114: U1.BM59 135.3,96.44 135.27,96.34 135.38,96.2 135.41,96.2 135.43,96.18 arc(135.72,96.19) 135.95,96.38 135.98,96.44 arc(136.48,96.73) 136.98,96.44 137.03,96.35 arc(137.14,96.24) 137.29,96.2 137.33,96.2 arc(137.62,96.12) 137.84,95.9 137.87,95.85 arc(137.99,95.74) 138.14,95.7 138.19,95.7 arc(138.42,95.65) 138.62,95.52 138.87,95.26 138.92,95.26 138.94,95.24
  ART07 w0.135: 200.73,38.56 200.45,38.28 199.92,38.28 arc(199.55,38.35) 199.23,38.56 198.41,39.38 arc(198.18,39.73) 198.09,40.15 198.09,42.06 arc(197.99,42.58) 197.7,43.01 190.61,50.1 arc(190.17,50.39) 189.66,50.5 186.13,50.5 arc(185.71,50.41) 185.35,50.17 185.26,50.08 arc(184.98,49.9) 184.66,49.83 180.21,49.83 arc(179.79,49.92) 179.44,50.15 176.49,53.1 arc(176.06,53.39) 175.54,53.49 172.75,53.49 arc(172.19,53.72) 171.96,54.28 171.96,56 arc(171.86,56.52) 171.56,56.96 169.91,58.61 arc(169.47,58.9) 168.96,59 165.75,59 arc(165.34,59.09) 164.98,59.32 163.44,60.87 arc(163.2,61.22) 163.12,61.64 163.12,68.78 arc(163.01,69.3) 162.72,69.74 156.55,75.9 arc(156.32,76.26) 156.23,76.68 156.23,77.04 arc(156.13,77.55) 155.84,77.99 154.21,79.61 arc(153.78,79.91) 153.26,80.01 152.37,80.01 arc(151.95,80.09) 151.6,80.33 147.46,84.47 arc(147.22,84.82) 147.14,85.24 147.14,87.15 arc(147.04,87.66) 146.75,88.1 145.52,89.32 arc(145.08,89.62) 144.57,89.72 142.1,89.72 arc(141.68,89.8) 141.33,90.04 140.45,90.92 arc(140.36,91.05) 140.34,91.2 140.34,91.62 140.45,91.73 140.45,92 140.34,92.12 140.34,92.39 140.45,92.5 140.45,92.77 140.34,92.88 140.34,93.15 arc(140.21,93.79) 139.84,94.34 139.56,94.63 139.56,94.79 139.37,94.98 139.2,94.98 138.94,95.24
PCIE_RC_RXN2: length 103.5
  TOP w0.097: J14.A26 200.88,42.65 arc(200.83,42.64) 200.78,42.61 200.73,42.56
  ART07 w0.114: U1.BL62 137.89,97.26 137.79,97.23 arc(137.77,97.06) 137.82,96.9 137.82,96.89 arc(137.99,96.73) 138.22,96.67 138.4,96.67 138.43,96.7 138.46,96.7
  ART07 w0.135: 138.46,96.7 138.6,96.7 arc(138.86,96.65) 139.09,96.5 139.42,96.17 arc(139.54,96.09) 139.67,96.06 140.08,96.06 arc(141.05,95.66) 141.45,94.69 141.45,94.42 141.57,94.31 141.57,94.04 141.45,93.92 141.45,93.65 141.57,93.54 141.57,93.27 141.45,93.16 141.45,92.89 141.57,92.77 141.57,92.5 141.45,92.39 141.45,91.58 arc(141.46,91.51) 141.49,91.45 arc(141.89,91.04) 142.44,90.89 142.71,90.89 142.82,91 143.09,91 143.21,90.89 144.92,90.89 arc(145.44,90.78) 145.88,90.49 147.79,88.58 arc(148.08,88.15) 148.18,87.63 148.18,85.82 arc(148.26,85.4) 148.5,85.05 152.23,81.32 arc(152.58,81.08) 153,81 153.8,81 arc(154.31,80.9) 154.75,80.61 163.99,71.36 arc(164.28,70.92) 164.39,70.41 164.39,62.38 arc(164.47,61.96) 164.71,61.61 165.75,60.57 arc(166.1,60.33) 166.52,60.25 174.65,60.25 arc(175.07,60.33) 175.42,60.57 177.56,62.7 arc(177.99,62.99) 178.51,63.09 182.7,63.09 arc(182.8,63.11) 182.88,63.17 182.96,63.25 arc(183.12,63.36) 183.32,63.4 184.3,63.4 arc(184.54,63.35) 184.74,63.21 184.83,63.13 arc(184.95,63.05) 185.09,63.02 186.23,63.02 arc(186.75,62.91) 187.19,62.62 190.23,59.58 arc(190.52,59.14) 190.62,58.63 190.62,52.09 arc(190.71,51.67) 190.94,51.32 199.85,42.41 arc(200,42.31) 200.17,42.28 200.45,42.28 200.73,42.56
PCIE_RC_RXN3: length 99.9
  TOP w0.097: J14.A30 200.88,46.65 arc(200.83,46.64) 200.78,46.61 200.73,46.56
  ART07 w0.114: U1.BH59 135.3,98.44 135.27,98.34 arc(135.41,98.23) 135.57,98.2 135.63,98.2 arc(135.82,98.25) 135.96,98.38 arc(136.44,98.66) 136.92,98.38 136.93,98.37 arc(137.06,98.24) 137.24,98.2 137.31,98.2 arc(137.6,98.12) 137.82,97.9 137.82,97.89 arc(137.97,97.75) 138.17,97.7 138.4,97.7 138.43,97.73 138.46,97.73
  ART07 w0.135: 200.73,46.56 200.45,46.28 199.59,46.28 arc(198.09,46.57) 196.82,47.42 195.11,49.14 192.6,51.65 arc(192.36,52.01) 192.28,52.42 192.28,54.86 arc(192.18,55.33) 191.91,55.73 191.83,55.82 arc(191.61,56.14) 191.54,56.51 191.54,59.11 arc(191.44,59.62) 191.14,60.06 190.77,60.44 arc(190.53,60.79) 190.45,61.21 190.45,63.38 arc(190.34,63.89) 190.05,64.33 188.43,65.95 arc(187.99,66.24) 187.48,66.34 178.81,66.34 arc(178.39,66.43) 178.04,66.66 177.33,67.37 arc(177.09,67.73) 177.01,68.15 177.01,71.84 arc(176.91,72.35) 176.62,72.79 175.4,74 arc(174.96,74.29) 174.45,74.4 171.06,74.4 arc(170.64,74.48) 170.29,74.72 169.56,75.45 arc(169.12,75.74) 168.6,75.84 165.36,75.84 arc(161.29,76.65) 157.84,78.96 arc(157.71,79.1) 157.59,79.25 157.06,79.94 arc(157.03,80) 157.02,80.07 157.02,80.69 arc(156.92,81.21) 156.63,81.65 arc(156.27,81.88) 155.86,81.96 153.41,81.96 arc(153.34,81.98) 153.29,82.02 150.25,85.05 arc(150.02,85.4) 149.93,85.82 149.93,87.17 arc(149.83,87.69) 149.54,88.12 145.89,91.77 arc(145.47,92.05) 144.98,92.15 144.42,92.15 arc(143.72,92.44) 143.43,93.14 143.43,94.31 arc(143.33,94.83) 143.04,95.27 142.79,95.52 142.46,95.84 142.46,96 142.27,96.19 142.11,96.19 141.92,96.38 141.92,96.55 141.73,96.74 141.57,96.74 141.38,96.93 arc(141.24,97.02) 141.07,97.05 140,97.05 arc(139.82,97.09) 139.66,97.2 139.36,97.5 arc(139.1,97.67) 138.8,97.73 138.46,97.73
PCIE_RC_RXN4: length 91.5
  TOP w0.097: 200.73,52.56 201.99,52.56 arc(202.04,52.57) 202.09,52.6 J14.A36
  ART07 w0.114: 138.46,98.7 138.43,98.7 138.4,98.67 138.22,98.67 arc(137.99,98.73) 137.82,98.89 137.82,98.9 arc(137.77,99.06) 137.79,99.23 137.89,99.26 U1.BG62
  ART07 w0.135: 138.46,98.7 139.18,98.7 arc(139.4,98.66) 139.6,98.53 139.92,98.21 arc(139.99,98.16) 140.07,98.15 140.34,98.15 140.45,98.26 140.72,98.26 140.84,98.15 141.11,98.15 141.22,98.26 141.49,98.26 141.6,98.15 141.87,98.15 141.99,98.26 142.26,98.26 142.37,98.15 142.68,98.15 arc(142.95,98.09) 143.18,97.94 143.51,97.61 arc(143.74,97.27) 143.82,96.86 143.82,96.32 arc(143.85,96.17) 143.93,96.05 144.12,95.86 144.28,95.86 144.47,95.67 144.47,95.51 151.5,88.48 arc(151.75,88.1) 151.84,87.67 151.84,85.64 arc(151.91,85.3) 152.1,85.01 153.74,83.37 arc(154.03,83.18) 154.37,83.11 156.09,83.11 arc(156.53,83.02) 156.9,82.77 157.94,81.73 arc(158.16,81.41) 158.25,81.03 158.31,80.02 arc(158.32,79.95) 158.35,79.89 158.6,79.53 arc(158.64,79.47) 158.69,79.43 arc(161.63,77.63) 164.98,76.81 arc(165.04,76.81) 165.09,76.81 169.55,76.81 arc(170.31,76.66) 170.96,76.22 171.22,75.96 arc(171.74,75.61) 172.36,75.49 176.84,75.49 arc(177.28,75.4) 177.65,75.15 179.24,73.56 arc(179.49,73.19) 179.58,72.75 179.58,69.87 arc(179.64,69.53) 179.84,69.24 181.45,67.62 arc(181.74,67.43) 182.08,67.36 188.8,67.36 arc(189.24,67.27) 189.61,67.03 193.69,62.94 arc(193.94,62.57) 194.03,62.14 194.03,60.24 arc(194.1,59.89) 194.29,59.61 196.33,57.56 arc(196.58,57.19) 196.67,56.75 196.67,55.68 199.94,52.41 arc(200.08,52.31) 200.25,52.28 200.45,52.28 200.73,52.56
PCIE_RC_RXN5: length 92.7
  TOP w0.097: 200.73,56.56 201.99,56.56 arc(202.04,56.57) 202.09,56.6 J14.A40
  ART07 w0.114: U1.BD59 135.3,100.44 135.27,100.34 arc(135.41,100.23) 135.57,100.2 arc(135.78,100.25) 135.92,100.4 135.93,100.4 arc(136.43,100.69) 136.94,100.4 136.96,100.37 arc(137.09,100.24) 137.26,100.2 137.31,100.2 arc(137.6,100.12) 137.82,99.9 137.82,99.89 arc(137.97,99.75) 138.17,99.7 138.4,99.7 138.43,99.73 138.46,99.73
  ART07 w0.135: 200.73,56.56 200.45,56.28 200.08,56.28 arc(199.96,56.3) 199.86,56.37 198.18,58.05 arc(197.31,59.35) 197,60.9 197,63.05 arc(196.91,63.49) 196.67,63.86 195.25,65.27 arc(195.06,65.56) 194.99,65.9 194.99,67.14 arc(194.91,67.58) 194.66,67.95 193.05,69.57 arc(192.67,69.81) 192.24,69.9 186.04,69.9 arc(185.7,69.97) 185.41,70.16 184.56,71.01 arc(184.19,71.26) 183.75,71.35 180.77,71.35 arc(180.57,71.43) 180.49,71.63 180.49,73.19 arc(180.4,73.62) 180.16,73.99 178.08,76.07 arc(177.71,76.32) 177.27,76.4 173.69,76.4 arc(173.6,76.44) 173.56,76.54 173.56,76.83 arc(173.5,77.09) 173.36,77.31 172.39,78.28 arc(172.02,78.52) 171.58,78.61 162.9,78.61 arc(162.56,78.68) 162.27,78.87 157.43,83.71 arc(157.06,83.96) 156.62,84.05 155.1,84.05 arc(154.76,84.12) 154.47,84.31 153.01,85.77 arc(152.82,86.06) 152.75,86.4 152.75,88.3 arc(152.67,88.74) 152.42,89.11 145.85,95.67 arc(145.68,95.93) 145.62,96.24 145.62,96.36 arc(145.54,96.77) 145.31,97.11 143.71,98.71 arc(143.15,99.08) 142.49,99.21 141.77,99.21 141.66,99.33 141.39,99.33 141.27,99.21 141.01,99.21 140.89,99.33 140.62,99.33 140.51,99.21 140.24,99.21 arc(140.19,99.22) 140.14,99.25 139.89,99.51 arc(139.64,99.67) 139.36,99.73 138.46,99.73
PCIE_RC_RXN6: length 87.3
  TOP w0.097: 200.73,60.56 201.99,60.56 arc(202.04,60.57) 202.09,60.6 J14.A44
  ART07 w0.114: U1.BC62 137.89,101.26 137.79,101.23 arc(137.77,101.06) 137.82,100.9 137.82,100.89 arc(137.99,100.73) 138.22,100.67 138.4,100.67 138.43,100.7 138.46,100.7
  ART07 w0.135: 200.73,60.56 200.45,60.28 200.28,60.28 arc(200.06,60.32) 199.88,60.44 199.78,60.54 198.41,61.91 arc(198.18,62.26) 198.09,62.68 198.09,64.06 arc(197.99,64.57) 197.7,65.01 197.42,65.29 arc(197.18,65.64) 197.1,66.06 197.1,68.43 arc(197,68.94) 196.71,69.38 192.7,73.39 arc(192.26,73.68) 191.74,73.79 184.22,73.79 arc(183.8,73.87) 183.45,74.11 180,77.56 arc(179.56,77.85) 179.04,77.95 174.72,77.95 arc(174.3,78.03) 173.95,78.27 173.06,79.16 arc(172.62,79.45) 172.11,79.55 163.62,79.55 arc(163.21,79.63) 162.85,79.87 159.19,83.53 arc(158.96,83.88) 158.87,84.3 158.87,86.92 arc(158.77,87.43) 158.48,87.87 155.89,90.46 arc(155.45,90.75) 154.94,90.85 152.93,90.85 arc(152.51,90.94) 152.15,91.17 146.71,96.62 arc(146.67,96.68) 146.66,96.75 146.66,96.87 arc(146.62,97.04) 146.53,97.19 143.86,99.86 143.56,100.15 arc(143.22,100.38) 142.83,100.46 142.56,100.46 142.44,100.57 142.17,100.57 142.06,100.46 141.79,100.46 141.68,100.57 141.41,100.57 141.29,100.46 141.02,100.46 140.91,100.57 140.64,100.57 140.53,100.46 140.26,100.46 arc(140.19,100.47) 140.13,100.51 140.13,100.51 arc(139.92,100.65) 139.67,100.7 139.22,100.7 139.11,100.82 138.84,100.82 138.73,100.7 138.46,100.7
PCIE_RC_RXN7: length 87.3
  TOP w0.097: 200.73,64.56 201.99,64.56 arc(202.04,64.57) 202.09,64.6 J14.A48
  ART07 w0.114: U1.AY59 135.35,102.47 arc(135.29,102.4) 135.31,102.31 arc(135.32,102.29) 135.34,102.28 135.37,102.25 arc(135.49,102.19) 135.61,102.17 arc(135.77,102.22) 135.89,102.33 135.94,102.42 arc(136.44,102.71) 136.93,102.42 136.95,102.4 arc(137.09,102.25) 137.3,102.2 137.31,102.2 arc(137.6,102.12) 137.82,101.9 137.82,101.89 arc(137.97,101.75) 138.17,101.7 138.27,101.7 138.3,101.73 138.33,101.73
  ART07 w0.135: 200.73,64.56 200.45,64.28 200.12,64.28 arc(200.02,64.3) 199.92,64.36 198.96,65.32 198.9,65.38 arc(198.4,66.14) 198.22,67.03 198.22,68.72 arc(198.13,69.16) 197.88,69.53 192.89,74.52 arc(192.52,74.77) 192.09,74.85 184.46,74.85 arc(184.12,74.92) 183.84,75.11 180.19,78.76 arc(179.82,79.01) 179.38,79.09 175.15,79.09 arc(174.81,79.16) 174.52,79.36 173.72,80.16 arc(173.35,80.4) 172.91,80.49 163.94,80.49 arc(163.6,80.56) 163.31,80.75 161.27,82.8 arc(161.08,83.09) 161.01,83.43 161.01,84.84 arc(160.92,85.28) 160.67,85.65 160.4,85.92 arc(160.21,86.21) 160.14,86.55 160.14,87.1 arc(160.06,87.54) 159.81,87.91 156.19,91.54 arc(155.82,91.78) 155.38,91.87 153.12,91.87 arc(152.78,91.94) 152.49,92.13 147.8,96.82 arc(147.76,96.88) 147.75,96.95 147.75,97.08 arc(147.72,97.25) 147.62,97.39 143.66,101.34 arc(143.6,101.4) 143.53,101.46 arc(143.4,101.53) 143.25,101.55 142.65,101.55 142.53,101.68 142.28,101.68 142.16,101.55 141.89,101.55 141.81,101.63 141.46,101.63 141.39,101.55 141.12,101.55 141,101.66 140.74,101.66 140.62,101.55 140.35,101.55 arc(140.2,101.57) 140.06,101.64 arc(140.06,101.63) 140.06,101.63 arc(139.91,101.7) 139.74,101.73 138.33,101.73
PCIE_RC_RXN8: length 85.1
  TOP w0.097: J14.A53 202.09,69.6 arc(202.04,69.57) 201.99,69.56 200.73,69.56
  ART07 w0.114: U1.AW62 137.89,103.26 137.79,103.23 arc(137.77,103.06) 137.82,102.9 137.82,102.89 arc(137.99,102.73) 138.22,102.67 138.4,102.67 138.43,102.7 138.46,102.7
  ART07 w0.135: 138.46,102.7 139.11,102.7 arc(139.45,102.73) 139.78,102.81 arc(140.19,102.91) 140.61,102.95 140.88,102.95 141,103.06 141.26,103.06 141.38,102.95 141.65,102.95 141.76,103.06 142.03,103.06 142.15,102.95 142.41,102.95 142.53,103.06 142.8,103.06 142.91,102.95 143.46,102.95 arc(143.85,102.83) 144.1,102.53 144.24,102.22 arc(144.26,102.18) 144.28,102.15 144.48,101.96 144.64,101.96 144.83,101.77 144.83,101.61 146.36,100.08 148.43,98 arc(148.6,97.77) 148.68,97.5 arc(148.76,97.22) 148.93,96.99 151.14,94.78 arc(151.49,94.54) 151.91,94.46 160.3,94.46 arc(160.85,94.23) 161.08,93.67 161.08,86.96 arc(161.17,86.55) 161.4,86.19 161.53,86.07 arc(161.82,85.63) 161.92,85.12 161.92,83.92 arc(162.01,83.5) 162.24,83.14 163.48,81.9 arc(163.84,81.67) 164.25,81.58 173.28,81.58 arc(173.79,81.48) 174.23,81.19 175.06,80.35 arc(175.42,80.12) 175.84,80.03 180.14,80.03 arc(180.65,79.93) 181.09,79.64 184.49,76.24 arc(184.85,76) 185.26,75.92 192.28,75.92 arc(192.8,75.82) 193.23,75.53 199.22,69.53 arc(199.51,69.34) 199.84,69.28 200.45,69.28 200.73,69.56
PCIE_RC_RXN9: length 90.6
  TOP w0.097: J14.A57 202.09,73.6 arc(202.04,73.57) 201.99,73.56 200.73,73.56
  ART07 w0.114: U1.AT59 135.3,104.44 135.27,104.34 arc(135.41,104.23) 135.57,104.2 arc(135.78,104.25) 135.92,104.4 135.93,104.4 arc(136.43,104.69) 136.94,104.4 136.96,104.37 arc(137.09,104.24) 137.26,104.2 137.31,104.2 arc(137.6,104.12) 137.82,103.9 137.82,103.89 arc(137.97,103.75) 138.17,103.7 138.4,103.7 138.43,103.73 138.46,103.73
  ART07 w0.135: 138.46,103.73 139.58,103.73 arc(139.65,103.73) 139.71,103.75 arc(139.93,103.82) 140.14,103.92 arc(140.2,103.96) 140.25,104 arc(140.43,104.1) 140.64,104.14 141.31,104.14 141.42,104.25 141.69,104.25 141.8,104.14 142.07,104.14 142.19,104.25 142.46,104.25 142.57,104.14 144.88,104.14 arc(144.95,104.15) 145.01,104.19 arc(145.34,104.42) 145.74,104.49 149.21,104.49 arc(149.64,104.41) 150.01,104.16 150.49,103.69 arc(150.77,103.5) 151.11,103.43 160.56,103.43 arc(161,103.34) 161.37,103.09 162.65,101.81 arc(162.9,101.44) 162.99,101 162.99,100.29 arc(162.9,99.86) 162.65,99.49 162.26,99.09 arc(162.07,98.8) 162,98.46 162,87.36 arc(162.07,87.02) 162.26,86.73 164.18,84.82 arc(164.46,84.62) 164.81,84.56 172.22,84.56 arc(172.66,84.47) 173.03,84.22 176.01,81.23 arc(176.3,81.04) 176.64,80.97 181.31,80.97 arc(181.75,80.89) 182.12,80.64 182.44,80.32 arc(182.73,80.13) 183.07,80.06 192.13,80.06 arc(192.57,79.97) 192.94,79.73 199.03,73.64 arc(199.43,73.37) 199.9,73.28 200.45,73.28 200.73,73.56
PCIE_RC_RXN10: length 83.8
  TOP w0.097: 200.73,77.56 201.99,77.56 arc(202.04,77.57) 202.09,77.6 J14.A61
  ART07 w0.114: U1.AR62 137.89,105.26 137.79,105.23 arc(137.77,105.06) 137.82,104.9 137.82,104.89 arc(137.99,104.73) 138.22,104.67 138.4,104.67 138.43,104.7 138.46,104.7
  ART07 w0.135: 138.46,104.7 139.12,104.7 arc(139.75,104.83) 140.28,105.18 arc(140.56,105.37) 140.89,105.43 141.89,105.43 142,105.55 142.27,105.55 142.39,105.43 143.87,105.43 143.98,105.55 144.25,105.55 144.37,105.43 144.64,105.43 144.75,105.55 145.02,105.55 145.14,105.43 145.4,105.43 145.52,105.55 145.79,105.55 145.9,105.43 149.72,105.43 arc(150.16,105.35) 150.53,105.1 151.05,104.58 arc(151.31,104.4) 151.62,104.34 161.4,104.34 arc(161.84,104.26) 162.21,104.01 162.32,103.89 arc(162.61,103.7) 162.95,103.63 177.3,103.63 arc(177.74,103.54) 178.11,103.3 178.22,103.18 arc(178.51,102.99) 178.85,102.92 179.91,102.92 arc(180.34,102.83) 180.71,102.59 185.99,97.31 arc(186.27,97.12) 186.61,97.05 191.19,97.05 arc(191.63,96.97) 192,96.72 195.06,93.65 arc(195.31,93.28) 195.4,92.85 195.4,84.23 arc(195.91,81.67) 197.36,79.5 198.84,78.02 199.34,77.52 arc(199.61,77.34) 199.92,77.28 200.45,77.28 200.73,77.56
PCIE_RC_RXN11: length 84.5
  TOP w0.097: J14.A65 202.09,81.6 arc(202.04,81.57) 201.99,81.56 200.73,81.56
  ART07 w0.114: 138.46,105.73 138.43,105.73 138.4,105.7 138.17,105.7 arc(137.97,105.75) 137.82,105.89 137.82,105.9 arc(137.6,106.12) 137.31,106.2 137.26,106.2 arc(137.09,106.24) 136.96,106.37 136.94,106.4 arc(136.43,106.69) 135.93,106.4 135.92,106.4 arc(135.78,106.25) 135.57,106.2 arc(135.41,106.23) 135.27,106.34 135.3,106.44 U1.AM59
  ART07 w0.135: 138.46,105.73 138.63,105.73 140.15,106.25 140.42,106.52 140.45,106.52 140.47,106.53 arc(140.6,106.64) 140.74,106.72 arc(140.9,106.77) 141.07,106.78 141.49,106.78 141.6,106.9 141.87,106.9 141.99,106.78 142.26,106.78 142.37,106.9 142.64,106.9 142.75,106.78 144.66,106.78 arc(144.86,106.74) 145.03,106.63 arc(145.23,106.5) 145.46,106.45 178.66,106.45 arc(179.49,106.11) 179.83,105.28 179.83,105.22 arc(179.9,104.88) 180.09,104.59 186.45,98.23 arc(186.74,98.03) 187.08,97.97 191.8,97.97 arc(192.24,97.88) 192.61,97.63 196,94.24 arc(196.25,93.87) 196.34,93.43 196.34,87 arc(196.79,84.74) 198.07,82.83 198.87,82.03 199.4,81.49 arc(199.64,81.33) 199.92,81.28 200.45,81.28 200.73,81.56
PCIE_RC_RXN12: length 81.2
  TOP w0.097: 200.73,85.56 201.99,85.56 arc(202.04,85.57) 202.09,85.6 J14.A69
  ART07 w0.114: 138.46,106.7 138.43,106.7 138.4,106.67 138.22,106.67 arc(137.99,106.73) 137.82,106.89 137.82,106.9 arc(137.77,107.06) 137.79,107.23 137.89,107.26 U1.AL62
  ART07 w0.135: 200.73,85.56 200.45,85.28 199.95,85.28 arc(199.7,85.33) 199.5,85.46 198.94,86.02 198.46,86.5 arc(197.62,87.75) 197.33,89.23 197.33,93.71 arc(197.24,94.15) 197,94.52 192.97,98.55 arc(192.6,98.79) 192.16,98.88 187.69,98.88 arc(187.35,98.95) 187.06,99.14 182.5,103.7 arc(182.31,103.99) 182.24,104.33 182.24,106.68 arc(182.03,107.18) 181.53,107.39 172.7,107.39 arc(172.36,107.46) 172.08,107.65 171.83,107.89 arc(171.46,108.14) 171.02,108.23 169.81,108.23 arc(169.38,108.14) 169,107.89 168.74,107.63 arc(168.45,107.43) 168.11,107.36 146.16,107.36 arc(145.59,107.48) 145.11,107.8 arc(144.89,107.95) 144.62,108 143.95,108 143.83,108.12 143.56,108.12 143.45,108 143.18,108 143.06,108.12 142.79,108.12 142.68,108 142.41,108 142.3,108.12 142.03,108.12 141.91,108 141.64,108 141.53,108.12 141.26,108.12 141.15,108 140.88,108 arc(140.63,107.95) 140.43,107.82 139.74,107.13 arc(139.27,106.81) 138.71,106.7 138.46,106.7
PCIE_RC_RXN13: length 83
  TOP w0.097: J14.A73 202.09,89.6 arc(202.04,89.57) 201.99,89.56 200.73,89.56
  ART07 w0.114: 138.46,107.73 138.43,107.73 138.4,107.7 138.17,107.7 arc(137.97,107.75) 137.82,107.89 137.82,107.9 arc(137.6,108.12) 137.31,108.2 arc(137.12,108.25) 136.98,108.38 136.96,108.42 arc(136.45,108.72) 135.94,108.42 135.93,108.4 arc(135.93,108.4) 135.93,108.4 135.92,108.39 arc(135.78,108.25) 135.57,108.2 arc(135.41,108.23) 135.27,108.34 135.3,108.44 U1.AH59
  ART07 w0.135: 200.73,89.56 200.45,89.28 200.23,89.28 arc(200.06,89.31) 199.93,89.4 199.91,89.42 199.4,89.93 arc(198.7,90.98) 198.45,92.23 198.45,93.89 arc(198.36,94.33) 198.11,94.7 193.35,99.46 arc(192.98,99.71) 192.54,99.8 189.88,99.8 arc(189.53,99.86) 189.25,100.06 187.53,101.77 arc(187.34,102.06) 187.27,102.4 187.27,103.2 arc(187.02,103.81) 186.4,104.06 186.07,104.06 arc(185.87,104.1) 185.7,104.22 185.14,104.77 arc(184.95,105.06) 184.88,105.4 184.88,105.75 arc(184.8,106.19) 184.55,106.56 182.86,108.25 arc(182.49,108.5) 182.05,108.58 172.74,108.58 arc(172.46,108.64) 172.23,108.8 172.14,108.88 arc(171.82,109.09) 171.45,109.17 169.25,109.17 arc(168.82,109.08) 168.45,108.83 168.36,108.74 arc(168.07,108.55) 167.73,108.48 153.98,108.48 arc(153.64,108.55) 153.36,108.74 150.62,111.48 arc(150.25,111.72) 149.82,111.81 142.73,111.81 arc(142.27,111.72) 141.89,111.46 141.15,110.73 140.99,110.73 140.8,110.54 140.8,110.38 140.61,110.19 140.45,110.19 140.26,109.99 140.26,109.83 140.05,109.63 arc(139.94,109.46) 139.9,109.26 139.9,109.06 arc(139.83,108.69) 139.62,108.38 139.25,108.01 arc(138.94,107.8) 138.57,107.73 138.46,107.73
