# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Nets (continued)
Pads without a net: D1 1 2 3 7 8; D41 1 2 3 7 8; J14 A19 A32 A33 A50 B30 B82; J18 6 7 8; J35 7 8; NOREF 1; NOREF#2 1; NOREF#3 1; NOREF#4 1; NOREF#7 1; NOREF#9 1; NOREF#11 1; NOREF#13 1; NOREF#14 1; NOREF#15 1; NOREF#16 1; NOREF#18 1; NOREF#19 1; NOREF#20 1; NOREF#23 1; NOREF#24 1; NOREF#25 1; NOREF#26 1; NOREF#27 1; NOREF#29 1; NOREF#31 1; NOREF#32 1; NOREF#33 1; NOREF#34 1; NOREF#36 1; NOREF#37 1; NOREF#38 1; NOREF#39 1; NOREF#40 1; NOREF#41 1; NOREF#42 1; NOREF#43 1; NOREF#44 1; SW6 4 5; U1 A20 A22 A24 A26 A28 A30 A34 A36 A38 AA10 AA12 AA14 AA16 AA18 AA20 AA42 AA44 AA46 AA48 AA52 AA56 AA62 AB11 AB13 AB15 AB17 AB19 AB43 AB45 AB47 AB55 AB61 AC14 AC16 AC18 AC42 AC44 AC46 AC56 AC62 AD15 AD17 AD43 AH19 AJ20 AJ46 AM19 AP17 AT17 AT19 B19 B21 B23 B27 B29 B31 B33 B35 B37 BK49 BL44 BL46 BL48 BL50 BM45 BM47 BM49 BN44 BN46 BN50 BP47 BR50 BT45 BT47 BT49 BT51 BT53 BT59 BU14 BU16 BU44 BU46 BU48 BU50 BU52 BU60 BV13 BV15 BV17 BV19 BV45 BV47 BV49 BV51 BV53 BV55 BY15 BY17 BY21 BY57 C14 C20 C22 C24 C26 C28 C30 C54 CA14 CA16 CA18 CA50 CA56 CB1 CB7 CB13 CB15 CB17 CB19 CB21 CB51 CC2 CC8 CC14 CC16 CC18 CC20 CC22 CC50 CE4 CE6 CE8 CE10 CE12 CE14 CE18 CE20 CE26 CE28 CE50 CF1 CF3 CF5 CF7 CF11 CF13 CF15 CF17 CF19 CF25 CF27 CF29 CF41 CF45 CF47 CF49 CG4 CG6 CG8 CG10 CG12 CG14 CG18 CG20 CG26 CG28 CG46 CG48 CH1 CH3 CH5 CH7 CH11 CH13 CH15 CH17 CH19 CH25 CH27 CH29 CH45 CH47 CH49 CH53 CK1 CK3 CK5 CK7 CK11 CK13 CK15 CK17 CK19 CK21 CK25 CK27 CK29 CK45 CK47 CK49 CK53 CK61 CL4 CL6 CL8 CL10 CL12 CL14 CL18 CL24 CL26 CL28 CL52 CL54 CM1 CM3 CM5 CM7 CM11 CM13 CM15 CM17 CM19 CM21 CM25 CM27 CM29 CM45 CM47 CM49 CM53 CM55 CM61 CN4 CN6 CN8 CN10 CN12 CN14 CN18 CN24 CN26 CN28 CN46 CN48 CN50 CN54 CR12 CR14 CR18 CR20 CR22 CR26 CR28 CR34 CR48 CT11 CT13 CT15 CT17 CT19 CT21 CT25 CT27 CT29 CT41 CT55 CU8 CU10 CU12 CU14 CU18 CU20 CU22 CU26 CU28 CV1 CV5 CV11 CV13 CV15 CV17 CV19 CV21 CV25 CV27 CV29 CY3 CY11 CY13 CY15 CY17 CY19 CY21 CY25 D7 D19 D21 D23 D27 D29 D31 D33 D35 D37 DA4 DA6 DA8 DA10 DA12 DA14 DA18 DA20 DA24 DA26 DA28 DB5 DB7 DB11 DB13 DB15 DB17 DB19 DB21 DB25 DC6 DC8 DC10 DC12 DC14 DC18 DC20 DC24 DC26 DC28 F19 F21 F23 F27 F29 F31 F33 F35 F37 F51 F59 G20 G22 G24 G26 G28 G30 G34 G36 G38 G50 G58 G62 H7 H19 H21 H23 H27 H29 H31 H33 H35 H37 H51 H57 H59 J14 J20 J22 J24 J26 J28 J30 J50 J52 J58 J62 L12 L42 L56 L58 L62 M35 M43 M47 M57 M59 M61 N14 N28 N34 N40 N42 N54 N56 N58 N62 P15 P21 P35 P41 P43 P47 P55 P57 P59 P61 T35 T37 T51 T55 T57 T59 T61 U50 U54 U56 U58 U62 V7 V21 V35 V37 V49 V51 V55 V61 W28 W36 W38 W50 W52 W54 W56 W58 W62; U2 A3 A4 C3 C4; U11 A2 C2; U14 A2 C2; U15 2 3 4 13 22 37 38 44 46 49 50 51 54 56 70 79 80 83 84 86 87 89 90 91 92 93 94 95; U17 A4 C4; U21 54; U23 A4 A5 A6 A7 A8 A9 A12 A13 A16 A17 B4 B7 B9 B11 B12 B13 B14 C7 C9 C10 C11 C12 C14 C18 D12 D13 E1 E18 F5 F11 F12 F18 G7 H1 H2 J3 J4 K11 K15 L3 M8 M9 N4 P4 P16 P17 R4 R9 T5 T6 T7 T8 T9 T11 T12 U7 U17 V6 V7 V9 V10 V11 V16 V17; U24 1; U25 1; U28 3; U29 E18 G7 K15 K16 L15 L16 M18 N18 P16 P17 P18 R1 R2 R18 T10 T11 T12 V9 V11; U31 6 22; U32 5 11; U33 5; U34 1 9 16 17 20 21 24 25 26 27 28; U35 20 28 30; U36 5 9 10 21; U37 5 9 10 13 21; U38 23 26 27; U46 4 5 6 7 8 9 10 11 12 13; U48 1 14; U53 C12 E10; U54 26 34 35 36 37 38 39 42 45 46 49; U59 C10 E11 H11 K10; U79 A3 C3; U84 5; U87 23 24 25 26; U88 23 24 25 26; U89 23 24 25 26; U90 23 24 25 26

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 691 vias
v2: diameter 0.406, hole 0.152, TOP to BOTTOM, 6194 vias
v3: diameter 0.508, hole 0.203, TOP to BOTTOM, 2721 vias
v4: diameter 0.61, hole 0.305, TOP to BOTTOM, 1400 vias
v5: diameter 1.27, hole 0.711, TOP to BOTTOM, 224 vias
v6: diameter 0.457, hole 0.203, TOP to BOTTOM, 115 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V: length 77.6
  TOP w0.254: U15.15 v2(24.29,19.86) ; U15.62 25.19,12.09 v2(24.99,12.29) ; U15.10 25.79,18.33 v2(25.63,18.16) ; v2(27.12,18.13) 26.99,18.27 U15.6 ; U15.1 28.49,19.94 v2(28.49,19.94) ; U15.57 v2(23.69,10.54) ; v2(26.54,10.54) 26.69,10.69 U15.67 ; U15.85 29.13,15.24 29.51,15.62 v2(29.72,15.62) ; U15.71 v2(27.89,10.59)
  ART03 w0.254: v2(35.38,12.02) 35.38,11.79 35.63,11.53 36.19,11.53 39.67,15.01 39.67,16.03 42.06,18.41 49.32,18.41 49.71,18.8 49.71,19.68 44.75,24.64 38.43,24.64 34.85,28.22 34.85,33.12 36.91,35.18 36.91,41.66 43.51,48.26 v2(44.36,48.26)
  BOTTOM w0.254: U32.22 45.57,49.13 45.58,49.11 45.58,48.38 45.31,48.11 44.51,48.11 v2(44.36,48.26) ; v2(35.99,12.75) 38.91,15.67 38.91,17.72 v2(39.73,18.53)
  vias: v2(34.62,12.93) v2(34.62,12.01) v2(35.36,12.93) v2(35.99,12.01) v2(41.53,14.83) v2(41.53,13.56) v2(41.53,12.29) v2(42.8,13.56) v2(42.8,12.29)
1.8V: length 108.1
  TOP w0.254: U23.P8 v2(42.74,171.12) ; U45.1 170.87,126.24 170.8,126.17 C945.2 ; C1410.2 163.99,126.24 U81.1 ; U23.P9 v2(42.73,171.92) ; R972.2 v3(163.8,143.26) ; R435.2 v3(168.88,143.26) ; R433.1 v3(170.15,143.26) ; U23.N9 v2(41.93,171.92) ; R501.2 v3(174.22,123.32) ; R371.1 160.75,83.31 v3(160.14,83.92) ; U23.P7 v2(42.74,170.32) ; R500.2 v3(169.9,123.32)
  TOP w0.305: R73.2 40.02,145.49 v2(39.42,145.49) ; R77.2 v2(42.16,159.77)
  TOP w0.508: R373.1 v4(159.97,89.66) ; v4(169.61,126.17) C945.2 ; C1410.2 163.61,125.03 v4(163.68,124.97) ; R372.1 v3(160.02,88.39) ; R504.2 v4(175.51,124.59)
  ART03 w0.381: v3(157.29,137.08) 157.78,137.08 159.38,135.48 159.38,131.6 v3(158.09,130.3)
  ART05 w0.254: v2(163.19,17.04) 161.87,18.36 161.87,24.33 160.35,25.86 v4(149.76,25.86)
  ART20 w0.508: v2(84.96,42.86) 83.78,41.68 83.11,41.68 82.22,40.79 52.55,40.79 49.53,43.81 48.82,43.81 48.17,44.46 48.17,45.17 46.81,46.54 v4(46.81,48.56)
  BOTTOM w0.254: R385.2 v3(174.09,155.7) ; U32.20 46.57,48.76 46.76,48.56 v4(46.81,48.56) ; v3(178.82,155.7) 178.82,155.07 178.79,155.04 R387.2 ; R386.2 183.23,155.04 183.26,155.07 v3(183.26,155.7) ; v3(192.41,155.7) 192.41,154.94 192.38,154.91 R946.2 ; R384.2 169.26,155.14 169.29,155.17 v3(169.29,155.7) ; R945.2 v3(187.81,155.7)
  BOTTOM w0.508: L31.1 198.69,60.45 v3(199.01,60.13) ; L26.1 172.15,50.93 C905.2 ; v3(199.01,56.07) 198.69,56.39 L28.1 ; L33.1 198.69,62.99 v3(199.01,63.31) ; L24.1 170.09,55.56 v3(169.39,55.56) ; L22.1 169.45,57.78 v3(169.39,57.72)
  vias: v1(152.5,25.02) v1(152.5,23.75) v1(152.5,22.48) v1(153.77,25.02) v1(153.77,23.75) v1(153.77,22.48) v1(155.04,25.02) v1(155.04,23.75) v1(155.04,22.48) v1(156.31,25.02) v1(156.31,23.75) v1(157.58,25.02) v1(157.58,23.75) v2(169.07,90.38) v2(169.87,90.38) v2(170.67,90.38) v2(171.47,90.38) v2(176.01,85.64) v2(176.88,85.62) v2(177.85,84.43) v2(177.98,85.57) v3(46.55,111.89) v3(46.96,104.64) v3(46.96,103.76) v3(47.81,103.72) v3(48.39,104.33) v3(86.33,30.29) v3(90.78,41.4) v3(90.78,40.51) v3(91.79,41.4) v3(91.79,40.51) v3(92.48,31.27) v3(92.45,30.15) v3(93.34,31.27) v3(93.34,30.17) v3(94.59,37.78) v3(95.48,41.15) v3(95.48,40.13) v3(96.37,41.15) v3(96.37,40.13) v3(102.52,36.45) v3(151.43,37.24) v3(151.46,36.35) v3(152.35,37.21) v3(152.4,36.33) v3(158.09,129.29) v3(158.09,128.4) v3(159.1,128.4) v3(160.09,145.41) v3(160.12,144.65) v3(160.12,143.76) v3(160.25,128.4) v3(160.98,145.41) v3(161.01,144.65) v3(161.01,143.76) v3(161.87,145.41) v3(161.9,144.65) v3(161.9,143.76) v3(171.85,51.23) v3(175.49,139.83) v3(175.49,138.94) v3(176.38,139.83) v3(176.38,138.94) v3(177.26,139.83) v3(177.26,138.94) v4(146.94,26.77) v4(146.96,25.86) v4(146.96,24.08) v4(148.23,24.97) v4(148.28,26.81) v4(148.31,24.09) v4(148.39,25.91) v4(149.73,26.77) v4(149.76,24.08)
1.8V_SI5338_0: length 9
  BOTTOM w0.254: 154.02,34.54 154.58,33.99 U36.7 ; U36.11 156.58,33.89 156.46,34.01 v3(156.46,34.56) ; v3(159.29,30.73) 158.96,31.07 U36.16 ; v3(156.59,27.95) 156.58,27.96 U36.20 ; v3(154.43,27.95) 154.43,28.86 154.58,29 U36.24 ; v3(159.29,31.75) 159.11,31.57 U36.15
  vias: v3(152.4,35.45) v3(152.55,34.49) v3(153.49,34.49) v3(153.8,35.45) v3(155.07,36.33)
1.8V_SI5338_1: length 8.6
  BOTTOM w0.254: U37.11 51.93,112.45 v3(51.94,112.46) ; U37.16 54.29,109.1 v3(54.55,108.84) ; U37.15 54.03,109.6 v3(54.55,110.11) ; 49.93,106.98 U37.24 ; v3(52.2,105.85) 51.93,106.12 U37.20 ; U37.4 v2(48.44,109.6) ; v3(49.4,112.46) 49.93,111.93 U37.7
  vias: v3(48.39,105.22) v3(48.61,106.17) v3(49.63,106.17) v3(49.66,105.22) v3(50.42,113.35)
2.5V: length 74.7
  TOP w0.203: v2(27.79,13.92) 27.79,13.64 28.28,13.14 U15.78
  TOP w0.254: v2(20.19,15.62) 20.41,15.84 U15.35 20.94,15.84 21.24,15.54 U15.36 ; U15.5 v2(27.29,19.93) ; U2.B1 76.37,60.71 v3(76.17,60.9) ; U15.45 v2(20.18,12.84) ; U15.66 v2(26.39,12.5) ; v2(22.49,19.94) 22.49,19.94 U15.21 ; U15.63 v2(25.49,10.61) ; U6.B1 v2(126.03,141.72) ; U15.88 v2(27.89,16.14) ; U5.R9 v2(107.4,152.92) ; v2(27.86,12.27) 28.19,11.94 U15.72 ; v2(22,12.65) 22,12.34 21.59,11.94 U15.48 ; v2(22.65,12.29) 22.5,12.29 22.19,11.98 U15.52 ; U4.B1 v2(103.17,141.72) ; U3.R9 v2(84.54,152.92) ; U7.R9 v2(73.11,152.92) ; U3.B1 v2(91.74,141.72) ; U15.26 21.59,18.54 v2(21.99,18.13) ; U15.32 21.71,16.74 v2(21.94,16.51) ; U15.40 v2(21.96,14.34) ; U4.R9 v2(95.97,152.92) ; U15.96 v2(29.67,18.84) ; U7.B1 v2(80.31,141.72) ; U5.B1 v2(114.6,141.72) ; U6.R9 v2(118.83,152.92) ; v2(34.67,21.59) U16.B1
  ART03 w2.032: J15.9 13.89,7.88 14.76,7.01 16.54,7.01
  ART07 w0.254: v4(78.84,27.43) 79.65,28.24 94.16,28.24 95.94,26.47 95.94,16.71 v3(96.01,16.64)
  BOTTOM w0.254: v2(46.06,48.23) U32.21 ; C373.1 v3(76.17,60.9) C372.1 ; C626.1 C643.1 ; R252.2 v2(18.99,6.29)
  BOTTOM w0.381: C1497.2 104.33,139.78 C1492.1 C1489.1 ; C1521.1 C1520.1 127.19,140.24 C1528.2 ; v2(70.67,154.92) 70.39,154.64 C1553.1 ; C1526.1 C1527.1 115.76,140.26 C1529.2 ; C1559.2 81.47,140.14 C1551.1 80.36,141.73 C1552.1 ; C1496.1 C1495.1 92.9,139.95 C1498.2
  BOTTOM w0.508: FB15.2 v3(23.09,5.28)
  vias: v1(84.38,25.02) v1(84.38,23.75) v1(84.38,22.48) v1(85.65,25.02) v1(85.65,23.75) v1(85.65,22.48) v1(86.92,25.02) v1(86.92,23.75) v1(86.92,22.48) v1(88.19,25.02) v1(88.19,23.75) v1(89.46,25.02) v1(89.46,23.75) v2(26.04,5.91) v2(29.21,5.91) v2(32.38,5.91) v2(48.26,138.18) v2(48.26,137.16) v2(48.26,136.14) v2(48.26,135.13) v2(48.26,134.11) v2(48.26,133.1) v2(49.28,138.18) v2(49.28,137.16) v2(49.28,136.14) v2(49.28,135.13) v2(49.28,134.11) v2(49.28,133.1) v2(50.29,138.18) v2(50.29,137.16) v2(50.29,136.14) v2(50.29,135.13) v2(50.29,134.11) v2(50.29,133.1) v2(51.31,138.18) v2(51.31,137.16) v2(51.31,136.14) v2(51.31,135.13) v2(51.31,134.11) v2(51.31,133.1) v2(77.82,57.59) v2(79.09,57.59) v2(84.49,155.32) v2(86.87,62.74) v2(86.87,61.72) v2(86.87,60.71) v2(87.88,62.74) v2(87.88,61.72) v2(87.88,60.71) v2(88.9,62.74) v2(88.9,61.72) v2(88.9,60.71) v2(95.92,155.32) v2(107.35,155.32) v2(118.78,155.32) v3(31.54,20.07) v3(31.56,22.61) v3(31.56,21.34) v3(31.56,18.8) v3(35.68,5.89) v3(38.98,5.89) v4(78.87,26.24) v4(78.87,24.46) v4(80.11,28.96) v4(80.11,27.43) v4(80.14,25.35) v4(80.18,24.47) v4(80.27,26.29) v4(81.58,29.01) v4(81.58,27.48) v4(81.66,26.24) v4(81.66,24.46)
2.5V_PRE: length 28.4
  BOTTOM w0.305: 158.88,212.85 159.11,212.62 159.11,209.45 158.57,208.91 150.98,208.91 150.72,209.17 150.72,212.6 150.98,212.85 158.88,212.85
  BOTTOM w0.508: D41.6 C1595.1 R986.1 R107.1
3.3V: length 117
  TOP w0.229: U11.B1 55.5,85.73 v3(55.47,85.76)
  TOP w0.254: v3(55.56,92.2) 55.5,92.14 U14.B1 ; R910.2 192.36,61.16 v2(192.43,61.09) ; v3(65.56,92.72) 66.04,92.23 U13.B1 ; v4(170.22,127.83) C946.2 170.94,127.79 171.81,126.92 U45.8 ; U41.B1 v2(181.71,69.72) ; R375.2 160.17,87.27 159.38,88.06 159.38,89.36 v2(159.03,89.71) 158.72,90.02 157.66,90.02 157.34,90.33 R376.2 157.36,90.85 R378.2 ; v3(174.82,110.74) 174.79,110.77 174.22,110.77 173.35,111.64 U31.15 ; J14.A10 v3(200.52,24.65) ; U42.B1 v2(167,53.47) ; U31.17 174.17,112.64 v3(174.82,113.28) ; U40.B1 v2(167,48.87) ; U10.B1 66.04,85.41 v3(66.1,85.47) ; R558.1 43.99,23.88 v2(44.12,23.75) ; v3(168.6,208.41) U18.B6 ; v3(161.97,208.53) U19.B6 ; U79.B1 v2(167,43.72) ; J14.A9 v3(200.6,23.65)
  TOP w0.381: R454.2 v3(186.66,46.93) ; R765.1 v2(143.37,139.29)
  TOP w0.508: R438.2 v4(156.06,101.85) ; R506.2 v4(173.35,129.41) ; R507.2 v4(172.34,129.41) ; X2.4 v4(158.56,101.85) C841.1 ; J14.B8 211.86,22.65 v3(212.15,22.35)
  BOTTOM w0.254: R771.2 v3(163.19,26.62) ; U46.3 v3(146.27,33.09) ; R780.2 v3(96.49,22.94) ; R6071.2 v3(97.03,23.85) ; R682.2 22.1,44.35 v3(22.68,44.93) ; C536.1 v3(185.78,119.76) ; v3(154.11,150.34) 154.21,150.44 154.21,150.81 154.28,150.87 R857.2 ; R6079.2 v3(49.73,46.23) ; R5421.1 v3(53.51,30.95) ; v3(32.64,130.89) 32.23,130.48 R6078.2 R6054.2 ; R6044.2 32,42.09 v3(32.23,42.32) ; v3(152.63,150.62) 152.88,150.88 R11.2 ; R291.1 v2(161.16,215.94) ; v2(183.39,93.88) 183.42,93.92 183.42,94.42 v2(183.61,94.61) ; R5448.1 v3(94.93,10.45) ; R6050.2 15.76,42.85 v3(14.82,42.85) ; R704.2 6.78,46.15 6.65,46.28 v3(6.64,46.28) ; R290.1 v2(164.47,215.91) ; R289.1 v2(167.77,215.96) ; R6077.2 14.1,43.03 v3(14.72,43.65) ; R6081.2 v3(164.87,14.33) ; R875.2 R874.2 181.76,64.21 v2(181.25,64.72) ; R6046.2 v3(141.07,13.56) ; R288.1 v2(171.07,215.94) ; v3(150.09,150.62) R9.2 ; R884.2 R883.2 v2(178.28,50.29) ; R5394.1 v3(120.92,14.52) ; R929.1 v3(213.04,20.19) ; R6082.2 v3(97.08,25.15) ; v3(27.09,121.41) R1013.2 ; R5391.1 v3(35.57,34.95) ; v3(121.14,20.54) 121.14,20.51 121.48,20.18 R6080.2 ; R6075.2 30.75,40.96 30.81,41.02 30.81,41.03 v3(30.94,41.16) ; v3(187.46,71.48) 187.15,71.16 L30.1 ; v3(68.73,73.91) 68.68,73.86 C551.1 ; R6067.2 v3(164.77,13) ; R5403.1 v3(18.12,36.87) ; R886.1 v2(189.77,55.57) R885.1 ; v3(151.48,150.75) R10.2 ; v3(143.69,19.67) 143.69,20.03 R6076.2 ; R751.2 v3(116.64,22.94) ; R6058.2 v3(48.31,46.3) ; R5412.1 v3(17.04,123.58) ; R930.1 v3(213.04,18.83) ; R695.2 v3(141.38,22.94) ; R5439.1 150.13,14.55 150.88,14.55 v3(151.13,14.81) ; v3(63.69,88.39) v3(63.69,89.41) ; v3(62.13,46.71) 61.91,46.93 C944.2 62.99,47.37 63.12,47.24 U44.8 ; R873.2 v2(192.25,58.04) ; R6062.2 v3(121.48,18.76) ; R5430.1 107.84,9.5 v3(106.32,9.5) ; R719.2 33.6,44.98 v3(33.25,44.63) ; R287.1 v3(173.01,213.68)
  BOTTOM w0.381: R502.1 v3(60.5,44.7)
  BOTTOM w0.508: R286.1 v3(176.18,213.68) ; R285.1 v3(179.49,213.68) ; L35.1 v3(191.17,43.05) ; v3(45.26,44.48) 44.64,44.48 v3(44.44,44.27) ; v3(192.42,71.48) 192.74,71.16 L27.1 ; R405.1 39.83,45.34 v3(39.04,46.13) ; R284.1 v3(182.79,213.55) ; v3(177.99,71.27) 177.9,71.18 L25.1 ; v3(199.01,68.13) 198.69,68.45 L21.1 ; v3(199.01,52.01) 198.69,52.32 L32.1 ; R573.1 v3(186.09,213.68) ; C909.2 v3(176.88,46.99) 177.39,47.5 L29.1 ; R5304.1 17.89,45.48 17.58,45.8 v3(16.89,45.8) ; v3(175.27,71.35) 174.72,70.8 L23.1 ; L17.1 v2(165.1,83.21)
  vias: v1(5.84,39.5) v1(5.84,38.23) v1(7.11,39.5) v1(7.11,38.23) v1(7.11,36.96) v1(8.38,38.23) v1(10.92,38.23) v1(12.19,38.23) v1(13.46,38.23) v1(15.77,143.71) v1(15.77,142.44) v1(16,39.5) v1(16,38.23) v1(18.31,143.71) v1(19.58,143.71) v1(20.85,143.71) v1(23.24,36.45) v1(23.24,35.18) v1(23.39,143.71) v1(24.51,36.45) v1(24.51,35.18) v1(24.51,33.91) v1(24.66,144.98) v1(24.66,143.71) v1(24.66,142.44) v1(25.78,35.18) v1(25.93,143.71) v1(25.93,142.44) v1(28.32,35.18) v1(29.59,35.18) v1(30.86,35.18) v1(33.4,36.45) v1(33.4,35.18) v1(40.51,38.61) v1(40.51,37.34) v1(41.78,38.61) v1(41.78,37.34) v1(41.78,36.07) v1(43.05,37.34) v1(45.59,37.34) v1(46.86,37.34) v1(48.13,37.34) v1(50.67,38.61) v1(50.67,37.34) v1(86.92,21.21) v1(88.19,22.48) v1(88.19,21.21) v1(88.19,19.94) v1(88.19,17.4) v1(88.19,16.13) v1(88.19,14.86) v1(88.19,12.32) v1(89.46,22.48) v1(89.46,21.21) v1(89.46,12.32) v1(107.06,21.21) v1(108.33,22.48) v1(108.33,21.21) v1(108.33,19.94) v1(108.33,17.4) v1(108.33,16.13) v1(108.33,14.86) v1(108.33,12.32) v1(109.6,22.48) v1(109.6,21.21) v1(109.6,12.32) v1(131.8,21.21) v1(133.07,22.48) v1(133.07,21.21) v1(133.07,19.94) v1(133.07,17.4) v1(133.07,16.13) v1(133.07,14.86) v1(133.07,12.32) v1(134.34,22.48) v1(134.34,21.21) v1(134.34,12.32) v1(155.04,21.21) v1(156.31,22.48) v1(156.31,21.21) v1(156.31,19.94) v1(156.31,17.4) v1(156.31,16.13) v1(156.31,14.86) v1(156.31,12.32) v1(157.58,22.48) v1(157.58,21.21) v1(157.58,12.32) v2(44.4,22.7) v2(44.4,21.81) v2(45.42,22.7) v2(45.42,21.81) v2(163.04,102.21) v2(164.24,102.18) v2(165.89,102.39) v2(165.87,88.78) v2(166.94,52.32) v2(166.94,42.67) v2(166.97,47.9) v2(167.47,93.58) v2(167.47,92.78) v2(167.47,91.98) v2(168.27,96.78) v2(168.27,93.58) v2(168.27,91.98) v2(169.87,94.38) v2(170.67,93.58) v2(171.47,94.38) v2(172.27,93.58) v2(173.61,102.11) v2(173.87,96.78) v2(173.87,91.18) v2(174.34,149.03) v2(175.03,102.26) v2(176.31,60.07) v2(176.31,58.93) v2(176.66,102.21) v2(177.39,149.03) v2(180.44,149.03) v2(180.85,69.72) v2(181.46,46.46) v2(182.98,46.46) v2(183.49,149.03) v2(185.77,118.87) v2(186.28,48.96) v2(186.54,149.03) v2(189.61,149.03) v2(191.82,119.96) v2(191.87,94.36) v2(191.97,93.62) v2(192.13,119.41) v2(192.25,95.12) v2(192.63,94.36) v2(192.66,149.03) v3(8.26,82.04) v3(12.7,82.17) v3(15.88,48.86) v3(18.03,82.17) v3(34.08,90.65) v3(34.69,90.07) v3(35.46,90.65) v3(36.07,90.07) v3(38.58,71.42) v3(38.58,70.31) v3(38.73,69.29) v3(38.71,67.92) v3(43.06,56.64) v3(52.77,92.46) v3(53.15,84.71) v3(53.15,83.44) v3(53.15,82.17) v3(53.28,90.04) v3(53.28,89.03) v3(54.46,85.76) v3(55.56,93.22) v3(58.82,95.66) v3(58.93,100.02) v3(58.87,99.19) v3(58.87,96.49) v3(60.14,100.02) v3(60.12,99.19) v3(60.09,96.49) v3(60.07,95.66) v3(61.56,92.35) v3(62.4,83.69) v3(63.18,85.72) v3(63.18,82.68) v3(63.18,81.66) v3(64.36,93.6) v3(66.11,86.44) v3(66.83,92.72) v3(67.67,73.03) v3(68.61,66.98) v3(68.91,73.03) v3(68.93,67.82) v3(69.49,67.01) v3(69.93,74.37) v3(70,67.72) v3(73.6,48.9) v3(76.2,48.45) v3(134.97,76.52) v3(143.83,142.11) v3(146.62,152.4) v3(147.16,34.36) v3(171.83,116.27) v3(173.1,116.27) v3(174.67,65.27) v3(175.11,64.01) v3(175.7,114.55) v3(175.7,112.01) v3(175.7,109.47) v3(176.25,54.61) v3(176.31,57.4) v3(176.31,55.63) v3(194.18,194.72) v3(195.35,194.64) v3(195.55,24.56) v3(195.58,23.44) v3(196.42,24.56) v3(196.44,23.44) v3(197.3,24.56) v3(197.33,23.42) v3(198.37,24.83) v3(198.37,23.42) v3(198.56,28.7) v3(199.64,24.83) v3(199.57,23.42) v4(11.43,32.04) v4(11.43,30.9) v4(11.46,29.86) v4(11.46,28.71) v4(12.55,31.04) v4(12.55,29.67) v4(12.52,28.6) v4(12.57,32.03) v4(17.07,153.1) v4(17.07,151.96) v4(17.7,150.36) v4(17.7,149.21) v4(18.26,153.28) v4(18.26,152.13) v4(28.83,28.99) v4(28.83,27.85) v4(28.96,26.71) v4(28.96,25.57) v4(29.95,27.99) v4(29.97,28.98) v4(30.05,26.52) v4(30.02,25.45) v4(46.1,31.15) v4(46.1,30.01) v4(46.35,28.99) v4(46.35,27.85) v4(47.24,31.14) v4(47.22,30.15) v4(47.45,28.8) v4(47.42,27.74) v4(78.07,16.89) v4(78.08,15.8) v4(79.12,15.7) v4(79.21,16.89) v4(80.06,15.75) v4(80.3,16.84) v4(81.13,15.72) v4(81.45,16.84) v4(97.92,15.37) v4(98.02,16.61) v4(98.83,16.61) v4(98.78,15.37) v4(99.64,15.54) v4(100,16.61) v4(100.71,15.52) v4(101.1,16.64) v4(122.64,16.31) v4(122.69,15.27) v4(123.65,16.31) v4(123.7,15.27) v4(124.56,15.49) v4(124.66,16.43) v4(125.63,15.47) v4(125.7,16.41) v4(126.75,15.39) v4(146,16.05) v4(145.96,14.91) v4(146.84,14.96) v4(146.91,16) v4(147.8,16.41) v4(147.75,15.37) v4(148.82,15.34) v4(148.89,16.38) v4(150.06,15.67) v4(189.46,196.62) v4(189.46,195.78) v4(189.46,194.34) v4(189.48,193.04) v4(189.83,191.74) v4(190.84,191.77) v4(190.96,195.86) v4(191.06,194.37) v4(191.08,193.36) v4(191.8,195.86) v4(192.37,191.67) v4(192.84,196.55) v4(192.76,194.35) v4(192.79,193.33) v4(192.89,195.71) v4(193.38,191.69) v4(193.88,195.83) v4(194.11,187.97) v4(194.13,186.96) v4(194.72,195.83) v4(195.14,186.89) v4(195.19,188.04) v4(196.2,188.06) v4(197.57,186.77) v4(197.74,195.07) v4(197.74,193.8) v4(197.74,192.53) v4(197.74,191.26) v4(198.69,186.79) v4(199.01,195.07) v4(199.01,193.8) v4(199.01,192.53) v4(199.01,191.26) v4(199.01,189.99) v4(199.01,188.72) v4(200.28,195.07) v4(200.28,193.8) v4(200.28,192.53) v4(200.28,191.26) v4(200.28,189.99) v4(207.9,195.07) v4(209.17,195.07) v4(209.17,193.8) v4(209.17,192.53) v4(210.44,195.07) v4(210.44,193.8) v4(210.44,192.53) v4(210.44,191.26) v4(210.44,189.99) v4(210.44,188.72) v4(211.71,195.07) v4(211.71,193.8) v4(211.71,192.53) v4(211.71,191.26) v4(211.79,186.64) v4(211.79,185.57) v4(212.83,191.56) v4(212.9,189.84) v4(212.88,188.67) v4(212.85,186.69) v4(212.85,185.62) v4(213.64,193.7) v4(213.62,192.53) v4(214.71,186.51) v4(214.73,185.5) v4(215.01,192.45) v4(215.14,193.65) v4(215.11,191.06) v4(215.16,189.71) v4(215.16,188.11) v4(215.77,186.56) v4(215.8,185.55) v4(216.2,193.7) v4(216.15,192.3) v4(216.18,191.11) v4(216.23,189.76) v4(216.23,188.16)
3.3V_PRE: length 398.5
  TOP w0.254: U21.11 19.31,174.78 v2(19.13,174.6) ; U23.G5 v2(36.33,168.72) ; R924.2 v3(164.69,128.97) ; U23.H13 v2(37.13,175.92) ; v2(40.26,183.96) 40.26,183.96 R181.2 ; R1075.2 78.9,215.77 v3(78.9,216.51) ; U23.J5 v2(37.93,168.72) ; U23.E9 v2(34.73,171.92) ; v2(19.26,178.66) 19.38,178.78 U21.3 ; v3(49.15,185.93) 49.4,186.18 R536.2 ; R543.2 v3(181.91,194.9) ; v3(49.38,188.72) 49.38,188.91 R542.2 ; R5998.1 51.27,139.08 v2(51.18,138.99) ; v2(19.18,176.6) 19.36,176.78 U21.7 ; v3(53.82,144.91) 54.2,144.53 R731.2 ; U23.L6 v2(40.34,169.52) ; R6015.2 v3(44.3,20.68) ; R6043.2 v3(80.21,216.48) ; v2(27.51,181.33) 27.51,180.88 27.3,180.67 U21.43 ; U23.K10 v2(39.54,173.52) ; R336.2 R335.2 R338.2 26.8,159.19 v3(27.69,160.08) ; v3(170.18,175.87) 169.75,175.44 R1130.1 ; U23.E8 v2(34.73,171.12) ; U23.F7 v2(35.54,170.32) ; U23.N6 v2(41.93,169.52) ; R923.2 v3(167.42,128.97) ; v3(32.99,158.62) 33.73,158.62 34.14,159.03 34.14,159.57 R658.1 ; U23.L13 v2(40.34,175.92) ; U23.N13 v2(41.93,175.92) ; U23.G14 v2(36.33,176.72) ; R991.2 28.93,160.11 v3(28.96,160.08) ; U23.H10 v2(37.13,173.52) ; U21.55 v2(21.3,181.32) ; v3(173.2,176.86) 172.87,176.53 R1129.2 ; U23.M13 v2(41.14,175.92) ; U23.E7 v2(34.73,170.32) ; U23.C3 v2(33.13,167.12) ; U23.L9 v2(40.34,171.92) ; U23.L14 v2(40.34,176.72) ; R6007.1 59.78,55.17 v3(58.95,55.17) ; v4(178.03,127.89) 178.22,128.08 C943.2 179.2,127.97 180.07,127.1 U43.8 ; C489.1 v3(61.7,177.42) ; U23.F13 v2(35.54,175.92) ; U23.J14 v2(37.93,176.72) ; v2(21.8,171.8) 21.8,172.63 U21.17 ; U23.J9 v2(37.93,171.92) ; R687.2 v3(28.64,42.35) ; U23.L5 v2(40.34,168.72) ; U23.M5 v2(41.14,168.72) ; R739.2 v3(68.22,53.11) ; R707.2 v3(12.43,45.5) ; v4(163.61,127.89) C1411.2 163.99,126.75 165.41,126.75 U81.8 ; v2(26.8,171.8) 26.8,171.8 U21.27 ; R725.2 v3(47,44.21) ; U23.K5 v2(39.54,168.72) ; U21.32 v2(28.71,174.78) ; U23.H5 v2(37.13,168.72) ; U23.J13 v2(37.93,175.92) ; U23.G13 v2(36.33,175.92) ; R5977.2 v3(82.53,213.53) ; U23.F9 v2(35.54,171.92) ; U23.K14 v2(39.54,176.72)
  TOP w0.305: R79.2 42.56,145.86 v2(42.64,145.95)
  TOP w0.381: U28.4 25.03,166.67 C685.2 v2(24.39,166.48) ; R296.2 v3(18.09,169.81) ; R764.1 v3(146.24,139.76) ; R745.1 v3(73.6,46.74)
  TOP w0.508: C682.1 30.1,160.08 v3(28.96,160.08) v3(27.69,160.08) ; v3(212.15,24.89) 211.42,24.89 211.17,24.65 J14.B10 ; R996.1 v3(160.12,90.93) ; R486.2 v4(180.47,129.67) ; R495.1 v3(145.92,163.51) ; R484.2 v4(181.74,129.67)
  ART03 w0.254: v3(170.18,175.87) 172.21,175.87 v3(173.2,176.86)
  ART03 w0.508: v3(147.12,213.53) 147.12,210.24 v2(148.88,208.48)
  ART05 w0.381: v3(180.31,178.88) 179.82,179.37 175.72,179.37 v3(173.2,176.86)
  ART05 w0.508: v3(145.92,163.51) 148.04,161.39 173.48,161.39 175.31,163.22 180.14,163.22 180.64,162.71 182.58,162.71 183.08,163.22 183.64,163.22 184.15,163.73 184.15,167.06 182.52,168.68 182.52,176.67 v3(180.31,178.88) ; v3(166.69,199.03) 175.01,199.03 v3(175.03,199.02) 175.03,198.7 174.51,198.18 174.51,197.4 175.54,196.37 180.44,196.37 v3(181.91,194.9) ; v4(163.61,127.89) v3(164.69,128.97) v3(167.42,128.97)
  ART07 w0.508: v3(47,44.21) 48.82,42.39 50.65,42.39 51.49,41.55 51.49,33.32 48.84,30.68 48.84,26.07 48.74,25.96 48.74,25.02 47.35,23.62 47.35,21.21 ; v3(167.42,128.97) 169.39,127 170.56,127 171.58,125.98 176.12,125.98 v4(178.03,127.89) 178.69,127.89 v4(180.47,129.67) v4(181.74,129.67)
  ART16 w0.254: 57.91,169.54 57.91,173.63 v3(61.7,177.42)
  ART16 w0.381: v3(46.99,56.64) 45.69,56.64 45.11,56.06 45.11,54.81 46.24,53.68 46.32,53.68 46.75,53.26 46.75,49.54 47.46,48.83 47.46,48.29 47.09,47.93 47.09,45.97 47,45.89 v3(47,44.21) 47.45,43.76 49.17,43.76 51.41,46 51.41,48.44 53.37,50.39 54.74,50.39 56.36,52.02 56.36,52.58 v3(58.95,55.17)
  ART16 w0.508: v2(51.18,138.99) 51,138.81 42.39,138.81 v3(40.23,140.97) 42.84,143.58 49.41,143.58 49.71,143.28 52.2,143.28 v3(53.82,144.91) ; v3(153.83,203.45) 149.31,207.97 149.31,208.05 v2(148.88,208.48) ; v3(59.69,164.72) v3(59.05,165.35) ; v3(166.69,199.03) v3(166.69,200.65) v3(166.69,202.26) v3(166.69,203.88) 166.23,204.34 159.64,204.34 158.24,205.74 158.24,211.57 v2(156.26,213.55) v2(153.21,213.55) 153.19,213.53 v3(150.26,213.53) v3(147.12,213.53) 147.1,213.55 v2(144.15,213.55) v2(141,213.55) 140.99,213.55 v2(138.07,213.55) 135.67,213.55 v2(135.23,213.11)
  BOTTOM w0.254: v2(40.26,183.96) R1057.2 R1056.2 R1055.2 R1054.2 ; v3(82.53,213.53) 82.51,213.51 82.15,213.51 82.13,213.53 R1066.2 ; v2(39.54,173.52) 39.56,173.55 C700.1 ; C696.1 38.34,171.51 v2(37.93,171.92) 37.93,172.01 C690.1 ; v3(202.54,183.37) 203.07,183.9 204.5,183.9 204.9,184.29 R5311.2 ; R792.1 48.3,18.43 v3(48.87,19) ; R575.2 81.57,212.27 R574.2 81.6,212.36 82.03,212.79 v2(82.38,212.79) ; R575.2 81.83,211.04 v2(82.4,211.61) ; R575.2 81.57,210.83 82.64,209.77 R576.2 ; R529.1 v3(7.66,182.65) ; R294.1 34.92,154.56 v2(34.92,154.56) ; R1019.2 v3(22.43,122.99) ; v3(203.78,20.32) R231.2 R232.2 R233.2 202.89,22.86 v3(203.78,23.75) ; R554.2 34.56,148.5 v3(34.92,148.13) ; R6035.2 74.69,214.06 75.67,215.04 77.43,215.04 v3(78.9,216.51) ; v2(33.31,152.27) 33,152.58 U22.4 ; R2295.1 v3(175.03,199.02)
  BOTTOM w0.381: C673.1 26.82,171.83 v2(26.8,171.8) ; v3(27.56,135.57) C681.1 29.27,136.02 U24.24 ; R528.1 v3(46.99,56.64) ; U25.24 39.43,135.89 C679.1 v3(38.34,135.57) ; C677.1 21.74,171.86 v2(21.8,171.8) ; R844.2 v3(30.1,133.94) ; R312.2 v3(16.76,165.96)
  BOTTOM w0.508: v2(135.23,213.11) 135.67,213.55 R347.1 ; R364.1 v2(156.26,213.55) ; R363.1 v2(153.21,213.55) ; R348.1 v2(141,213.55) ; R344.1 v2(138.07,213.55) ; R352.1 v2(144.15,213.55) ; R367.1 v3(147.12,213.53) ; R368.1 v3(150.26,213.53)
  vias: v1(65.37,175.06) v1(65.37,173.79) v1(65.37,172.52) v1(66.64,173.79) v1(66.64,172.52) v2(19.84,169.81) v2(29.36,165.45) v2(29.8,163.49) v2(30.45,166.31) v2(41.27,183.96) v2(42.29,183.96) v2(43.41,183.96) v2(44.55,183.96) v2(45.82,183.96) v2(46.99,181.42) v2(48.07,176.4) v3(16.76,161.61) v3(29.97,156.27) v3(30.1,160.08) v3(30.33,146.37) v3(30.96,159.64) v3(30.96,158.62) v3(30.96,157.73) v3(31.98,159.64) v3(31.98,158.62) v3(31.98,157.73) v3(32.48,146.37) v3(32.95,159.61) v3(32.99,157.73) v3(37.28,161.66) v3(46.94,168.03) v3(47.14,164.96) v3(50.96,168.91) v3(50.96,167.89) v3(51.51,187.58) v3(52.13,168.78) v3(52.47,187.58) v3(54.05,160.02) v3(54.96,160.02) v3(57.91,168.91) v3(57.91,168.15) v3(58.8,168.91) v3(58.8,168.15) v3(59.69,168.91) v3(59.69,168.15) v3(60.58,168.91) v3(60.58,168.15) v3(173.84,15.11) v3(213.01,28.57) v3(213.04,26.16) v3(213.04,23.62) v6(38,165.4)
3.3V_PRE_AGND: length 6.1
  TOP w0.254: v2(60.5,180.95) C2108.2 60.67,180.21 C497.1 R1121.2 v2(61.75,178.82) ; R6034.2 v2(73.65,180.32)
  BOTTOM w0.254: v1(69.18,176.33) 68.58,176.92 V4.2
3.3V_PRE_R: length 9.2
  TOP w0.109: U23.H7 v2(37.13,170.32)
  ART05 w0.114: v2(37.13,170.32) 36.41,170.32 36.04,169.95 32.16,169.95 31.34,169.14 31.34,168.27 30.74,167.68 30.74,167.49 v2(30.45,167.19)
5V: length 35.9
  TOP w0.254: U90.28 128.36,197.77 128.09,198.04 127.86,197.82 U90.29 ; R546.1 191.96,134.87 R6037.1 193.73,134.87 v3(193.9,135.05) ; U87.29 86.87,198.93 87.1,199.16 87.37,198.89 U87.28 ; U89.28 115.26,198.23 114.99,198.5 114.76,198.27 U89.29 ; U88.29 100.97,198.42 101.24,198.7 101.47,198.48 U88.28 ; C2047.1 187.15,200.66 187.81,201.32 187.81,201.78 188.26,202.24 188.54,202.24
  TOP w0.305: R1098.2 C1650.1 87.48,200.43 87.1,200.05 87.1,199.16 ; R5973.2 126.67,200.74 126.82,200.58 C2017.1 127.64,199.8 128.09,199.34 128.09,198.04 ; R5971.2 C1979.1 101.57,200.18 101.24,199.85 101.24,198.7 ; 114.99,198.5 114.99,199.67 115.37,200.05 C1998.1 R5972.2
  BOTTOM w0.508: J49.2 v3(167.89,142.11) ; v3(162.1,133.17) 162.27,133.01 C1622.1 165.01,133.01 166.5,134.49 J49.8
  vias: v1(181.94,204.01) v1(181.94,202.74) v1(183.21,204.01) v1(183.21,202.74) v1(183.21,201.47) v2(46.61,14.83) v2(46.61,13.56) v2(46.61,12.29) v2(46.79,10.71) v2(47.79,10.77) v2(47.79,10.22) v2(48.52,13.6) v2(48.7,12.23) v2(49.06,13.61) v2(49.24,12.23) v2(49.26,10.69) v2(49.27,10.15) v2(56.52,142.88) v2(57.78,142.88) v2(58.5,42.95) v2(58.5,42.32) v2(58.72,45.44) v2(58.72,44.91) v2(59.05,142.88) v2(59.39,45.52) v2(59.39,44.88) v2(59.46,42.98) v2(59.46,42.34) v2(61.32,145.73) v2(61.31,145.11) v2(61.27,143.31) v2(61.26,142.69) v3(87.24,201.59) v3(87.72,201.09) v3(101.34,201.08) v3(101.82,200.58) v3(115.13,200.98) v3(115.61,200.48) v3(127.4,200.83) v3(127.88,200.33) v3(184.19,207.54) v3(184.19,206.53) v3(185.94,207.62) v3(185.94,206.6) v3(185.94,205.59) v3(186.95,207.62) v3(186.95,206.6) v3(186.95,205.59) v3(187.97,207.62) v3(187.97,206.6) v3(187.97,205.59) v3(188.99,207.62) v3(188.99,206.6) v3(188.99,205.59) v3(191.9,164.97) v3(192.02,163.7) v3(192.89,166.83) v4(10.93,117.86) v4(10.95,116.28) v4(11.07,118.9) v4(11.35,117.02) v4(11.51,115.37) v4(11.68,118.35) v4(11.96,116.41) v4(12.06,117.47) v4(20.98,118.19) v4(22.94,119.41) v4(23.11,120.4)
5V_AGND: length 3.7
  TOP w0.508: v2(186.61,198.37) 186.63,198.39 R5994.2 ; v2(185.62,195.73) 185.51,195.62 C2097.2 ; C1827.1 v2(183.86,195.62)
  BOTTOM w0.254: ST18.1 178.87,200.2 v1(179.4,200.2) 179.41,200.19 R2298.2
12V: length 79.1
  TOP w0.203: 71.35,210.16 U54.32
  TOP w0.254: v3(67.93,210.72) 68.49,210.16 71.35,210.16 ; U51.6 51.67,189.61 51.41,189.86 v3(51.41,190.25) ; U58.J1 200.58,137.61 200.58,137.97 199.9,138.65 199.9,140.38 R5323.2 ; U84.2 202.66,6.86 202.54,6.98 v5(201.9,6.98)
  ART03 w0.305: v4(168.45,191.87) 168.45,192.15 168.2,192.41 155.68,192.41 153.49,190.22 153.49,189.18 v4(153.19,188.87)
  ART03 w0.508: 54.71,195.17 54.71,195.17 51.41,191.87 v3(51.41,190.25)
  ART20 w0.508: J21.2 17.75,120.85 18.69,121.79 23.5,121.79 25.02,120.27 28.8,120.27 29.74,121.21 32.03,121.21 32.77,121.95 32.77,125.65 37.69,130.58 37.69,134.24 36.7,135.23 36.7,137.21 37.95,138.46 37.95,141.07 37.59,141.43 37.74,141.58
  BOTTOM w0.508: R541.2 v3(192.43,213.74)
  vias: v1(199.34,165.48) v1(200.61,165.48) v2(38.1,150.24) v2(38.1,149.48) v2(79.25,205.46) v2(79.35,202.38) v2(79.4,204.81) v2(79.37,203.22) v2(80.13,202.4) v2(80.16,205.71) v2(80.16,204.92) v2(80.16,203.22) v3(30.33,149.86) v3(55.04,156.72) v3(55.8,156.69) v3(63.78,204.24) v3(63.78,203.63) v3(63.86,206.3) v3(63.86,205.69) v3(64.64,206.27) v3(64.64,205.66) v3(64.57,204.22) v3(64.57,203.61) v3(66.88,206.38) v3(66.88,205.77) v3(67.67,206.35) v3(67.67,205.74) v3(69.16,206.07) v3(69.16,205.46) v3(69.95,206.04) v3(69.95,205.44) v3(79.4,198.07) v3(80.01,198.07) v3(81.18,198.09) v3(81.81,198.07) v3(83.74,197.31) v3(83.74,196.7) v3(84.38,197.33) v3(84.38,196.72) v3(84.99,197.33) v3(84.99,196.72) v3(85.6,197.33) v3(85.6,196.72) v3(86.31,197.49) v3(86.31,196.82) v3(86.94,197.46) v3(86.87,196.81) v3(87.39,196.79) v3(87.5,197.46) v3(88.17,197.37) v3(88.17,196.84) v3(88.77,197.36) v3(88.77,196.83) v3(89.38,197.36) v3(89.38,196.83) v3(90.01,197.36) v3(90.01,196.83) v3(91.69,197.84) v3(91.82,207.77) v3(91.82,207.01) v3(91.82,206.25) v3(91.82,205.49) v3(92.38,197.82) v3(92.46,207.77) v3(92.46,207.01) v3(92.46,206.25) v3(92.46,205.49) v3(93.01,201.27) v3(93.02,200.34) v3(93.03,198.86) v3(93.04,197.92) v3(93.09,207.77) v3(93.09,207.01) v3(93.09,206.25) v3(93.09,205.49) v3(93.44,196.93) v3(93.73,207.77) v3(93.73,207.01) v3(93.73,206.25) v3(93.73,205.49) v3(94.28,196.93) v3(97.84,196.8) v3(97.84,196.19) v3(98.48,196.82) v3(98.48,196.22) v3(99.09,196.82) v3(99.09,196.22) v3(99.69,196.82) v3(99.69,196.22) v3(100.41,196.98) v3(100.41,196.32) v3(101.04,196.95) v3(100.97,196.31) v3(101.48,196.28) v3(101.6,196.95) v3(102.27,196.86) v3(102.27,196.33) v3(102.86,196.85) v3(102.86,196.32) v3(103.47,196.85) v3(103.47,196.32) v3(104.14,196.85) v3(104.11,196.32) v3(105.79,205.99) v3(105.79,205.23) v3(105.76,197.05) v3(106.43,205.99) v3(106.43,205.23) v3(106.6,197.05) v3(106.68,207.77) v3(106.68,207.01) v3(106.82,201.24) v3(106.83,200.31) v3(107.06,205.99) v3(107.06,205.23) v3(107.31,207.77) v3(107.31,207.01) v3(107.6,196.81) v3(107.7,205.99) v3(107.7,205.23) v3(107.95,207.77) v3(107.95,207.01) v3(108.48,196.81) v3(108.58,207.77) v3(108.58,207.01) v3(109.35,197.03) v3(109.93,197.03) v3(111.63,196.7) v3(111.63,196.09) v3(112.27,196.72) v3(112.27,196.11) v3(112.88,196.72) v3(112.88,196.11) v3(113.49,196.72) v3(113.49,196.11) v3(114.2,196.88) v3(114.2,196.22) v3(114.83,196.85) v3(114.76,196.2) v3(115.28,196.18) v3(115.39,196.85) v3(116.06,196.76) v3(116.06,196.23) v3(116.65,196.75) v3(116.65,196.22) v3(117.26,196.75) v3(117.26,196.22) v3(117.9,196.75) v3(117.9,196.22) v3(119.51,206.25) v3(119.51,205.49) v3(119.53,197.08) v3(119.63,207.9) v3(119.63,207.14) v3(119.76,201.6) v3(119.76,200.95) v3(120.14,206.25) v3(120.14,205.49) v3(120.19,197.08) v3(120.27,207.9) v3(120.27,207.14) v3(120.44,202.54) v3(120.44,200.13) v3(120.45,199.19) v3(120.78,206.25) v3(120.78,205.49) v3(120.9,207.9) v3(120.9,207.14) v3(121.01,196.8) v3(121.41,206.25) v3(121.41,205.49) v3(121.54,207.9) v3(121.54,207.14) v3(121.66,196.8) v3(122.55,197.08) v3(123.24,197.05) v3(124.74,196.22) v3(124.74,195.61) v3(125.37,196.24) v3(125.37,195.63) v3(125.98,196.24) v3(125.98,195.63) v3(126.59,196.24) v3(126.59,195.63) v3(127.3,196.39) v3(127.3,195.73) v3(127.94,196.37) v3(127.87,195.72) v3(128.38,195.7) v3(128.5,196.37) v3(129.16,196.28) v3(129.16,195.75) v3(129.76,196.27) v3(129.76,195.74) v3(130.37,196.27) v3(130.37,195.74) v3(130.56,208.03) v3(130.56,207.26) v3(131.01,196.27) v3(131.01,195.74) v3(131.19,208.03) v3(131.19,207.26) v3(131.83,208.03) v3(131.83,207.26) v3(132.03,202.74) v3(132.01,201.41) v3(132.03,200.43) v3(132.08,206.25) v3(132.08,205.49) v3(132.08,204.72) v3(132.46,208.03) v3(132.46,207.26) v3(132.72,206.25) v3(132.72,205.49) v3(132.72,204.72) v3(132.71,196.88) v3(133.35,206.25) v3(133.35,205.49) v3(133.35,204.72) v3(133.55,196.88) v3(133.99,206.25) v3(133.99,205.49) v3(133.99,204.72) v3(134.46,196.62) v3(135.3,196.62) v3(184.45,131.19) v3(184.45,130.53) v3(184.45,129.82) v3(185.16,131.16) v3(185.16,130.5) v3(185.16,129.82) v4(159.54,188.87) v4(168.48,191.03) v4(168.48,190.14) v4(168.45,189.13) v4(169.21,191.87) v4(169.24,191.03) v4(169.24,190.14) v4(169.21,189.13) v4(170.74,191.82) v4(170.74,189.08) v4(170.76,190.98) v4(170.76,190.09) v4(171.5,190.96) v4(171.5,190.07) v4(171.55,189.23) v4(172.8,190.93) v4(172.8,190.04) v4(172.85,189.2) v4(174.04,190.88) v4(174.04,189.99) v4(174.09,189.15) v4(195.86,145.44) v4(195.86,144.55) v4(195.86,143.69) v4(196.82,145.44) v4(196.82,144.55) v4(196.82,143.69) v4(197.46,181.14) v4(197.47,180.04) v4(197.49,178.78) v4(197.75,145.41) v4(197.74,144.53) v4(197.74,143.66) v4(198.45,157.14) v4(198.46,156.04) v4(198.61,181.11) v4(198.61,180.01) v4(198.59,178.79) v4(198.58,154.34) v4(198.59,153.24) v4(199.34,173.1) v4(199.34,171.83) v4(199.34,170.56) v4(199.34,169.29) v4(199.34,168.02) v4(199.34,164.21) v4(199.34,162.94) v4(199.34,161.67) v4(199.34,160.4) v4(199.34,159.13) v4(199.85,157.14) v4(199.86,156.04) v4(199.85,154.22) v4(199.86,153.12) v4(199.98,179.11) v4(199.99,178.01) v4(199.98,176.19) v4(199.99,175.09) v4(200.61,173.1) v4(200.61,171.83) v4(200.61,170.56) v4(200.61,169.29) v4(200.61,162.94) v4(200.61,161.67) v4(200.61,160.4) v4(200.61,159.13) v4(206.5,137.19) v5(55.75,206.83) v5(56.74,197.97) v5(57,195.68) v5(57.1,205.28) v5(57.1,199.72) v5(59,212.04) v5(59,209.5) v5(59,206.96) v5(59.71,205.08) v5(59.72,203.02) v5(59.66,200.66) v5(62.2,195.58) v5(64.18,196.16) v5(66.9,203.99) v5(69.19,203.71) v5(70.74,200.79) v5(70.71,198.53) v5(194.92,5.08) v5(194.92,3.17) v5(196.82,5.08) v5(196.82,3.17) v5(198.73,5.08) v5(198.73,3.17) v5(200,6.98) v5(200.53,5.13) v5(200.63,3.17) v5(202.21,5.21) v5(202.54,3.17)
12V_DCIN: length 23.2
  TOP w0.254: R522.1 11.53,187.07 D35.1 ; U48.2 31.36,188.11 30.96,187.71 v2(30.91,187.71) 30.33,187.71
  TOP w0.305: V2.1 29.18,194.18 29.18,202.64 28.97,202.86 28.02,202.86
  TOP w0.508: 29.44,189.86 29.44,190.63 27.79,192.28 27.79,195.2
  BOTTOM w0.254: R521.2 31.28,187.34 v2(30.91,187.71)
  vias: v5(6.96,207.64) v5(10.13,210.82) v5(10.13,207.64) v5(10.13,191.13) v5(13.31,210.82) v5(13.31,207.64) v5(13.31,191.13) v5(16.48,210.82) v5(16.48,207.64) v5(16.48,191.13) v5(19.66,210.82) v5(19.66,207.64) v5(19.66,204.47) v5(19.66,201.29) v5(19.66,198.12) v5(22.83,210.82) v5(22.83,207.64) v5(22.83,204.47) v5(22.83,201.29) v5(22.83,198.12) v5(26.01,210.82) v5(26.01,207.64) v5(26.01,204.47) v5(26.01,201.29) v5(26.01,198.12)
12V_IN: length 50.7
  TOP w0.254: R1126.1 v3(64.92,179.45) ; U48.8 34.36,188.37 34.63,188.1 34.83,188.1 35.15,187.78 R516.1 ; U53.J1 201.96,203.1 201.96,203.73 200.6,205.08 200.6,205.63 R5312.2 ; U51.4 54.95,190.11 55.47,190.63 57.34,190.63 R533.1 v3(58.67,189.99)
  TOP w0.508: 37.06,195.33 37.06,189.61 36.42,188.98 R511.1 R516.1
  BOTTOM w0.254: C966.1 51.92,195.63 51.61,195.33 39.21,195.33 37.3,193.42 R509.2
  BOTTOM w0.305: v3(153.29,198.63) 154.94,198.63 155.57,199.26 C1597.1 156.27,200.85 156.32,200.9 U82.3
  BOTTOM w0.508: R520.2 v3(7.53,190.32)
  vias: v1(70.45,175.06) v1(70.45,173.79) v1(70.45,172.52) v1(178.13,204.01) v1(178.13,202.74) v1(178.13,201.47) v3(75.56,178.18) v3(75.56,177.42) v3(75.56,176.66) v3(76.33,178.18) v3(76.33,177.42) v3(76.33,176.66) v3(77.22,178.18) v3(77.22,177.42) v3(77.22,176.66) v3(140.39,203.96) v3(140.39,203.28) v3(141.15,203.96) v3(141.15,203.28) v3(173.81,207.9) v3(173.81,206.88) v3(173.81,205.87) v3(173.81,204.85) v3(173.81,203.84) v3(174.7,207.9) v3(174.7,206.88) v3(174.7,205.87) v3(174.7,204.85) v3(174.7,203.84) v3(175.21,208.66) v3(175.69,207.9) v3(175.69,206.88) v3(175.69,205.87) v3(175.69,204.85) v3(175.69,203.84) v3(176.43,208.56) v3(176.58,207.39) v3(176.71,204.85) v3(176.71,203.84) v3(177.39,208.51) v3(177.39,206.4) v4(194.56,208.46) v4(194.56,207.57) v4(194.56,206.71) v4(195.4,208.48) v4(195.4,207.59) v4(195.4,206.73) v4(196.34,208.43) v4(196.34,207.54) v4(196.34,206.68) v4(197.21,208.43) v4(197.21,207.54) v4(197.21,206.68) v4(207.9,202.69) v5(37.44,211.45) v5(37.82,205.61) v5(38,197.92) v5(41.25,206.37) v5(41.25,203.2) v5(42.01,211.45) v5(43.66,196.72) v5(44.3,200.79) v5(44.42,209.55) v5(44.42,206.37) v5(44.42,203.2) v5(47.47,200.79) v5(47.6,209.55) v5(47.6,206.37) v5(47.6,203.2) v5(49.25,197.87) v5(50.77,212.09) v5(50.77,209.55) v5(50.77,206.37) v5(50.77,203.2) v5(50.9,200.41) v5(53.31,212.09) v5(53.31,209.55) v5(53.31,206.37) v5(53.44,200.28)
12V_PCIE: length 2.1
  TOP w0.254: 204.16,7.97 U84.1 203.43,7.36 202.92,7.87
  vias: v3(212.15,17.53) v3(212.15,16.26) v3(212.15,14.99) v5(195.81,15.11) v5(198.09,15.37) v5(200.25,17.65) v5(200.76,13.72) v5(201.9,12.06) v5(201.9,9.52) v5(205.71,9.52) v5(208.38,9.52) v5(209.52,14.22) v5(209.52,11.81) v5(210.28,9.52) v5(211.17,13.46)
AGND_1.2V: length 3
  TOP w0.254: C2098.2 v3(41.38,20.7) ; C2094.1 v3(42.8,20.65) ; R5484.2 v3(50.06,18.03)
  BOTTOM w0.254: ST21.1 43.31,17.3 43.36,17.35
  vias: v2(45.34,16.1)
AGND_1.8V: length 0.6
  BOTTOM w0.254: ST10.1 156.01,13.26 155.96,13.21
  vias: v1(155.04,12.32)
AGND_2.5V: length 0.6
  BOTTOM w0.254: 87.76,13.13 87.86,13.03 ST11.1
  vias: v1(86.92,12.32)
AGND_3.3V: length 5.3
  TOP w0.254: R5322.1 v3(209.05,184.72) ; R553.2 v3(205.36,184)
  BOTTOM w0.254: R5320.1 v3(206.72,186.5) ; v3(209.5,185.34) 209.91,184.94 C1899.1 ; C1900.1 v3(209.35,183.54) ; v1(204.09,191.26) 204.72,191.9 ST1.1
  vias: v1(204.09,192.53) v1(205.36,192.53) v1(205.36,191.26) v1(209.17,189.99)
AGND_VCCCLK_GXE_FPGA_2.5V: length 4.9
  TOP w0.109: R6005.2 52.79,143.83 53.08,143.53 v2(53.98,143.53)
  TOP w0.254: R6006.2 54.95,135.5 v3(54.53,135.08)
  BOTTOM w0.254: ST13.1 55.55,141.3 v2(55.24,141.6) ; ST13.1 55.55,140.71 55.73,140.53 55.73,140.31 ; ST13.1 55.12,140.97
AGND_VCCFUSEWR_SDM_FPGA_2.4V: length 13.1
  TOP w0.254: C1975.1 65.24,52.9 v2(65.02,52.68) ; R6013.2 v2(65.04,48.06)
  ART03 w0.381: v2(65.02,52.68) 64.03,52.68 61.75,50.39 61.75,49.43 v2(61.16,48.84) 61.39,48.62 64.48,48.62 v2(65.04,48.06)
  BOTTOM w0.254: ST20.1 58.06,49.89
AGND_VCCH_FPGA_0.9V: length 10.2
  TOP w0.254: R1140.2 v2(172.87,172.52) ; C1961.2 181.01,165.23 181.04,165.26 C1962.1 R1134.1 R5461.1
  TOP w0.305: v2(180.19,164.49) C1961.2 ; C1962.1 180.41,165.79 v2(180.34,165.86)
  TOP w0.508: R5963.1 R5964.1 v2(177.24,168.55)
  BOTTOM w0.254: v4(157,178.71) 157.28,178.71 ST19.1
  vias: v3(175.64,175.92) v3(175.71,173.43) v3(175.97,171.27) v3(178.99,174.88) v3(178.97,172.85) v4(155.73,178.71) v4(155.73,177.44) v4(157,177.44)
AGND_VCCH_GXE_FPGA_1.1V: length 0.5
  BOTTOM w0.254: ST6.1 15.21,36.91
  vias: v1(16,36.96)
AGND_VCCIO_FPGA_1.2V: length 4.8
  BOTTOM w0.254: v2(216.28,169.47) 215.96,169.79 R5476.1 215.45,167.89 R668.1 v2(216.45,167.83) ; 205.03,166.57 205.05,166.6 ST3.1
  vias: v1(194.94,171.78) v1(197.03,171.78) v1(204.42,166.75) v1(204.42,165.48) v1(205.69,166.75) v1(205.69,165.48)
AGND_VCCIO_FPGA_1.5V: length 0.6
  BOTTOM w0.254: ST8.1 49.68,36.55 49.83,36.4
  vias: v1(50.67,36.07)
AGND_VCCIO_FPGA_1.8V: length 1.7
  BOTTOM w0.254: v1(15.77,144.98) 15.93,144.83 ST16.1 ; R6057.1 27.85,124.86 v3(27.18,124.86)
  vias: v2(23.8,124.75) v2(23.85,123.56) v2(24.99,123.58) v2(25.11,124.92)
AGND_VCCL_HPS_FPGA_0.9V: length 0.6
  BOTTOM w0.254: 32.13,33.63 32.28,33.78 ST4.1
  vias: v1(33.4,33.91)
AGND_VCCL_SDM_FPGA_0.8V: length 0.5
  BOTTOM w0.254: 132.46,13.06 132.54,13.13 ST5.1
  vias: v1(131.8,12.32)
AGND_VCCPT_FPGA_1.8V: length 4.7
  TOP w0.254: R5330.1 v3(207.66,119.21) ; R5324.2 v3(203.96,118.49)
  TOP w0.305: R6038.1 v3(208.81,118.62)
  BOTTOM w0.254: R5333.1 v3(205.32,120.99) ; 204.62,126.85 ST2.1 204.32,127.38 v1(203.96,127.03)
  vias: v1(202.69,127.03) v1(202.69,125.76) v1(203.96,125.76) v1(207.77,124.49) v4(204.72,115.72) v4(205.79,115.42) v4(206.98,115.93) v4(208.25,115.95)
GND: length 1250.2
  TOP w0.199: R6042.1 v3(76.4,216.46)
  TOP w0.203: U54.40 71.83,206.96 v3(71.55,206.68) 71.68,206.56 U54.41
  TOP w0.229: U13.B4 v2(66.04,89.31)
  TOP w0.254: v2(149.57,54.56) CON1.30 ; v2(99.32,60.32) CON1.223 ; 45.23,91.57 45.26,91.54 45.6,91.54 ; 45.23,91.57 45.23,91.13 ; 45.23,91.57 45.23,95.93 ; SW10.3 165.45,161.52 v3(166.24,162.31) ; v2(191.86,84.12) 191.85,84.11 J10.22 ; J10.14 191.91,82.11 v2(192,82.02) ; U6.A8 v2(119.62,140.92) ; R455.2 191.55,60.13 v2(192.12,59.56) ; 52.51,60.99 52.51,61.85 ; 52.51,61.85 52.51,62.36 ; 52.51,61.85 52.42,61.94 v2(51.85,61.94) U12.57 49.63,61.94 ; 55.47,64.74 U12.23 v2(57.71,64.74) 58.37,64.74 ; 55.47,64.74 v2(54.78,64.74) U12.61 52.54,64.74 52.51,64.77 ; 55.47,64.74 55.47,67.14 ; 55.47,64.74 55.47,62.34 ; 52.51,62.36 52.53,62.34 U12.58 v2(54.78,62.34) 55.47,62.34 ; 52.51,62.36 52.55,62.39 52.55,64.22 52.51,64.26 ; U23.E2 v2(34.73,166.32) ; v2(119.12,99.1) U1.BG38 v2(115.66,99.1) ; 46.79,66.74 v2(47.32,66.74) U12.13 v2(48.92,66.74) 49.63,66.74 ; 52.51,74.42 52.55,74.46 52.55,76.16 52.51,76.2 ; 52.51,74.42 52.51,73.91 ; 52.51,74.42 52.59,74.34 53.98,74.34 U12.73 v2(54.78,74.34) 55.47,74.34 ; v2(107.07,54.56) CON1.192 ; U23.A18 v2(31.53,179.92) ; U5.A2 v2(113.8,140.92) ; v2(187.71,110.69) v2(187.71,109.65) v2(187.71,108.64) ; J10.27 v2(185.83,85.61) ; v2(103.57,54.56) CON1.206 ; 52.51,73.91 52.55,73.87 52.55,72.05 52.51,72.01 ; 52.51,73.91 52.49,73.94 v2(51.85,73.94) 51.05,73.94 U12.42 49.63,73.94 ; S16.1 v3(178.69,162.4) ; v2(147.07,54.56) CON1.40 ; U23.E6 v2(34.73,169.52) ; J14.A4 203.51,18.65 v3(203.55,18.6) ; v2(119.12,106.1) U1.AN38 v2(115.66,106.1) ; v2(37.59,158.18) 37.57,158.2 C1414.2 C1413.2 ; U23.J10 37.96,173.5 v2(37.96,173.54) ; U23.V18 v2(45.94,179.92) ; v2(115.7,101.1) U1.BC38 v2(119.12,101.1) ; 45.23,89.15 45.25,89.14 45.6,89.14 ; 45.23,89.15 45.23,88.72 ; 45.23,89.15 45.23,91.13 ; U6.D8 v2(119.62,143.32) ; J11.19 v2(185.51,109.01) ; v2(183.36,80.79) 183.36,80.77 183.53,80.61 J10.7 ; 52.51,72.01 52.58,71.94 U12.70 v2(54.78,71.94) 55.47,71.94 ; 52.51,72.01 52.51,71.63 52.42,71.54 v2(51.85,71.54) U12.45 49.63,71.54 ; 52.51,66.8 52.45,66.74 v2(51.85,66.74) U12.51 49.63,66.74 ; 52.51,66.8 52.51,67.06 52.6,67.14 U12.64 v2(54.78,67.14) 55.47,67.14 ; 52.51,66.8 52.55,66.76 52.55,64.81 52.51,64.77 ; v2(185.75,106.22) 185.53,106.01 J11.7 ; U41.B4 v2(184.12,69.72) ; U7.F1 v2(80.31,144.92) ; v2(139.82,60.32) CON1.69 ; CON1.89 134.82,60.3 v2(134.84,60.3) ; 55.47,76.74 55.44,76.77 55.44,77.69 ; 55.47,76.74 v2(54.78,76.74) U12.76 52.55,76.74 52.51,76.71 ; 55.47,76.74 U12.38 v2(57.71,76.74) 58.37,76.74 ; 55.47,76.74 55.47,74.34 ; R377.2 160.22,96.29 v3(159.92,95.99) ; U10.B4 v2(66.04,82.73) ; U7.H1 v2(80.31,146.52) ; v2(34.62,18.87) 34.67,18.92 U16.B4 ; U23.A1 v2(31.53,166.32) ; U23.E13 v2(34.73,175.92) ; U15.65 26.09,11.29 25.79,11.59 U15.64 25.79,12.18 v2(25.7,12.27) ; U21.12 21.22,174.28 v2(21.51,173.99) ; U6.E3 v2(123.62,144.12) ; v3(68.68,215.13) 69.83,215.13 C2001.2 ; v2(133.57,54.56) CON1.94 ; v2(148.07,54.56) CON1.36 ; v2(95.35,60.32) 95.32,60.35 CON1.239 ; U5.D8 v2(108.19,143.32) ; v2(119.12,103.1) U1.AW38 v2(115.66,103.1) ; 46.61,76.34 v2(47.32,76.34) ; v2(113.07,54.56) CON1.168 ; U7.G8 v2(73.9,145.72) ; 52.51,64.77 52.51,64.26 ; U7.H9 v2(73.1,146.52) ; 58.37,67.14 v2(57.71,67.14) U12.26 55.47,67.14 ; v2(106.07,54.56) CON1.196 ; v2(136.82,60.3) CON1.81 ; v2(170.51,43.46) 170.05,43.92 R1062.2 ; v2(20.19,18.41) 20.37,18.24 U15.27 ; 49.63,76.34 49.58,76.39 49.58,77.69 ; 49.63,76.34 U12.39 v2(51.85,76.34) 52.37,76.34 52.51,76.2 ; 49.63,76.34 49.63,73.94 ; 49.63,76.34 v2(48.92,76.34) 46.79,76.34 ; v2(109.07,54.56) CON1.184 ; U40.B4 v2(167,51.58) ; CON1.175 111.32,60.42 v2(111.1,60.2) ; 45.23,86.33 45.23,86.34 v2(44.89,86.34) J12.19 v2(43.09,86.34) 42.37,86.34 ; 45.23,86.33 45.23,85.85 ; 45.23,86.33 45.23,86.74 ; R973.2 v3(163.8,140.97) ; v2(135.82,60.32) CON1.85 ; J10.4 189.89,79.6 v2(189.38,79.1) ; C2000.2 68.87,213.26 v3(68.71,213.1) ; U21.10 19.39,175.28 v2(19.18,175.48) ; v2(42.6,23.75) 42.85,24 R559.1 ; v2(126.03,153.72) 125.8,153.49 U6.T1 ; U23.K13 v2(39.54,175.92) ; U84.4 208.24,6.36 ; v2(146.07,54.56) CON1.44 ; v2(192.45,109.68) 192.29,109.51 J11.22 ; v2(144.32,60.32) CON1.51 ; v2(108.82,60.2) CON1.185 ; v3(113.8,198.62) 113.8,197.8 U89.31 ; v2(119.12,102.1) U1.BA38 115.71,102.1 v2(115.7,102.08) ; U6.K1 v2(126.03,148.92) ; v2(189.38,104.5) 189.89,105 J11.4 ; J10.36 191.8,87.61 v2(191.97,87.78) ; S17.1 v3(187.83,162.4) ; U4.H9 v2(95.96,146.52) ; v2(26.59,173.99) 26.55,173.99 26.3,173.73 U21.26 ; v2(93.07,54.56) CON1.248 ; v3(17.63,171.58) 17.12,172.08 C668.2 ; v2(100.82,60.32) CON1.217 ; v2(141.82,60.32) CON1.61 ; v2(96.57,54.56) CON1.234 ; J10.40 v2(192,88.61) ; v2(47.32,73.94) 46.79,73.94 48.12,73.94 U12.4 v2(48.92,73.94) 49.63,73.94 ; v3(82.37,210.82) 82.06,211.13 C1721.2 ; U5.E3 v2(112.19,144.12) ; J11.14 191.85,107.51 v2(191.92,107.44) ; v2(137.57,54.56) CON1.78 ; 45.23,96.34 45.24,96.34 v2(45.6,96.34) J12.32 47.38,96.34 v2(47.38,96.34) 48.12,96.34 ; 45.23,96.34 45.23,98.32 ; 45.23,96.34 45.23,95.93 ; U23.J17 v2(37.93,179.12) ; R374.1 159.79,84.58 v3(159.41,84.96) ; U35.8 163.35,138.5 v3(163.17,138.68) ; J11.40 v2(191.97,114.01) ; U6.B2 v2(125.23,141.72) ; U23.E3 v2(34.73,167.12) ; 55.47,62.34 55.44,62.31 55.44,60.99 ; 55.47,62.34 U12.20 v2(57.71,62.34) 58.44,62.34 ; C544.2 v3(63.54,72.66) ; R5979.1 v3(73.91,216.48) ; CON1.107 130.32,60.3 v2(130.37,60.25) ; v2(119.12,97.1) U1.BL38 v2(115.66,97.1) ; v2(142.07,54.56) CON1.60 ; 49.63,64.34 v2(48.92,64.34) U12.16 v2(47.32,64.34) 46.79,64.34 ; 49.63,64.34 U12.54 51.05,64.34 v2(51.85,64.34) 52.43,64.34 52.51,64.26 ; 49.63,64.34 49.63,66.74 ; 49.63,64.34 49.63,61.94 ; U4.E3 v2(100.76,144.12) ; C1592.2 v3(168.5,129.79) ; U5.K9 v2(107.39,148.92) ; U7.K9 v2(73.1,148.92) ; v2(186.03,104.5) 185.52,105 J11.3 ; SW5.7 v3(158.34,163.67) ; v3(152.8,77.42) 153.33,77.94 FB1.2 152.85,78.23 152.83,78.26 v3(152.78,78.26) ; U23.V1 45.75,165.71 46.33,165.71 ; U23.D3 v2(33.94,167.12) ; U3.E8 v2(85.33,144.12) ; v3(65.3,64.69) 66.12,64.69 66.55,65.13 C555.2 ; v2(115.66,104.1) U1.AU38 v2(119.12,104.1) ; v3(56.26,54.69) 55.69,55.26 C2086.1 ; v2(111.1,54.61) 111.07,54.58 CON1.176 ; U88.31 100.01,197.9 v3(100.01,198.72) ; v2(187.71,113.84) v2(187.71,112.95) ; v3(75.14,216.51) R5978.1 ; R5980.1 v3(72.67,216.48) ; J10.3 185.52,79.6 v2(186.03,79.1) ; U3.A8 v2(85.33,140.92) ; U5.G8 v2(108.19,145.72) ; v2(98.57,54.56) CON1.226 ; 52.51,76.2 52.51,76.71 ; 52.51,76.71 52.51,77.69 ; v2(150.57,54.56) CON1.26 ; U23.B10 v2(32.33,173.52) ; J10.15 183.47,82.61 v2(183.45,82.59) ; v2(113.15,60.22) 113.32,60.39 CON1.167 ; 49.63,71.54 v2(48.92,71.54) 46.79,71.54 v2(47.32,71.54) ; 49.63,71.54 49.63,73.94 ; v2(112.07,54.56) CON1.172 ; v2(80.47,148.59) 80.4,148.52 U7.K1 ; U23.E10 v2(34.73,173.52) ; 42.37,91.14 v2(43.09,91.14) 43.09,91.14 J12.13 v2(44.89,91.14) 45.23,91.14 45.23,91.13 ; v2(138.82,60.32) CON1.73 ; U51.1 55.08,188.61 v3(55.22,188.47) ; v2(103.82,60.32) CON1.205 ; 48.12,86.74 v2(47.38,86.74) 47.38,86.74 J12.20 v2(45.6,86.74) 45.24,86.74 45.23,86.74 ; v2(22.52,179.07) 22.3,179.29 U21.53 ; U3.H1 v2(91.74,146.52) ; 67.61,208.76 v3(67.72,208.76) C1718.1 ; U19.B2 v3(159.33,208.53) ; J10.35 v2(183.44,87.61) ; U6.N1 v2(126.03,151.32) ; v2(151.57,54.56) CON1.22 ; C828.2 v3(158.48,133.33) ; R300.1 15.81,174.4 15.47,174.74 15.47,174.74 v3(15.44,174.77) ; U5.A8 v2(108.19,140.92) ; U4.H1 v2(103.17,146.52) ; v2(56.64,147.08) C3.1 55.06,147.08 54.91,147.08 54.89,147.1 C2.1 ; v2(79.51,143.32) U7.D2 ; S18.1 v3(192.41,162.4) ; U4.C9 v2(95.96,142.52) ; v2(115.66,98.1) U1.BJ38 v2(119.12,98.1) ; 45.23,86.74 45.23,88.72 ; 45.23,88.72 45.22,88.74 v2(44.89,88.74) J12.16 v2(43.09,88.74) 42.37,88.74 ; U42.B4 v2(167,55.98) ; v2(143.07,54.56) CON1.56 ; v2(20.28,181.33) 20.8,180.8 U21.56 ; 49.63,61.94 49.58,61.9 49.58,60.99 ; 49.63,61.94 v2(48.92,61.94) U12.19 v2(47.32,61.94) 46.79,61.94 ; U5.D2 v2(113.8,143.32) ; 45.6,91.54 J12.26 47.38,91.54 v2(47.38,91.54) 48.12,91.54 ; 45.6,91.54 v2(45.6,91.54) ; 58.44,71.94 v2(57.71,71.94) U12.32 55.47,71.94 ; v2(131.57,54.56) CON1.102 ; 48.12,98.74 v2(47.38,98.74) 47.38,98.74 J12.35 v2(45.6,98.74) 45.24,98.74 45.23,98.73 ; SW10.4 164.18,162.69 v3(163.55,163.32) ; v3(141.48,141.33) U69.8 141.48,142.85 v2(141.45,142.87) ; U23.F17 v2(35.54,179.12) ; v2(166.6,125.22) 166.52,125.22 166.26,125.48 U81.4 ; v2(153.57,54.56) CON1.14 ; CON1.201 104.82,60.52 v2(104.62,60.32) ; 55.47,74.34 55.47,71.94 ; 55.47,74.34 56.91,74.34 U12.35 v2(57.71,74.34) 58.37,74.34 ; v2(145.07,54.56) CON1.48 ; U2.B4 v3(80.36,60.71) ; U4.F1 v2(103.17,144.92) ; R434.1 v3(170.15,140.97) ; R5981.1 v3(71.46,216.46) ; v2(107.82,60.2) CON1.189 ; v2(112.38,60.04) 112.32,60.11 CON1.171 ; U6.H1 v2(126.03,146.52) ; CON1.35 148.32,60.33 v2(148.29,60.3) ; U90.31 126.91,197.32 v3(126.91,198.14) ; R848.2 v3(167.49,129.79) ; U3.G8 v2(85.33,145.72) ; 45.23,98.73 45.23,98.32 ; 45.23,98.73 45.23,100.71 ; 45.23,98.32 45.22,98.34 v2(44.89,98.34) J12.4 v2(43.09,98.34) 42.3,98.34 ; R847.2 v3(168.37,140.84) ; v2(95.57,54.56) CON1.238 ; CON1.1 156.82,62.43 v2(157.04,62.65) ; R6036.1 v3(71.4,213.92) ; v2(101.57,54.56) CON1.214 ; v2(130.57,54.56) CON1.106 ; v2(78.21,51.78) 78.62,51.38 U67.4 79.44,51.38 79.82,51.75 v3(79.95,51.75) ; J11.36 v2(191.97,113.01) ; U23.F8 v2(35.54,171.12) ; U3.A2 v2(90.94,140.92) ; v2(155.57,54.56) CON1.6 ; v2(102.82,60.32) CON1.209 ; v2(79.51,152.92) 79.74,153.15 U7.T1 80.08,153.49 v2(80.31,153.72) ; U5.E8 v2(108.19,144.12) ; v2(135.57,54.56) CON1.86 ; U23.L4 v2(40.34,167.92) ; U23.K9 v2(39.54,171.92) ; 45.23,95.93 45.23,95.94 v2(44.89,95.94) J12.7 v2(43.09,95.94) 42.37,95.94 ; v3(85.91,199.63) 85.91,198.4 U87.31 ; v2(36.26,144.09) 36.62,144.46 C1587.2 ; 34.39,185.42 34.39,187.21 34.16,187.44 34.16,187.93 33.86,188.23 U48.7 ; U15.53 22.49,10.54 v2(22.49,10.54) ; v2(133.82,60.32) CON1.93 ; 48.12,101.14 v2(47.38,101.14) 47.38,101.14 J12.38 v2(45.6,101.14) 45.24,101.14 45.23,101.14 ; U4.A8 v2(96.76,140.92) ; U7.N1 80.09,151.1 v2(80.54,151.1) ; J11.63 v2(187.71,114.99) v2(187.71,116.1) v2(187.71,117.96) ; v2(109.82,60.07) CON1.181 ; v2(152.32,60.32) CON1.19 ; v3(68.81,211.07) C2002.2 ; 48.12,89.14 v2(47.38,89.14) 47.38,89.14 J12.23 45.6,89.14 ; v2(144.07,54.56) CON1.52 ; U69.4 140.98,145.36 v3(140.56,145.77) ; v2(134.57,54.56) CON1.90 ; U23.U4 v2(45.14,167.92) ; U21.41 26.8,179.28 v2(26.59,179.07) ; U7.A2 v2(79.51,140.92) ; CON1.180 110.07,54.6 v2(110.08,54.61) ; v3(169.54,162.22) S13.1 ; 45.23,100.71 45.21,100.74 v2(44.89,100.74) J12.1 v2(43.09,100.74) 42.44,100.74 42.44,100.74 ; 45.23,100.71 45.23,101.14 ; v2(80.31,144.12) U7.E1 ; R1119.1 v3(65.02,180.82) ; C824.2 v3(167.1,140.84) 167.1,141.34 166.69,141.76 Y3.2 ; U17.B4 154.91,147.57 v3(154.15,148.34) ; v2(90.94,152.92) 91.17,153.15 U3.T1 91.51,153.49 v2(91.74,153.72) ; U23.G2 v2(36.33,166.32) ; R142.1 v3(129.58,143.85) ; U3.C9 v2(84.53,142.52) ; U6.H9 v2(118.82,146.52) ; MTH5.1 47.65,215.26 v5(52.68,215.26) ; v2(59.31,146.71) 58.61,146.71 R734.1 ; U4.K1 v2(103.17,148.92) ; v2(183.45,83.5) 183.56,83.61 J10.19 ; v2(136.57,54.56) CON1.82 ; U23.N2 v2(41.93,166.32) ; U6.K9 v2(118.82,148.92) ; U6.A2 v2(125.23,140.92) ; SW1.5 v3(153.03,163.67) ; U67.8 v3(75.46,50.88) ; v2(100.57,54.56) CON1.218 ; v2(24.77,10.03) 24.89,10.16 U15.61 ; U45.4 172.69,125.71 v2(172.69,125.2) ; v2(119.12,100.1) U1.BE38 v2(115.66,100.1) ; U31.21 v3(171.19,114.68) ; C1780.2 76.95,47.56 v3(77.33,47.94) ; S15.1 v3(183.26,162.4) ; Y3.4 v3(165.24,143.85) ; U3.D2 v2(90.94,143.32) ; v2(108.07,54.56) CON1.188 ; CON1.77 137.82,60.35 v2(137.87,60.3) ; v3(83.44,209.25) 82.31,209.25 82.16,209.4 C1720.1 ; U7.E8 v2(73.9,144.12) ; v2(102.57,54.56) CON1.210 ; v2(101.82,60.32) CON1.213 ; v2(140.82,60.32) CON1.65 ; J11.35 v2(185.8,113.01) ; v2(99.57,54.56) CON1.222 ; SW5.8 v3(157.07,163.67) ; v2(45.6,89.14) 45.6,89.14 ; v3(171.64,135.6) 171.3,135.25 C1590.2 R975.2 ; U4.D8 v2(96.76,143.32) ; v2(147.32,60.32) CON1.39 ; U23.K6 v2(39.54,169.52) ; C1411.1 v3(162.72,127.89) ; v2(131.32,60.2) CON1.103 ; U4.G8 v2(96.76,145.72) ; v2(19.13,172.94) 19.46,173.28 U21.14 ; CON1.193 106.82,60.36 106.78,60.32 v2(106.78,60.2) ; U23.N17 v2(41.93,179.12) ; U4.N1 v2(103.17,151.32) ; v2(150.32,60.32) CON1.27 ; 45.23,101.14 45.23,101.8 ; U4.K9 v2(95.96,148.92) ; SW1.6 v3(151.76,163.67) ; v2(93.32,60.32) CON1.247 ; C2110.1 v3(71.39,178.97) ; v2(154.82,60.32) CON1.9 ; v2(140.07,54.56) CON1.68 ; v2(105.82,60.2) CON1.197 ; v2(132.57,54.56) CON1.98 ; U23.U14 v2(45.14,176.72) ; v3(62.41,68.55) 62.94,68.55 63.16,68.77 C554.2 ; U79.B4 v2(167,46.2) ; v2(149.45,60.32) 149.32,60.46 CON1.31 ; C1591.2 v3(164.44,129.79) ; v2(141.07,54.56) CON1.64 ; v2(83.85,148.87) 84.59,148.87 U3.K9 ; v2(170.21,44.71) 169.6,44.71 R1063.2 ; U5.B2 v2(113.8,141.72) ; U4.B2 v2(102.37,141.72) ; C1843.2 v3(138.24,139.76) ; v2(145.32,60.32) CON1.47 ; U7.D8 v2(73.9,143.32) ; C829.2 v3(165.2,140.97) ; R6019.1 v3(47.57,20.55) ; U3.N1 v2(91.74,151.32) ; v2(185.75,111.01) J11.27 ; C2062.1 v3(51.19,11.49) ; v2(155.82,60.32) CON1.5 ; J10.23 v2(183.44,84.61) ; J10.49 v2(185.78,91.11) ; U35.32 167.97,137.26 168.37,137.67 v3(168.37,138.18) ; J11.49 185.68,116.51 v2(185.8,116.64) ; R851.2 182.31,125.22 v4(181.28,125.22) 180.87,125.63 U43.4 ; U23.N12 v2(41.93,175.12) ; U7.A8 v2(73.9,140.92) ; U6.G8 v2(119.62,145.72) ; U23.B6 v2(32.33,169.52) ; J14.B4 v3(207.97,18.65) ; v2(152.57,54.56) CON1.18 ; U3.H9 v2(84.53,146.52) ; v2(113.8,152.92) 114.03,153.15 U5.T1 114.37,153.49 v2(114.6,153.72) ; U6.C9 v2(118.82,142.52) ; U14.B4 v2(55.5,89.1) ; v2(92.07,54.56) CON1.252 ; v2(142.82,60.32) CON1.57 ; J11.23 v2(185.8,110.01) ; U7.C9 v2(73.1,142.52) ; 16.51,177.16 16.77,176.91 18.69,176.91 18.95,177.16 19.61,177.16 19.72,177.28 U21.6 ; U5.E1 v2(114.6,144.12) ; v2(153.32,60.32) CON1.15 ; U23.M14 v2(41.14,176.72) ; U3.K1 v2(91.74,148.92) ; v2(94.21,60.32) 94.32,60.44 CON1.243 ; C2113.1 v3(75.35,201.81) ; U5.F1 v2(114.6,144.92) ; U18.B2 v3(165.91,208.41) ; U23.R7 v2(43.53,170.32) ; R538.1 v3(49.12,187.58) ; U3.F1 v2(91.74,144.92) ; U4.A2 v2(102.37,140.92) ; U5.C9 v2(107.39,142.52) ; SW5.5 v3(160.88,163.67) ; U5.K1 v2(114.6,148.92) ; v2(119.12,105.1) U1.AR38 v2(115.66,105.1) ; U3.E3 v2(89.33,144.12) ; SW1.7 v3(150.5,163.67) ; U23.H14 v2(37.13,176.72) ; v2(132.32,60.2) CON1.99 ; R140.1 v3(129.58,155.24) ; U4.E8 v2(96.76,144.12) ; C1410.1 v3(162.72,124.9) ; v2(97.32,60.32) CON1.231 ; U4.D2 v2(102.37,143.32) ; U6.D2 v2(125.23,143.32) ; U11.B4 v3(55.5,82.7) ; U21.28 27.3,172.06 v6(27.56,171.8) ; J11.39 v2(185.8,114.01) ; U3.D8 v2(85.33,143.32) ; v2(92.32,60.32) CON1.251 ; U6.F1 v2(126.03,144.92) ; v2(96.32,60.32) CON1.235 ; J10.39 v2(183.44,88.61) ; v2(185.8,108.01) J11.15 ; v2(139.07,54.56) CON1.72 ; U7.E3 v2(77.9,144.12) ; U4.E1 v2(103.17,144.12) ; R337.2 v3(23.01,158.62) ; U5.H9 v2(107.39,146.52) ; v2(156.57,54.56) CON1.2 ; U6.E8 v2(119.62,144.12) ; v2(98.32,60.32) CON1.227 ; U23.U10 v2(45.14,173.52) ; SW5.6 v3(159.61,163.67) ; v2(104.57,54.56) CON1.202 ; U5.N1 v2(114.6,151.32) ; U23.N10 v2(41.93,173.52) ; U23.N5 v2(41.93,168.72) ; v2(97.57,54.56) CON1.230 ; SW1.8 v3(149.22,163.67) ; R143.2 130.08,149.61 v3(130.43,149.61) ; v2(146.32,60.32) CON1.43 ; U23.B15 v2(32.33,177.52) ; U7.B2 v2(79.51,141.72) ; v2(102.37,152.92) 102.6,153.15 U4.T1 102.94,153.49 v2(103.17,153.72) ; U3.B2 v2(90.94,141.72) ; S14.1 v3(175.94,160.58) ; v2(151.32,60.32) CON1.23 ; R742.1 v3(64.2,51.14) ; U3.E1 v2(91.74,144.12) ; C1637.1 v3(77.67,216.48) ; v2(94.07,54.56) CON1.244 ; U23.G4 v2(36.33,167.92) ; v2(154.57,54.56) CON1.10 ; U6.E1 v2(126.03,144.12) ; U5.H1 v2(114.6,146.52) ; R5876.2 v3(84.68,212.31)
  TOP w0.305: Y1.4 v2(16.11,183) ; v2(16.11,183) 15.09,183 v2(15.08,182.98) v2(15.08,182.1) v2(15.08,181.25) v2(15.08,180.47) 15.08,180.03 C665.2 15.5,179.61 15.5,178.18 16.51,177.16 ; v2(16.11,183) v2(17.17,183) 18.49,183 v2(18.5,183.01) v2(18.5,181.79) v2(18.5,180.95) ; U1.AN26 107.31,105.79 v2(107.92,105.79) ; Y1.2 v2(18.5,180.95) ; v2(18.5,180.95) 18.5,179.9 C666.2 v2(18.25,178.66) ; v3(164.91,203.5) 164.52,203.5 164.21,203.19 S7.1 ; U1.BG26 v2(108.05,99.1) ; v3(46.62,165.92) 46.41,165.71 46.33,165.71 ; U1.AU26 v2(107.9,104.1) ; U1.BL26 107.43,97.54 v2(108.05,97.54) ; R547.1 v3(179.44,194.9) ; v2(108.05,105.03) 107.98,105.1 U1.AR26 ; U1.AW26 107.77,103.1 v2(107.9,102.97) ; U1.BE26 v2(108.05,100.1) ; U1.BJ26 107.85,98.1 v2(108.05,98.3)
  TOP w0.381: v2(207.83,92.37) 208.11,92.65 J14.B76 210.47,92.65 v2(210.75,92.37) v2(213.04,92.37) ; v2(213.04,55.37) v2(210.75,55.37) 210.47,55.65 J14.B39 208.11,55.65 v2(207.83,55.37) ; v2(213.04,89.93) v2(210.75,89.93) 210.47,89.65 J14.B73 208.11,89.65 v2(207.83,89.93) ; v2(200.73,65.37) 201.01,65.65 J14.A49 203.37,65.65 v2(203.65,65.37) ; v2(213.04,68.37) v2(210.75,68.37) 210.47,68.65 J14.B52 208.11,68.65 v2(207.83,68.37) ; v2(200.73,58.93) 201.01,58.65 J14.A42 203.37,58.65 v2(203.65,58.93) ; v2(200.73,47.37) 201.01,47.65 J14.A31 203.37,47.65 v2(203.65,47.37) ; v2(203.65,43.37) 203.37,43.65 J14.A27 201.01,43.65 v2(200.73,43.37) ; v2(207.83,69.93) 208.11,69.65 J14.B53 210.47,69.65 v2(210.75,69.93) v2(213.04,69.93) ; 203.37,31.65 J14.A15 201.01,31.65 ; 203.37,31.65 v2(203.65,31.37) ; 203.37,31.65 v2(203.65,31.93) ; v2(200.73,70.37) 201.01,70.65 J14.A54 203.37,70.65 v2(203.65,70.37) ; v2(213.04,51.37) v2(210.75,51.37) 210.47,51.65 J14.B35 208.11,51.65 v2(207.83,51.37) ; v2(207.83,38.93) 208.11,38.65 J14.B22 210.47,38.65 v2(210.75,38.93) v2(213.04,38.93) ; v2(207.83,56.93) 208.11,56.65 J14.B40 210.47,56.65 v2(210.75,56.93) v2(213.04,56.93) ; v2(203.65,83.93) 203.37,83.65 J14.A67 201.01,83.65 v2(200.73,83.93) ; v2(213.04,59.37) v2(210.75,59.37) 210.47,59.65 J14.B43 208.11,59.65 v2(207.83,59.37) ; R767.1 140.4,139.43 v3(140.94,138.89) ; v2(203.65,53.37) 203.37,53.65 J14.A37 201.01,53.65 v2(200.73,53.37) ; v2(200.73,98.37) 201.01,98.65 J14.A82 203.37,98.65 v2(203.65,98.37) ; v2(207.83,81.93) 208.11,81.65 J14.B65 210.47,81.65 v2(210.75,81.93) v2(213.04,81.93) ; v2(207.83,42.93) 208.11,42.65 J14.B26 210.47,42.65 v2(210.75,42.93) v2(213.04,42.93) ; v2(200.73,34.37) 201.01,34.65 J14.A18 203.37,34.65 v2(203.65,34.37) ; v2(207.83,29.93) 208.11,29.65 J14.B13 210.47,29.65 v2(210.75,29.93) v2(213.04,29.93) ; v2(203.65,39.37) 203.37,39.65 J14.A23 201.01,39.65 v2(200.73,39.37) ; v2(200.73,86.37) 201.01,86.65 J14.A70 203.37,86.65 v2(203.65,86.37) ; v2(203.65,94.37) 203.37,94.65 J14.A78 201.01,94.65 v2(200.73,94.37) ; v2(213.04,32.37) v2(210.75,32.37) 210.47,32.65 J14.B16 208.11,32.65 v2(207.83,32.37) ; v2(207.83,76.37) 208.11,76.65 J14.B60 210.47,76.65 v2(210.75,76.37) v2(213.04,76.37) ; C685.1 v3(23.63,168.21) ; v2(213.04,72.37) v2(210.75,72.37) 210.47,72.65 J14.B56 208.11,72.65 v2(207.83,72.37) ; v2(200.73,75.93) 201.01,75.65 J14.A59 203.37,75.65 v2(203.65,75.93) ; v2(200.73,54.93) 201.01,54.65 J14.A38 203.37,54.65 v2(203.65,54.93) ; v2(203.65,57.37) 203.37,57.65 J14.A41 201.01,57.65 v2(200.73,57.37) ; v2(203.65,91.93) 203.37,91.65 J14.A75 201.01,91.65 v2(200.73,91.93) ; v2(207.83,88.37) 208.11,88.65 J14.B72 210.47,88.65 v2(210.75,88.37) v2(213.04,88.37) ; v2(213.04,41.37) v2(210.75,41.37) 210.47,41.65 J14.B25 208.11,41.65 v2(207.83,41.37) ; v2(200.73,40.93) 201.01,40.65 J14.A24 203.37,40.65 v2(203.65,40.93) ; v2(207.83,96.37) 208.11,96.65 J14.B80 210.47,96.65 v2(210.75,96.37) v2(213.04,96.37) ; v2(203.65,67.93) 203.37,67.65 J14.A51 201.01,67.65 v2(200.73,67.93) ; v2(213.04,34.93) v2(210.75,34.93) 210.47,34.65 J14.B18 208.11,34.65 v2(207.83,34.93) ; v2(213.04,73.93) v2(210.75,73.93) 210.47,73.65 J14.B57 208.11,73.65 v2(207.83,73.93) ; v2(200.73,31.37) 201.01,31.65 ; 201.01,31.65 v2(200.73,31.93) ; v2(200.73,74.37) 201.01,74.65 J14.A58 203.37,74.65 v2(203.65,74.37) ; v2(207.83,93.93) 208.11,93.65 J14.B77 210.47,93.65 v2(210.75,93.93) v2(213.04,93.93) ; v2(213.04,60.93) v2(210.75,60.93) 210.47,60.65 J14.B44 208.11,60.65 v2(207.83,60.93) ; v2(213.04,80.37) v2(210.75,80.37) 210.47,80.65 J14.B64 208.11,80.65 v2(207.83,80.37) ; v2(207.83,37.37) 208.11,37.65 J14.B21 210.47,37.65 v2(210.75,37.37) v2(213.04,37.37) ; v2(203.65,87.93) 203.37,87.65 J14.A71 201.01,87.65 v2(200.73,87.93) ; v2(200.73,79.93) 201.01,79.65 J14.A63 203.37,79.65 v2(203.65,79.93) ; v2(213.04,84.37) v2(210.75,84.37) 210.47,84.65 J14.B68 208.11,84.65 v2(207.83,84.37) ; v2(200.73,71.93) 201.01,71.65 J14.A55 203.37,71.65 v2(203.65,71.93) ; v2(200.73,95.93) 201.01,95.65 J14.A79 203.37,95.65 v2(203.65,95.93) ; v2(213.04,77.93) v2(210.75,77.93) 210.47,77.65 J14.B61 208.11,77.65 v2(207.83,77.93) ; v2(203.65,36.93) 203.37,36.65 J14.A20 201.01,36.65 v2(200.73,36.93) ; v2(200.73,78.37) 201.01,78.65 J14.A62 203.37,78.65 v2(203.65,78.37) ; v2(203.65,90.37) 203.37,90.65 J14.A74 201.01,90.65 v2(200.73,90.37) ; v2(203.65,61.37) 203.37,61.65 J14.A45 201.01,61.65 v2(200.73,61.37) ; v2(213.04,52.93) v2(210.75,52.93) 210.47,52.65 J14.B36 208.11,52.65 v2(207.83,52.93) ; v2(207.83,65.93) 208.11,65.65 J14.B49 210.47,65.65 v2(210.75,65.93) v2(213.04,65.93) ; v2(203.65,44.93) 203.37,44.65 J14.A28 201.01,44.65 v2(200.73,44.93) ; v2(200.73,50.93) 201.01,50.65 J14.A34 203.37,50.65 v2(203.65,50.93) ; v2(213.04,48.93) v2(210.75,48.93) 210.47,48.65 J14.B32 208.11,48.65 v2(207.83,48.93) ; v2(200.73,62.93) 201.01,62.65 J14.A46 203.37,62.65 v2(203.65,62.93) ; v2(207.83,63.37) 208.11,63.65 J14.B47 210.47,63.65 v2(210.75,63.37) v2(213.04,63.37) ; v2(213.04,45.37) v2(210.75,45.37) 210.47,45.65 J14.B29 208.11,45.65 v2(207.83,45.37) ; J14.B7 v3(207.93,21.65) ; v2(200.73,28.93) 201.01,28.65 J14.A12 203.37,28.65 v2(203.65,28.93) ; v2(200.73,82.37) 201.01,82.65 J14.A66 203.37,82.65 v2(203.65,82.37) ; v2(213.04,85.93) v2(210.75,85.93) 210.47,85.65 J14.B69 208.11,85.65 v2(207.83,85.93)
  TOP w0.508: C825.2 v3(159.04,143.45) ; C841.2 v4(157.67,102.6) ; R931.2 v4(167.39,105.41) ; R852.2 v4(174.12,124.59) ; R5286.2 153.33,79.22 FB1.2 ; v2(37.59,158.18) C8.2 ; C683.2 v3(28.96,159.19) C682.2 ; U80.2 165.82,65.04 v3(165.71,65.15) ; C826.2 v3(162.5,142.21) ; C945.1 v4(170.31,124.59) ; D1.5 157.72,75.63 v3(157.14,76.2) 157.5,76.56 158.95,76.56 159.42,77.02 C1600.2 159.42,79.46 v3(158.92,79.96) ; C942.1 v4(178.56,124.59) ; R920.2 180.63,39.33 v3(180.13,38.84) ; J14.A1 203.48,15.65 v3(203.93,16.1) ; C946.1 v4(170.94,129.41) ; X1.2 v3(24.33,6.29) ; C943.1 v4(179.2,129.79) ; U39.2 v3(184.36,41.27) ; v3(156.18,95.4) 155.4,95.4 X2.2 153.43,95.3 153.19,95.3 v3(152.98,95.5) ; D1.4 v3(157.72,67.06)
  ART03 w0.254: v2(66.36,95.52) 66.36,94.51 67.29,93.58 70.37,93.58 71.01,92.95 77.15,92.95 78.08,92.02 84.79,92.02 84.88,92.12 85.51,92.12 86.01,91.62 86.41,91.62 86.85,92.05 86.88,92.08 87.28,92.08 87.31,92.05 87.75,91.62 88.14,91.62 88.35,91.82 88.35,91.82 88.61,92.08 89.01,92.08 89.48,91.62 89.88,91.62 90.35,92.09 90.74,92.09 91.21,91.62 91.61,91.62 92.07,92.08 92.08,92.08 92.47,92.08 92.9,91.66 92.94,91.62 93.34,91.62 93.76,92.04 93.76,92.04 93.81,92.08 94.17,92.08 94.71,92.62 95.07,92.62 95.54,93.08 95.91,93.08 96.41,93.58 97.5,93.58 99,95.08 99.36,95.08 99.87,95.59 100.24,95.59 100.77,96.12 101.13,96.12 101.63,96.61 101.97,96.61 102.5,97.14 102.84,97.14 102.85,97.14 102.89,97.14 103.37,97.62 103.73,97.62 104.22,98.11 104.58,98.11 104.93,98.45 104.93,98.76 v2(105.26,99.1)
  ART03 w2.032: 11.35,8 11.35,5.44 13.64,3.15 v2(20.57,3.15) v2(22.73,3.15)
  BOTTOM w0.254: C627.2 33.3,21.51 v3(33.75,21.97) ; C1405.1 v3(169.16,193.42) ; C574.2 v3(65.56,93.61) ; v2(19.79,51.82) U33.35 ; 16.48,145.97 16.71,145.75 ST16.2 ; v2(32.99,181.93) 32.51,181.93 32.51,181.93 R1060.2 ; v2(32.33,177.52) 32.36,177.5 C738.2 ; R5468.1 214.92,158.18 v3(214.91,158.17) ; v2(73.1,146.52) 71.94,145.35 R135.2 ; C1330.2 166.61,45.81 v2(167,46.2) ; U32.1 v2(41.06,54.92) ; U36.6 153.2,32.57 v3(153.01,32.77) ; v3(63.69,90.68) C575.2 ; R5467.1 v3(194.06,180.59) ; U37.6 v3(48.43,110.6) ; 15.21,38.66 ST6.2 ; C938.2 166.41,55.98 v2(167,55.98) ; v2(26.59,175) 26.84,174.75 C670.2 ; v2(20.8,48.89) 21.13,49.22 U33.31 ; C1503.2 117.92,149.22 118.22,148.92 v2(118.82,148.92) ; U33.37 19.8,52.82 v2(19.71,52.91) ; v3(82.17,200.03) 82.13,200.06 C2132.2 ; U33.33 19.98,50.82 19.94,50.77 v2(19.79,50.77) ; C776.2 182.12,89.03 183.02,89.03 v2(183.44,88.61) ; v2(22.91,54.96) 22.63,54.68 U33.4 ; C374.2 77.8,59.94 77.42,59.56 v3(77.42,59.33) ; R565.2 202.07,186.39 v3(202.29,186.39) ; v2(40.66,48.74) 41.06,49.14 U32.31 ; ST18.2 178.82,199.29 178.64,199.11 ; C2134.2 96,200.33 95.78,200.33 v3(95.76,200.3) ; C1719.2 v3(84.33,207.92) ; C1404.1 v3(164.85,193.42) ; v3(165.74,201.42) 165.35,201.42 164.83,200.9 U82.12 ; 204.7,193.24 204.72,193.22 ST1.2 ; R127.1 77.15,142.1 76.5,142.75 v2(76.39,142.75) ; J16.6 v3(144.37,157.86) ; U33.32 20.24,50.32 20.09,50.16 v3(19.43,50.16) ; v2(76.53,153.92) 76.53,153.63 R1010.1 ; v2(89.53,53.47) 89.53,53.32 R114.1 R113.1 v2(91.07,54.65) ; v3(106.97,10.2) 107.3,10.53 R5434.2 ; v2(34.73,173.52) 35.56,174.35 C671.2 ; C156.2 99.47,93.44 C140.1 99.45,92.41 R97.1 ; C934.2 181.64,70.55 v2(181.58,70.61) ; v2(58.62,48.84) 58.52,48.95 ST20.2 ; R5425.2 v3(53.51,28.44) ; R951.1 66.85,96.01 v2(66.36,95.52) ; v3(118.52,38.1) v3(117.02,36.6) ; C677.2 21.74,173.75 v2(21.51,173.99) ; C2131.2 89.09,200.72 v3(89.53,201.17) ; R130.1 77.2,144.84 77.9,144.14 v2(77.9,144.12) ; 157.68,180.37 157.63,180.31 ST19.2 ; 148.21,12.95 147.97,13.2 R5443.2 ; v2(80.47,148.59) 80.68,148.59 C1530.2 ; R5392.2 v3(35.57,32.4) ; U34.6 v2(87.73,37.97) ; v3(55.5,82.7) 56.24,83.44 C553.2 ; R641.2 200.67,120.88 v3(200.89,120.88) ; 164.2,86.36 164.2,87.11 v2(164.27,87.18) ; v3(162.31,201.17) 162.31,201.93 162.57,202.2 U82.10 ; C1921.2 v3(196.61,138.82) ; v2(87.96,153.92) 87.96,153.63 R1006.1 ; 88.77,13.03 89.33,13.03 89.41,12.95 ; U33.1 21.13,54.41 v2(20.75,54.79) ; U24.12 v2(36.26,144.09) ; v2(167,51.58) 166.54,51.12 C941.2 ; R1059.2 29.82,181.04 v2(29.44,180.66) 29.34,180.76 29.34,181.61 29.02,181.93 R1058.2 ; C2063.2 v3(175.97,162.25) ; C718.2 36.55,172.71 C712.2 37.7,172.71 37.96,172.96 v2(37.96,173.54) 38.67,174.26 C700.2 ; v3(203.6,19.46) 202.75,19.46 R230.2 ; v3(39.62,53.52) 39.85,53.52 40.05,53.32 U32.38 ; ST8.2 49.68,37.95 49.99,38.25 49.99,38.28 50.09,38.38 ; v3(161.16,194.44) 161.1,194.5 C1403.1 ; C2133.2 104.18,200.05 v3(103.57,200.66) ; C1327.2 v3(185.19,63.68) ; R5416.2 v3(14.3,123.58) ; v2(99.39,153.92) 99.39,153.55 R1007.1 ; v3(39.55,50.16) 39.7,50.32 U32.32 ; C988.2 v3(195.26,197.85) ; v2(39.54,175.92) 39.19,175.58 C714.2 ; C935.2 183.98,69.86 v2(184.12,69.72) ; 205.08,168.43 205.05,168.4 ST3.2 ; C731.2 v2(48.26,173.23) ; v2(44.07,16.1) 43.59,16.1 ST21.2 ; U32.4 v2(42.57,54.94) ; 133.93,13.06 133.86,13.13 ST5.2 ; U32.33 39.82,50.82 39.78,50.77 v3(38.99,50.77) ; U33.30 21.63,48.96 21.03,48.36 20.57,48.36 20.08,48.86 v2(19.68,48.86) ; R932.2 v2(83.08,150.62) ; R949.2 116.48,117.64 v2(116.52,117.6) ; U33.7 24.13,54.69 v2(23.87,54.94) 23.63,54.69 U33.6 ; C704.2 33.12,173.67 C737.2 ; v3(153.01,31.75) 153.19,31.57 U36.4 ; R124.1 79.31,140.72 v2(79.51,140.92) ; C1400.1 v3(147.07,193.42) ; ST10.2 157.25,13.26 157.58,12.93 ; 109.27,13.08 109.09,13.26 ST9.2 ; v3(186.91,131.36) 187.86,131.36 R402.2 187.72,130.5 v3(186.89,130.5) ; U36.23 v3(155.08,28.61) ; v3(74.12,201.9) C2115.2 ; v2(34.73,175.92) 34.7,175.96 C736.2 ; U33.38 20.24,53.32 20.02,53.54 v2(19.74,53.54) ; R1009.1 121.96,153.63 v2(122.25,153.92) ; v3(39.59,52.44) 39.71,52.32 U32.36 ; v3(117.36,200.56) 117.69,200.23 C2135.2 ; v2(118.82,146.52) 118.24,145.94 118.24,145.94 ; R205.1 48.32,56.96 v3(48.9,56.39) ; R667.2 111.1,118.68 C1122.2 110.78,117.44 110.93,117.28 110.93,116.88 110.82,116.77 110.82,116.41 110.93,116.29 110.93,115.84 110.79,115.69 110.79,115.46 111.15,115.1 111.51,115.1 111.99,114.62 112.38,114.62 112.93,114.07 113.27,114.07 113.55,113.79 113.55,113.43 113.36,113.25 113.36,112.98 113.54,112.8 113.54,112.43 113.52,112.42 113.51,112.37 113.42,112.27 113.42,111.92 113.56,111.78 113.56,111.44 C290.2 ; v3(76.28,201.75) 76.58,202.06 C2117.2 ; C1439.2 116.89,58.95 116.11,58.17 v2(115.87,58.17) ; U37.23 v3(50.43,106.54) ; C1402.1 155.96,193.6 v3(156.18,193.37) ; U32.35 39.88,51.82 39.8,51.89 v3(39.04,51.89) ; v2(73.9,140.92) 73.9,140.28 74.1,140.08 ; C1515.1 122.65,148.03 v2(121.97,148.72) ; v2(26.59,173.99) 26.59,173.6 C673.2 ; v3(40.83,47.88) 40.83,48.02 41.57,48.75 U32.30 ; ST13.2 56.52,140.97 56.64,140.84 ; C730.2 39.65,171.92 v2(39.54,171.92) 39.41,172.05 C690.2 ; R644.1 121.84,110.93 C1104.2 120.66,110.93 120.33,110.6 v2(119.99,110.6) ; C699.2 40.89,162.91 v3(40.99,162.81) ; C658.2 v3(165.07,207.14) ; C672.2 20.95,177.49 v2(21.51,178.05) ; R1008.1 110.82,153.63 v2(110.82,153.92) ; v3(75.56,59.36) v3(75.56,60.01) C373.2 76.83,59.59 v3(76.53,59.28) ; V4.1 68.58,178.56 ; U32.6 43.57,54.48 arc(43.56,54.51) 43.56,54.55 arc(43.49,54.79) v2(43.36,55.02) ; U82.8 v3(164.91,203.5) ; v3(39.62,51.32) U32.34 ; C1399.1 v3(142.62,193.42) ; ST4.2 32.28,34.75 32.64,35.1 ; C696.2 38.73,170.1 39.32,169.52 v2(39.54,169.52) ; 79,204.24 79,204 C2116.2 ; U32.37 39.97,52.82 39.8,52.98 v3(38.96,52.98) ; 204.62,127.89 204.22,128.3 v4(203.96,128.3) ; U33.34 v3(19.39,51.32) ; C551.2 66.06,73.86 v3(65.76,74.17) ; C1497.1 102.75,140.54 v2(102.37,140.92) ; 51.92,192.6 51.92,194.56 51.6,194.88 39.39,194.88 R512.2 ; R5398.2 v3(120.92,17.13) ; U25.12 v3(46.42,141.23) ; R5452.2 v3(91.99,10.45) ; v3(168.53,47.65) 169.02,47.16 R1065.1 ; C1398.1 v3(138.81,194.5) ; v3(123.12,200.17) 122.84,199.89 C2138.2 ; R5407.2 v3(18.12,34.37) ; C1401.1 v3(151.36,193.42)
  BOTTOM w0.279: C1482.2 83.94,148.78 v2(83.85,148.87)
  BOTTOM w0.305: R517.2 52.32,214 ; R120.2 107.12,146.24 v2(107.39,146.52) ; v2(84.53,146.52) 84.26,146.24 R116.2 ; R121.2 118.24,145.94 ; R117.2 95.69,146.24 v2(95.96,146.52) ; R134.1 74.1,140.08
  BOTTOM w0.381: R317.2 v3(31.37,131.5) ; R332.2 v3(46.74,134.01) ; R324.2 v3(44.2,133.98) ; v2(106.58,151.3) 106.72,151.45 R934.2 ; J35.1 154.81,163.29 154.43,163.67 v3(153.03,163.67) ; v2(89.33,144.12) 88.7,144.12 C1488.1 ; v3(60.55,46.96) 60.96,47.37 C944.1 ; v2(112.19,144.12) 111.69,144.12 C1517.1 ; R330.2 v3(45.47,131.47) ; C681.2 v3(28.83,133.99) ; C1531.2 72.81,148.46 C1546.1 ; v2(122.58,98.1) 122.58,97 C1623.2 122.94,96.12 v2(123.45,95.6) ; v2(113.8,140.92) 113.95,140.77 C1529.1 ; R318.2 v3(41.66,131.47) ; R331.2 v3(36.45,133.99) ; v3(163.68,136.91) 163.61,136.97 C657.2 ; v3(157.07,163.67) 157.35,163.39 J35.3 ; C1487.1 100.22,144.12 v2(100.76,144.12) ; R505.2 v3(60.48,45.97) ; C680.2 v3(27.56,134.01) ; R313.2 v3(30.1,131.45) ; v2(90.94,140.92) 90.94,139.92 C1498.1 ; v2(123.62,144.12) 123.14,144.12 C1516.1 ; J35.5 159.89,163.39 v3(159.61,163.67) ; C1518.1 110.84,148.41 v2(110.54,148.72) ; v2(69.15,154.92) 69.5,154.56 C1553.2 ; R314.2 v3(40.39,131.44) ; C679.2 v3(39.12,133.96) ; R322.2 v3(42.93,131.47) ; R328.2 v3(45.47,134.01) ; R334.2 v3(40.39,134.09) ; 100.98,105.63 101.06,105.55 C130.2 ; v2(127.78,98.1) 127.64,97.95 C1625.2 128.19,96.6 v2(128.65,96.6) ; R320.2 v3(42.93,133.98) ; v3(90.84,60.2) C1463.2 C375.2 v3(90.84,62.8) ; R326.2 v3(44.2,131.47) ; C536.2 v3(184.9,119.77) ; R329.2 v3(36.45,131.42) ; R323.2 v3(33.91,133.96) ; v3(112.84,46.24) v2(112.84,46.86) v2(112.84,47.51) C1779.2 112.84,49.82 C399.1 ; R319.2 v3(32.64,133.91) ; C758.2 164.2,86.36 ; R310.2 v3(16.76,156.31) ; R321.2 v3(33.91,131.4) ; R333.2 v3(28.83,131.45) ; C656.2 163.56,135.62 v3(163.68,135.51) ; C1528.1 125.15,140.83 v2(125.23,140.92) ; R315.2 v3(31.37,133.94) ; R325.2 v3(35.18,131.5) ; R327.2 v3(35.18,133.96) ; R316.2 v3(41.66,134.01)
  BOTTOM w0.508: v2(149.32,89.09) 149.05,89.09 Q1.E ; v3(45.9,47.27) 45.8,47.37 45.03,47.37 v3(44.91,47.24) 44.91,46.33 44.83,46.25 44.83,46.11 44.44,45.72 C803.1 ; v3(162,132.21) 162.09,132.12 C1622.2 ; Q2.E v2(148.14,80.64) ; v3(39.85,47.88) v3(40.83,47.88) C801.2 ; J49.5 v3(175.38,137.03) ; v2(148.79,85.57) 148.5,85.28 Q3.E ; v3(168.5,133.1) 167.68,133.1 167.17,132.59 J49.10 ; v2(19.68,48.86) v2(18.41,48.86)
  vias: v1(3.3,40.77) v1(4.57,42.04) v1(4.57,40.77) v1(5.84,42.04) v1(5.84,40.77) v1(7.11,42.04) v1(7.11,35.69) v1(7.11,34.42) v1(8.38,42.04) v1(8.38,35.69) v1(8.38,34.42) v1(9.65,34.42) v1(10.92,42.04) v1(10.92,34.42) v1(12.19,42.04) v1(12.19,34.42) v1(13.46,42.04) v1(13.46,35.69) v1(13.46,34.42) v1(14.73,42.04) v1(14.73,34.42) v1(15.77,147.52) v1(15.77,141.17) v1(15.77,139.9) v1(16,42.04) v1(16,40.77) v1(16,34.42) v1(17.04,147.52) v1(17.04,139.9) v1(18.31,147.52) v1(18.31,146.25) v1(18.31,139.9) v1(19.58,147.52) v1(19.58,139.9) v1(20.7,38.99) v1(20.7,37.72) v1(20.85,147.52) v1(20.85,139.9) v1(21.97,38.99) v1(21.97,37.72) v1(22.12,147.52) v1(22.12,139.9) v1(23.24,38.99) v1(23.24,37.72) v1(23.39,147.52) v1(23.39,146.25) v1(23.39,139.9) v1(24.51,38.99) v1(24.51,32.64) v1(24.51,31.37) v1(24.66,147.52) v1(24.66,146.25) v1(24.66,139.9) v1(25.78,38.99) v1(25.78,32.64) v1(25.78,31.37) v1(25.93,141.17) v1(25.93,139.9) v1(27.05,31.37) v1(27.2,141.17) v1(27.2,139.9) v1(28.32,38.99) v1(28.32,31.37) v1(28.47,141.17) v1(28.47,139.9) v1(29.59,38.99) v1(29.59,31.37) v1(30.86,38.99) v1(30.86,32.64) v1(30.86,31.37) v1(32.13,38.99) v1(32.13,31.37) v1(33.4,38.99) v1(33.4,37.72) v1(33.4,31.37) v1(37.97,41.15) v1(37.97,39.88) v1(39.24,41.15) v1(39.24,39.88) v1(40.51,41.15) v1(40.51,39.88) v1(41.78,41.15) v1(41.78,34.8) v1(41.78,33.53) v1(43.05,41.15) v1(43.05,34.8) v1(43.05,33.53) v1(44.32,33.53) v1(45.59,41.15) v1(45.59,33.53) v1(46.86,41.15) v1(46.86,33.53) v1(48.13,41.15) v1(48.13,34.8) v1(48.13,33.53) v1(49.4,41.15) v1(49.4,33.53) v1(50.67,41.15) v1(50.67,39.88) v1(50.67,33.53) v1(67.91,176.33) v1(67.91,175.06) v1(67.91,173.79) v1(67.91,172.52) v1(69.18,173.79) v1(84.38,21.21) v1(84.38,19.94) v1(84.38,18.67) v1(84.38,17.4) v1(84.38,16.13) v1(84.38,14.86) v1(84.38,13.59) v1(84.38,12.32) v1(85.65,21.21) v1(85.65,19.94) v1(85.65,14.86) v1(90.73,25.02) v1(90.73,23.75) v1(90.73,22.48) v1(90.73,12.32) v1(92,25.02) v1(92,23.75) v1(92,22.48) v1(92,21.21) v1(92,19.94) v1(92,17.4) v1(92,16.13) v1(92,14.86) v1(92,13.59) v1(92,12.32) v1(104.52,21.21) v1(104.52,19.94) v1(104.52,18.67) v1(104.52,17.4) v1(104.52,16.13) v1(104.52,14.86) v1(104.52,13.59) v1(104.52,12.32) v1(105.79,21.21) v1(105.79,19.94) v1(105.79,14.86) v1(110.87,25.02) v1(110.87,23.75) v1(110.87,22.48) v1(110.87,12.32) v1(112.14,25.02) v1(112.14,23.75) v1(112.14,22.48) v1(112.14,21.21) v1(112.14,19.94) v1(112.14,17.4) v1(112.14,16.13) v1(112.14,14.86) v1(112.14,13.59) v1(112.14,12.32) v1(129.26,21.21) v1(129.26,19.94) v1(129.26,18.67) v1(129.26,17.4) v1(129.26,16.13) v1(129.26,14.86) v1(129.26,13.59) v1(129.26,12.32) v1(130.53,21.21) v1(130.53,19.94) v1(130.53,14.86) v1(135.61,25.02) v1(135.61,23.75) v1(135.61,22.48) v1(135.61,12.32) v1(136.88,25.02) v1(136.88,23.75) v1(136.88,22.48) v1(136.88,21.21) v1(136.88,19.94) v1(136.88,17.4) v1(136.88,16.13) v1(136.88,14.86) v1(136.88,13.59) v1(136.88,12.32) v1(152.5,21.21) v1(152.5,19.94) v1(152.5,18.67) v1(152.5,17.4) v1(152.5,16.13) v1(152.5,14.86) v1(152.5,13.59) v1(152.5,12.32) v1(153.77,21.21) v1(153.77,19.94) v1(153.77,14.86) v1(158.85,25.02) v1(158.85,23.75) v1(158.85,22.48) v1(158.85,12.32) v1(160.12,25.02) v1(160.12,23.75) v1(160.12,22.48) v1(160.12,21.21) v1(160.12,19.94) v1(160.12,17.4) v1(160.12,16.13) v1(160.12,14.86) v1(160.12,13.59) v1(160.12,12.32) v1(179.4,202.74) v1(180.67,204.01) v1(180.67,202.74) v1(180.67,201.47) v1(180.67,200.2) v2(8.16,207.64) v2(8.42,190.12) v2(12.14,140.93) v2(13.05,169.04) v2(13.05,168.27) v2(13.05,166.37) v2(13.05,165.61) v2(13.33,140.93) v2(13.56,163.7) v2(13.56,162.94) v2(13.82,169.04) v2(13.82,168.27) v2(13.82,166.37) v2(13.82,165.61) v2(14.32,163.7) v2(14.32,162.94) v2(17.5,16.89) v2(17.5,11.81) v2(17.78,1.27) v2(17.9,174.88) v2(18.15,188.7) v2(18.14,185.26) v2(18.18,187.97) v2(18.18,185.99) v2(18.89,188.67) v2(18.95,185.99) v2(18.91,185.26) v2(18.96,187.94) v2(19.7,9.93) v2(20.12,11.06) v2(20.32,1.27) v2(21.51,179.07) v2(21.51,177.04) v2(21.51,176.02) v2(21.51,175) v2(22.52,178.05) v2(22.52,177.04) v2(22.52,176.02) v2(22.52,175) v2(22.52,173.99) v2(22.86,17.27) v2(22.86,16.26) v2(22.86,15.24) v2(22.86,14.22) v2(22.86,13.21) v2(22.86,1.27) v2(23.54,179.07) v2(23.54,178.05) v2(23.54,177.04) v2(23.54,176.02) v2(23.54,175) v2(23.54,173.99) v2(23.88,17.27) v2(23.88,16.26) v2(23.88,15.24) v2(23.88,14.22) v2(23.88,13.21) v2(24.56,179.07) v2(24.56,178.05) v2(24.56,177.04) v2(24.56,176.02) v2(24.56,175) v2(24.56,173.99) v2(24.89,17.27) v2(24.89,16.26) v2(24.89,15.24) v2(24.89,14.22) v2(24.89,13.21) v2(25.4,3.12) v2(25.4,1.27) v2(25.57,179.07) v2(25.57,178.05) v2(25.57,177.04) v2(25.57,176.02) v2(25.57,175) v2(25.57,173.99) v2(25.91,17.27) v2(25.91,16.26) v2(25.91,15.24) v2(25.91,14.22) v2(25.91,13.21) v2(26.59,178.05) v2(26.59,177.04) v2(26.59,176.02) v2(26.92,17.27) v2(26.92,16.26) v2(26.92,15.24) v2(26.92,14.22) v2(26.92,13.21) v2(27.29,20.81) v2(27.69,182.27) v2(27.91,3.07) v2(27.94,1.27) v2(28.49,20.83) v2(29.56,167.26) v2(30.05,152.78) v2(30.26,188.47) v2(30.38,3) v2(30.48,1.27) v2(30.58,190.63) v2(30.58,189.61) v2(30.56,18.84) v2(30.61,15.62) v2(30.71,194.12) v2(30.96,13.72) v2(31.21,11.18) v2(31.53,171.12) v2(31.6,190.63) v2(31.6,189.61) v2(32.35,161.56) v2(32.61,190.63) v2(32.61,189.61) v2(32.81,160.98) v2(33.01,162.4) v2(32.97,2.95) v2(33.02,1.27) v2(33.13,164.19) v2(33.13,163.3) v2(33.37,187.64) v2(33.37,16.26) v2(33.5,11.3) v2(33.63,190.63) v2(33.63,189.61) v2(34.2,153.42) v2(34.2,152.27) v2(34.26,181.9) v2(34.64,190.63) v2(34.64,189.61) v2(34.64,187.64) v2(34.83,194.18) v2(34.92,153.03) v2(34.9,151.76) v2(35.15,181.9) v2(35.53,2.89) v2(35.56,1.27) v2(36.04,181.9) v2(36.2,153.03) v2(36.32,163.77) v2(36.8,151.76) v2(36.93,181.9) v2(37.02,11.11) v2(37.02,10.14) v2(37.21,163.75) v2(37.51,152.35) v2(37.56,11.12) v2(37.56,10.15) v2(37.69,186.88) v2(37.74,154.43) v2(37.82,181.9) v2(37.92,167.93) v2(38.02,151.71) v2(37.97,2.79) v2(38.1,1.27) v2(38.17,146.18) v2(38.33,153.82) v2(38.71,181.9) v2(39.04,163.75) v2(38.96,147.73) v2(39.12,154.05) v2(39.23,10.96) v2(39.23,10.09) v2(39.77,10.96) v2(39.77,10.1) v2(39.98,151.89) v2(40.49,2.89) v2(40.61,182.37) v2(40.64,1.27) v2(41.76,182.37) v2(41.94,22.63) v2(41.94,21.86) v2(42.16,152.02) v2(42.67,147.57) v2(42.78,167.89) v2(42.95,22.63) v2(42.95,21.86) v2(43.18,1.27) v2(43.38,146.73) v2(43.57,10.56) v2(43.58,10.02) v2(43.99,182.32) v2(44.07,14.83) v2(44.07,13.56) v2(44.07,12.29) v2(44.23,10.56) v2(44.24,10.02) v2(44.41,11.7) v2(44.65,145.03) v2(45.03,11.24) v2(45.09,181.93) v2(45.22,10.71) v2(45.23,10.17) v2(45.34,13.56) v2(45.72,1.27) v2(45.97,181.93) v2(47.12,179.39) v2(47.11,159.59) v2(48.26,172.34) v2(48.26,171.32) v2(48.26,1.27) v2(48.92,170.23) v2(49.25,140.69) v2(49.28,139.83) v2(49.43,144.25) v2(49.73,170.25) v2(50.01,140.69) v2(50.06,139.93) v2(50.49,146.1) v2(50.8,1.27) v2(50.9,151.61) v2(51.66,151.61) v2(51.98,45.65) v2(52.14,135.46) v2(52.4,47.5) v2(52.45,48.13) v2(52.55,151.64) v2(52.93,48.11) v2(53.04,47.5) v2(53.34,1.27) v2(53.95,158.48) v2(54.66,154.53) v2(54.81,47.5) v2(54.86,48.13) v2(54.99,158.48) v2(55.24,140.34) v2(55.35,48.11) v2(55.44,110.11) v2(55.44,108.84) v2(55.45,47.5) v2(55.75,154.56) v2(55.88,1.27) v2(56.03,42.85) v2(56.03,42.21) v2(56.06,45.47) v2(56.06,44.83) v2(56.49,159.16) v2(56.52,155.47) v2(56.52,140.34) v2(56.61,154.56) v2(56.69,45.42) v2(56.67,44.93) v2(56.9,42.95) v2(56.9,42.32) v2(57.4,155.47) v2(57.35,50.11) v2(57.48,154.58) v2(57.68,147.08) v2(57.78,141.6) v2(57.78,140.34) v2(57.76,112.09) v2(57.76,109.3) v2(58.07,201.93) v2(58.42,1.27) v2(58.62,50.11) v2(59.05,140.34) v2(59.6,111.33) v2(59.6,110.06) v2(59.89,50.11) v2(60.96,1.27) v2(61.16,50.11) v2(61.49,139.8) v2(62.33,136.14) v2(62.31,135.41) v2(62.31,133.4) v2(62.36,134.26) v2(62.58,8.64) v2(62.71,38.35) v2(62.71,24.51) v2(62.81,142.72) v2(62.94,145.73) v2(62.94,145.11) v2(62.97,143.34) v2(63.5,1.27) v2(63.73,38.35) v2(63.73,24.51) v2(63.85,8.64) v2(66.04,1.27) v2(68.58,1.27) v2(71.12,1.27) v2(72.17,154.05) v2(72.17,152.78) v2(72.24,139.32) v2(73.1,151.32) v2(73.66,1.27) v2(73.91,154.52) v2(74.71,152.12) v2(74.7,149.71) v2(74.71,147.32) v2(74.71,146.52) v2(74.71,145.72) v2(74.71,144.92) v2(74.71,144.12) v2(74.71,143.32) v2(74.71,142.52) v2(74.71,141.72) v2(74.71,140.92) v2(76.25,148.72) v2(76.2,144.97) v2(76.2,1.27) v2(76.68,151.21) v2(76.83,152.35) v2(77.04,148.79) v2(76.97,51.75) v2(76.99,50.85) v2(76.98,50.03) v2(77.58,51.78) v2(77.6,50.88) v2(77.59,50.06) v2(78.01,35.18) v2(78.01,34.16) v2(78.23,50.88) v2(78.22,50.06) v2(78.71,147.32) v2(78.71,146.52) v2(78.71,145.72) v2(78.71,144.92) v2(78.7,144.12) v2(78.7,143.32) v2(78.7,142.52) v2(78.7,141.72) v2(78.7,140.92) v2(78.74,1.27) v2(78.79,154.52) v2(79.5,149.66) v2(79.86,36.07) v2(79.86,33.27) v2(80.36,63.94) v2(81,37.59) v2(81,36.19) v2(81.28,1.27) v2(81.53,138.56) v2(82.36,141.73) v2(82.87,205.71) v2(82.85,204.74) v2(82.87,203.29) v2(82.85,202.32) v2(83.6,155.32) v2(83.6,154.05) v2(83.6,152.78) v2(83.63,144.15) v2(83.82,1.27) v2(85.34,154.52) v2(85.35,121.6) v2(85.35,120.6) v2(85.35,117.6) v2(85.35,112.6) v2(85.35,108.6) v2(85.35,106.6) v2(85.35,104.6) v2(85.35,102.6) v2(85.35,100.6) v2(85.35,98.6) v2(85.35,96.6) v2(85.35,94.6) v2(85.35,92.6) v2(85.35,90.6) v2(85.35,85.6) v2(85.35,82.6) v2(85.35,81.6) v2(86.14,152.12) v2(86.14,150.52) v2(86.14,147.32) v2(86.14,146.52) v2(86.14,145.72) v2(86.14,144.92) v2(86.14,144.12) v2(86.14,143.32) v2(86.14,142.52) v2(86.14,141.72) v2(86.14,140.92) v2(86.21,122.1) v2(86.21,121.1) v2(86.21,120.1) v2(86.21,115.1) v2(86.21,110.1) v2(86.21,109.1) v2(86.21,107.1) v2(86.21,105.1) v2(86.21,103.1) v2(86.21,101.1) v2(86.21,99.1) v2(86.21,97.1) v2(86.21,95.1) v2(86.21,93.1) v2(86.21,92.1) v2(86.21,90.1) v2(86.21,89.1) v2(86.21,88.1) v2(86.21,87.1) v2(86.21,86.1) v2(86.21,85.1) v2(86.21,84.1) v2(86.21,83.1) v2(86.21,82.1) v2(86.21,81.1) v2(86.36,1.27) v2(86.46,42.29) v2(87.08,121.6) v2(87.08,120.6) v2(87.08,117.6) v2(87.08,112.6) v2(87.08,108.6) v2(87.08,107.6) v2(87.08,106.6) v2(87.08,105.6) v2(87.08,104.6) v2(87.08,103.6) v2(87.08,102.6) v2(87.08,101.6) v2(87.08,100.6) v2(87.08,99.6) v2(87.08,98.6) v2(87.08,97.6) v2(87.08,96.6) v2(87.08,95.6) v2(87.08,94.6) v2(87.08,93.6) v2(87.08,92.6) v2(87.08,91.6) v2(87.08,90.6) v2(87.08,85.6) v2(87.08,81.6) v2(87.25,53.09) v2(87.48,42.29) v2(87.73,148.4) v2(87.95,122.1) v2(87.95,121.1) v2(87.95,120.1) v2(87.95,119.1) v2(87.95,118.1) v2(87.95,117.1) v2(87.95,116.1) v2(87.95,115.1) v2(87.95,114.1) v2(87.95,113.1) v2(87.95,110.1) v2(87.95,108.1) v2(87.95,106.1) v2(87.95,104.1) v2(87.95,102.1) v2(87.95,100.1) v2(87.95,98.1) v2(87.95,96.1) v2(87.95,94.1) v2(87.95,92.1) v2(87.95,91.1) v2(87.95,88.1) v2(87.95,83.1) v2(87.95,81.1) v2(87.88,53.09) v2(88.11,151.21) v2(88.31,152.37) v2(88.53,148.62) v2(88.81,117.6) v2(88.81,112.6) v2(88.81,107.6) v2(88.81,105.6) v2(88.81,103.6) v2(88.81,101.6) v2(88.81,99.6) v2(88.81,97.6) v2(88.81,95.6) v2(88.81,93.6) v2(88.81,91.6) v2(88.81,90.6) v2(88.81,85.6) v2(88.9,1.27) v2(89.41,39.94) v2(89.68,120.1) v2(89.68,115.1) v2(89.68,110.1) v2(89.68,108.1) v2(89.68,107.1) v2(89.68,106.1) v2(89.68,105.1) v2(89.68,104.1) v2(89.68,103.1) v2(89.68,102.1) v2(89.68,101.1) v2(89.68,100.1) v2(89.68,99.1) v2(89.68,98.1) v2(89.68,97.1) v2(89.68,96.1) v2(89.68,95.1) v2(89.68,94.1) v2(89.68,93.1) v2(89.68,92.1) v2(89.68,91.1) v2(89.68,88.1) v2(89.68,83.1) v2(90.14,154.52) v2(90.14,147.32) v2(90.14,146.52) v2(90.14,145.72) v2(90.14,144.92) v2(90.13,144.12) v2(90.13,143.32) v2(90.13,142.52) v2(90.13,141.72) v2(90.13,140.92) v2(90.17,149.71) v2(90.54,117.6) v2(90.54,112.6) v2(90.54,108.6) v2(90.54,106.6) v2(90.54,104.6) v2(90.54,102.6) v2(90.54,100.6) v2(90.54,98.6) v2(90.54,96.6) v2(90.54,94.6) v2(90.54,92.6) v2(90.54,90.6) v2(90.54,85.6) v2(91.41,120.1) v2(91.41,115.1) v2(91.41,110.1) v2(91.41,109.1) v2(91.41,107.1) v2(91.41,105.1) v2(91.41,103.1) v2(91.41,101.1) v2(91.41,99.1) v2(91.41,97.1) v2(91.41,95.1) v2(91.41,93.1) v2(91.41,92.1) v2(91.41,88.1) v2(91.41,83.1) v2(91.44,1.27) v2(91.54,36.45) v2(91.54,35.69) v2(91.74,50.85) v2(91.73,49.61) v2(91.73,48.51) v2(92.28,117.6) v2(92.28,112.6) v2(92.28,108.6) v2(92.28,107.6) v2(92.28,106.6) v2(92.28,105.6) v2(92.28,104.6) v2(92.28,103.6) v2(92.28,102.6) v2(92.28,101.6) v2(92.28,100.6) v2(92.28,99.6) v2(92.28,98.6) v2(92.28,97.6) v2(92.28,96.6) v2(92.28,95.6) v2(92.28,94.6) v2(92.28,93.6) v2(92.28,92.6) v2(92.28,91.6) v2(92.28,90.6) v2(92.28,89.6) v2(92.28,88.6) v2(92.28,87.6) v2(92.28,86.6) v2(92.28,85.6) v2(92.28,84.6) v2(92.28,83.6) v2(92.28,82.6) v2(92.28,81.6) v2(92.57,51.41) v2(92.56,9.52) v2(93.14,120.1) v2(93.14,115.1) v2(93.14,110.1) v2(93.14,109.1) v2(93.14,108.1) v2(93.14,106.1) v2(93.14,104.1) v2(93.14,102.1) v2(93.14,100.1) v2(93.14,98.1) v2(93.14,96.1) v2(93.14,94.1) v2(93.14,92.1) v2(93.14,91.1) v2(93.14,88.1) v2(93.14,83.1) v2(93.24,63.32) v2(93.57,51.41) v2(93.79,141.73) v2(94.01,121.6) v2(94.01,120.6) v2(94.01,119.6) v2(94.01,118.6) v2(94.01,117.6) v2(94.01,116.6) v2(94.01,115.6) v2(94.01,114.6) v2(94.01,113.6) v2(94.01,112.6) v2(94.01,109.6) v2(94.01,107.6) v2(94.01,105.6) v2(94.01,103.6) v2(94.01,101.6) v2(94.01,99.6) v2(94.01,97.6) v2(94.01,95.6) v2(94.01,93.6) v2(94.01,91.6) v2(94.01,90.6) v2(94.01,85.6) v2(93.95,9.52) v2(93.98,1.27) v2(94.43,51.08) v2(94.84,63.5) v2(94.87,120.1) v2(94.87,115.1) v2(94.87,110.1) v2(94.87,109.1) v2(94.87,107.1) v2(94.87,106.1) v2(94.87,105.1) v2(94.87,104.1) v2(94.87,103.1) v2(94.87,102.1) v2(94.87,101.1) v2(94.87,100.1) v2(94.87,99.1) v2(94.87,98.1) v2(94.87,97.1) v2(94.87,96.1) v2(94.87,95.1) v2(94.87,94.1) v2(94.87,93.1) v2(94.87,92.1) v2(94.87,91.1) v2(94.87,88.1) v2(94.87,83.1) v2(95.03,155.32) v2(95.03,154.05) v2(95.03,152.78) v2(95.06,144.15) v2(95.24,51.08) v2(95.48,34.54) v2(95.48,33.53) v2(95.74,117.6) v2(95.74,112.6) v2(95.74,109.6) v2(95.74,106.6) v2(95.74,103.6) v2(95.74,102.6) v2(95.74,101.6) v2(95.74,100.6) v2(95.74,99.6) v2(95.74,98.6) v2(95.74,97.6) v2(95.74,96.6) v2(95.74,95.6) v2(95.74,94.6) v2(95.74,92.6) v2(95.74,90.6) v2(95.74,85.6) v2(95.86,63.5) v2(95.96,151.32) v2(96.07,51.41) v2(96.52,1.27) v2(96.6,120.1) v2(96.6,115.1) v2(96.6,110.1) v2(96.6,109.1) v2(96.6,104.1) v2(96.6,95.1) v2(96.6,93.1) v2(96.6,88.1) v2(96.6,83.1) v2(96.75,34.04) v2(96.75,32.77) v2(96.77,154.52) v2(97.07,51.41) v2(97.33,63.3) v2(97.47,117.6) v2(97.47,112.6) v2(97.47,109.6) v2(97.47,106.6) v2(97.47,105.6) v2(97.47,104.6) v2(97.47,100.6) v2(97.47,99.6) v2(97.47,98.6) v2(97.47,94.6) v2(97.47,90.6) v2(97.47,85.6) v2(97.57,152.12) v2(97.57,149.72) v2(97.57,147.32) v2(97.57,146.52) v2(97.57,145.72) v2(97.57,144.92) v2(97.57,144.12) v2(97.57,143.32) v2(97.57,142.52) v2(97.57,141.72) v2(97.57,140.92) v2(98.07,51.41) v2(98.35,151.31) v2(98.34,120.1) v2(98.34,115.1) v2(98.34,110.1) v2(98.34,109.1) v2(98.34,104.1) v2(98.34,103.1) v2(98.34,102.1) v2(98.34,101.1) v2(98.34,98.1) v2(98.34,97.1) v2(98.34,96.1) v2(98.34,95.1) v2(98.34,93.1) v2(98.34,90.1) v2(98.34,89.1) v2(98.34,88.1) v2(98.34,87.1) v2(98.34,86.1) v2(98.34,85.1) v2(98.34,84.1) v2(98.34,83.1) v2(98.34,82.1) v2(98.34,81.1) v2(99.11,148.72) v2(99.07,51.41) v2(99.06,1.27) v2(99.2,117.6) v2(99.2,112.6) v2(99.2,109.6) v2(99.2,106.6) v2(99.2,103.6) v2(99.2,100.6) v2(99.2,99.6) v2(99.2,98.6) v2(99.2,94.6) v2(99.2,90.6) v2(99.2,85.6) v2(99.36,63.58) v2(99.54,151.21) v2(99.74,152.37) v2(99.9,148.79) v2(100.07,122.1) v2(100.07,121.1) v2(100.07,120.1) v2(100.07,119.1) v2(100.07,118.1) v2(100.07,117.1) v2(100.07,116.1) v2(100.07,115.1) v2(100.07,114.1) v2(100.07,113.1) v2(100.07,110.1) v2(100.07,109.1) v2(100.07,108.1) v2(100.07,107.1) v2(100.07,104.1) v2(100.07,103.1) v2(100.07,102.1) v2(100.07,101.1) v2(100.07,100.1) v2(100.07,99.1) v2(100.07,98.1) v2(100.07,97.1) v2(100.07,96.1) v2(100.07,95.1) v2(100.07,94.1) v2(100.07,88.1) v2(100.07,83.1) v2(100.07,51.41) v2(100.61,63.5) v2(100.77,150.52) v2(100.94,117.6) v2(100.94,112.6) v2(100.94,107.6) v2(100.94,105.6) v2(100.94,103.6) v2(100.94,99.6) v2(100.94,96.6) v2(100.94,90.6) v2(100.94,85.6) v2(101.07,51.41) v2(101.57,154.52) v2(101.57,147.32) v2(101.57,146.52) v2(101.57,145.72) v2(101.57,144.92) v2(101.56,144.12) v2(101.56,143.32) v2(101.56,142.52) v2(101.56,141.72) v2(101.56,140.92) v2(101.6,1.27) v2(101.8,120.1) v2(101.8,115.1) v2(101.8,111.1) v2(101.8,110.1) v2(101.8,109.1) v2(101.8,107.1) v2(101.8,102.1) v2(101.8,99.1) v2(101.8,96.1) v2(101.8,94.1) v2(101.8,93.1) v2(101.8,92.1) v2(101.8,88.1) v2(101.8,83.1) v2(102.07,51.41) v2(102.37,151.32) v2(102.37,149.72) v2(102.67,117.6) v2(102.67,112.6) v2(102.67,111.6) v2(102.67,90.6) v2(102.67,85.6) v2(103.07,51.41) v2(103.38,45.39) v2(103.53,120.1) v2(103.53,115.1) v2(103.53,110.1) v2(103.53,109.1) v2(103.53,108.1) v2(103.53,107.1) v2(103.53,106.1) v2(103.53,105.1) v2(103.53,104.1) v2(103.53,103.1) v2(103.53,102.1) v2(103.53,101.1) v2(103.53,100.1) v2(103.53,99.1) v2(103.53,98.1) v2(103.53,97.1) v2(103.53,96.1) v2(103.53,95.1) v2(103.53,94.1) v2(103.53,93.1) v2(103.53,92.1) v2(103.53,88.1) v2(103.53,83.1) v2(103.5,63.47) v2(104.07,51.41) v2(104.14,1.27) v2(104.4,117.6) v2(104.4,112.6) v2(104.4,92.6) v2(104.4,91.6) v2(104.4,90.6) v2(104.4,89.6) v2(104.4,88.6) v2(104.4,87.6) v2(104.4,86.6) v2(104.4,85.6) v2(104.4,84.6) v2(104.4,83.6) v2(104.4,82.6) v2(104.4,81.6) v2(104.39,45.39) v2(104.98,51.38) v2(105.22,141.73) v2(105.26,120.1) v2(105.26,115.1) v2(105.26,111.1) v2(105.26,110.1) v2(105.26,109.1) v2(105.26,107.1) v2(105.26,106.1) v2(105.26,105.1) v2(105.26,104.1) v2(105.26,103.1) v2(105.26,102.1) v2(105.26,101.1) v2(105.26,100.1) v2(105.26,98.1) v2(105.26,97.1) v2(105.26,96.1) v2(105.26,94.1) v2(105.26,93.1) v2(105.26,92.1) v2(105.26,88.1) v2(105.26,83.1) v2(105.74,51.36) v2(105.66,45.39) v2(105.94,63.6) v2(106.13,121.6) v2(106.13,120.6) v2(106.13,119.6) v2(106.13,118.6) v2(106.13,117.6) v2(106.13,116.6) v2(106.13,115.6) v2(106.13,114.6) v2(106.13,113.6) v2(106.13,112.6) v2(106.13,94.6) v2(106.13,93.6) v2(106.13,90.6) v2(106.13,85.6) v2(106.36,147.32) v2(106.43,144.15) v2(106.46,155.32) v2(106.46,154.05) v2(106.46,152.78) v2(106.57,51.41) v2(106.68,45.39) v2(106.68,1.27) v2(107,120.1) v2(107,115.1) v2(107,111.1) v2(107,110.1) v2(107,109.1) v2(107,107.1) v2(107,101.1) v2(107,96.1) v2(107,94.1) v2(107,93.1) v2(107,92.1) v2(107,91.1) v2(107,88.1) v2(107,83.1) v2(107.5,63.52) v2(107.57,51.41) v2(107.86,117.6) v2(107.86,112.6) v2(107.87,101.85) v2(107.86,90.6) v2(107.86,85.6) v2(108.07,45.39) v2(108.2,154.52) v2(108.43,103.56) v2(108.41,102.36) v2(108.57,51.41) v2(108.73,120.1) v2(108.73,115.1) v2(108.73,111.1) v2(108.73,110.1) v2(108.73,109.1) v2(108.73,107.1) v2(108.73,106.1) v2(108.73,97.1) v2(108.73,96.1) v2(108.73,94.1) v2(108.73,93.1) v2(108.73,92.1) v2(108.73,88.1) v2(108.73,83.1) v2(108.81,105.33) v2(108.81,98.68) v2(108.81,97.92) v2(108.92,104.19) v2(109,152.12) v2(109,150.52) v2(109,147.32) v2(109,146.52) v2(109,145.72) v2(109,144.92) v2(109,144.12) v2(109,143.32) v2(109,142.52) v2(109,141.72) v2(109,140.92) v2(109.09,45.39) v2(109.22,1.27) v2(109.37,104.83) v2(109.47,105.71) v2(109.5,97.31) v2(109.6,117.6) v2(109.6,112.6) v2(109.6,90.6) v2(109.6,85.6) v2(109.57,51.41) v2(109.88,63.47) v2(110.46,120.1) v2(110.46,115.1) v2(110.46,111.1) v2(110.46,110.1) v2(110.46,109.1) v2(110.46,107.1) v2(110.46,106.1) v2(110.46,105.36) v2(110.49,97.84) v2(110.46,97.1) v2(110.46,96.1) v2(110.46,94.1) v2(110.46,93.1) v2(110.46,92.1) v2(110.46,90.1) v2(110.46,89.1) v2(110.46,88.1) v2(110.46,87.1) v2(110.46,86.1) v2(110.46,85.1) v2(110.46,84.1) v2(110.46,83.1) v2(110.46,82.1) v2(110.46,81.1) v2(110.49,45.39) v2(110.57,51.41) v2(110.97,151.21) v2(111.11,63.45) v2(111.17,152.37) v2(111.22,105.63) v2(111.23,97.46) v2(111.33,148.79) v2(111.33,117.6) v2(111.33,112.6) v2(111.33,90.6) v2(111.33,85.6) v2(111.5,45.39) v2(111.57,51.41) v2(112.04,105.36) v2(112.04,97.87) v2(112.2,150.52) v2(112.19,122.1) v2(112.19,121.1) v2(112.19,120.1) v2(112.19,119.1) v2(112.19,118.1) v2(112.19,117.1) v2(112.19,116.1) v2(112.19,115.1) v2(112.19,114.1) v2(112.19,113.1) v2(112.19,111.1) v2(112.19,110.1) v2(112.19,109.1) v2(112.19,107.1) v2(112.19,106.1) v2(112.19,97.1) v2(112.19,96.1) v2(112.19,94.1) v2(112.19,93.1) v2(112.19,92.1) v2(112.19,88.1) v2(112.19,83.1) v2(112.57,51.41) v2(112.88,105.51) v2(112.88,97.61) v2(112.97,154.64) v2(113,147.32) v2(113,146.52) v2(113,145.72) v2(113,144.92) v2(112.99,144.12) v2(112.99,143.32) v2(112.99,142.52) v2(112.99,141.72) v2(112.99,140.92) v2(113.06,117.6) v2(113.06,112.6) v2(113.06,90.6) v2(113.06,85.6) v2(113.38,63.63) v2(113.42,51.69) v2(113.61,105.36) v2(113.67,97.79) v2(113.8,151.32) v2(113.8,149.72) v2(113.92,120.1) v2(113.92,115.1) v2(113.92,111.1) v2(113.92,110.1) v2(113.92,109.1) v2(113.92,107.1) v2(113.92,106.1) v2(113.92,97.1) v2(113.92,96.1) v2(113.92,94.1) v2(113.92,93.1) v2(113.92,92.1) v2(113.92,88.1) v2(113.92,83.1) v2(114.3,1.27) v2(114.57,104.15) v2(114.6,99.01) v2(114.66,105.03) v2(114.79,117.6) v2(114.79,112.6) v2(114.78,105.79) v2(114.78,97.54) v2(114.79,90.6) v2(114.79,85.6) v2(114.88,98.27) v2(115.01,55.52) v2(115.09,103.58) v2(115.11,102.59) v2(115.09,101.55) v2(115.09,100.61) v2(115.09,99.62) v2(115.48,59.47) v2(115.66,120.1) v2(115.66,115.1) v2(115.66,111.1) v2(115.66,110.1) v2(115.66,109.1) v2(115.66,107.1) v2(115.66,96.1) v2(115.66,94.1) v2(115.66,93.1) v2(115.66,92.1) v2(115.66,88.1) v2(115.66,83.1) v2(116.05,127) v2(116.05,126.11) v2(116.52,112.6) v2(116.52,90.6) v2(116.52,89.6) v2(116.52,88.6) v2(116.52,87.6) v2(116.52,86.6) v2(116.52,85.6) v2(116.52,84.6) v2(116.52,83.6) v2(116.52,82.6) v2(116.52,81.6) v2(116.65,141.73) v2(116.56,50.61) v2(116.84,1.27) v2(116.94,45.72) v2(117.07,127) v2(117.07,126.11) v2(117.39,120.1) v2(117.39,115.1) v2(117.39,111.1) v2(117.39,110.1) v2(117.39,109.1) v2(117.39,108.1) v2(117.39,107.1) v2(117.39,96.1) v2(117.39,95.1) v2(117.39,94.1) v2(117.39,93.1) v2(117.39,92.1) v2(117.39,88.1) v2(117.39,83.1) v2(117.73,62.91) v2(117.89,155.32) v2(117.89,154.05) v2(117.89,152.78) v2(117.89,147.17) v2(117.86,144.15) v2(118.05,141.6) v2(117.96,45.72) v2(118.21,50.61) v2(118.34,127) v2(118.34,126.11) v2(118.26,121.6) v2(118.26,120.6) v2(118.26,119.6) v2(118.26,118.6) v2(118.26,117.6) v2(118.26,116.6) v2(118.26,115.6) v2(118.26,114.6) v2(118.26,113.6) v2(118.26,112.6) v2(118.26,109.6) v2(118.26,108.6) v2(118.26,90.6) v2(118.26,85.6) v2(118.59,62.87) v2(118.62,59.32) v2(118.72,151.56) v2(118.97,45.72) v2(119.12,120.1) v2(119.12,115.1) v2(119.12,112.1) v2(119.12,111.1) v2(119.12,110.1) v2(119.12,109.1) v2(119.12,108.1) v2(119.12,107.1) v2(119.12,96.1) v2(119.12,95.1) v2(119.12,94.1) v2(119.12,93.1) v2(119.12,92.1) v2(119.12,91.1) v2(119.12,88.1) v2(119.12,83.1) v2(119.35,127) v2(119.35,126.11) v2(119.38,1.27) v2(119.63,154.52) v2(119.86,45.72) v2(119.99,117.6) v2(119.99,112.6) v2(119.99,111.6) v2(119.99,90.6) v2(119.99,85.6) v2(120.24,64.52) v2(120.43,152.12) v2(120.43,150.52) v2(120.43,149.72) v2(120.43,147.32) v2(120.43,146.52) v2(120.43,145.72) v2(120.43,144.92) v2(120.43,144.12) v2(120.43,143.32) v2(120.43,142.52) v2(120.43,141.72) v2(120.43,140.92) v2(120.75,127) v2(120.75,126.11) v2(120.85,120.1) v2(120.85,115.1) v2(120.85,110.1) v2(120.85,109.1) v2(120.85,108.1) v2(120.85,107.1) v2(120.85,106.1) v2(120.85,105.1) v2(120.85,104.1) v2(120.85,103.1) v2(120.85,102.1) v2(120.85,101.1) v2(120.85,100.1) v2(120.85,99.1) v2(120.85,98.1) v2(120.85,97.1) v2(120.85,96.1) v2(120.85,95.1) v2(120.85,94.1) v2(120.85,93.1) v2(120.85,92.1) v2(120.85,91.1) v2(120.85,88.1) v2(120.85,83.1) v2(121.13,45.72) v2(121.64,50.98) v2(121.72,117.6) v2(121.72,112.6) v2(121.72,107.6) v2(121.72,106.6) v2(121.72,105.6) v2(121.72,104.6) v2(121.72,101.6) v2(121.72,97.6) v2(121.72,95.6) v2(121.72,90.6) v2(121.72,85.6) v2(121.77,127) v2(121.77,126.11) v2(121.79,63.77) v2(121.89,59) v2(121.92,1.27) v2(122.15,45.72) v2(122.45,151.31) v2(122.6,152.37) v2(122.58,120.1) v2(122.58,115.1) v2(122.58,109.1) v2(122.58,108.1) v2(122.58,107.1) v2(122.58,106.1) v2(122.58,99.1) v2(122.58,93.1) v2(122.58,92.1) v2(122.58,91.1) v2(122.58,90.1) v2(122.58,89.1) v2(122.58,88.1) v2(122.58,87.1) v2(122.58,86.1) v2(122.58,85.1) v2(122.58,84.1) v2(122.58,83.1) v2(122.58,82.1) v2(122.58,81.1) v2(122.76,148.79) v2(123.04,63.77) v2(123.14,59) v2(123.06,50.98) v2(123.29,127) v2(123.29,126.11) v2(123.45,117.6) v2(123.45,112.6) v2(123.45,109.6) v2(123.45,107.6) v2(123.45,106.6) v2(123.45,105.6) v2(123.45,104.6) v2(123.45,103.6) v2(123.45,102.6) v2(123.45,101.6) v2(123.45,100.6) v2(123.45,99.6) v2(123.45,97.6) v2(123.45,90.6) v2(123.45,85.6) v2(123.63,150.52) v2(124.31,127) v2(124.31,126.11) v2(124.32,122.1) v2(124.32,121.1) v2(124.32,120.1) v2(124.32,119.1) v2(124.32,118.1) v2(124.32,117.1) v2(124.32,116.1) v2(124.32,115.1) v2(124.32,114.1) v2(124.32,113.1) v2(124.32,110.1) v2(124.32,107.1) v2(124.32,105.1) v2(124.32,102.1) v2(124.32,99.1) v2(124.32,98.1) v2(124.32,95.1) v2(124.32,93.1) v2(124.32,92.1) v2(124.32,91.1) v2(124.32,88.1) v2(124.32,83.1) v2(124.43,154.52) v2(124.43,147.32) v2(124.43,146.52) v2(124.43,145.72) v2(124.43,144.92) v2(124.42,144.12) v2(124.42,143.32) v2(124.42,142.52) v2(124.42,141.72) v2(124.42,140.92) v2(124.51,63.73) v2(124.46,51.92) v2(124.46,1.27) v2(124.69,55.56) v2(125.23,149.72) v2(125.18,117.6) v2(125.18,112.6) v2(125.18,110.6) v2(125.18,109.6) v2(125.18,108.6) v2(125.18,107.6) v2(125.18,106.6) v2(125.18,105.6) v2(125.18,104.6) v2(125.18,101.6) v2(125.18,100.6) v2(125.18,99.6) v2(125.18,97.6) v2(125.18,90.6) v2(125.18,85.6) v2(125.19,49.91) v2(125.37,64.46) v2(125.5,45.7) v2(125.83,127) v2(125.83,126.11) v2(125.85,51.25) v2(125.93,55.56) v2(126.05,120.1) v2(126.05,115.1) v2(126.05,111.1) v2(126.05,109.1) v2(126.05,107.1) v2(126.05,104.1) v2(126.05,103.1) v2(126.05,102.1) v2(126.05,100.1) v2(126.05,99.1) v2(126.05,98.1) v2(126.05,96.1) v2(126.05,95.1) v2(126.05,93.1) v2(126.05,88.1) v2(126.05,83.1) v2(126.29,63.64) v2(126.52,45.7) v2(126.69,60.27) v2(126.85,127) v2(126.85,126.11) v2(126.85,51.44) v2(126.92,117.6) v2(126.92,112.6) v2(126.92,111.6) v2(126.92,109.6) v2(126.92,107.6) v2(126.92,99.6) v2(126.92,95.6) v2(126.92,90.6) v2(126.92,85.6) v2(127,1.27) v2(127.23,55.56) v2(127.73,65.33) v2(127.78,120.1) v2(127.78,115.1) v2(127.78,112.1) v2(127.78,111.1) v2(127.78,110.1) v2(127.78,109.1) v2(127.78,108.1) v2(127.78,107.1) v2(127.78,106.1) v2(127.78,105.1) v2(127.78,104.1) v2(127.78,103.1) v2(127.78,102.1) v2(127.78,101.1) v2(127.78,100.1) v2(127.78,99.1) v2(127.78,93.1) v2(127.78,88.1) v2(127.78,83.1) v2(127.84,63.66) v2(127.76,60.3) v2(128.08,141.73) v2(128.18,58.42) v2(128.37,127) v2(128.37,126.11) v2(128.65,117.6) v2(128.65,112.6) v2(128.65,111.6) v2(128.65,110.6) v2(128.65,109.6) v2(128.65,108.6) v2(128.65,107.6) v2(128.65,106.6) v2(128.65,105.6) v2(128.65,104.6) v2(128.65,103.6) v2(128.65,102.6) v2(128.65,101.6) v2(128.65,100.6) v2(128.65,99.6) v2(128.65,98.6) v2(128.65,97.6) v2(128.65,95.6) v2(128.65,92.6) v2(128.65,90.6) v2(128.65,89.6) v2(128.65,88.6) v2(128.65,87.6) v2(128.65,86.6) v2(128.65,85.6) v2(128.65,84.6) v2(128.65,83.6) v2(128.65,82.6) v2(128.65,81.6) v2(129.03,63.73) v2(129,51.1) v2(129.39,127) v2(129.39,126.11) v2(129.51,120.1) v2(129.51,115.1) v2(129.51,111.1) v2(129.51,109.1) v2(129.51,107.1) v2(129.51,105.1) v2(129.51,103.1) v2(129.51,101.1) v2(129.51,99.1) v2(129.51,97.1) v2(129.51,95.1) v2(129.51,93.1) v2(129.51,88.1) v2(129.51,83.1) v2(129.54,1.27) v2(129.64,54.67) v2(130.07,51.1) v2(130.38,121.6) v2(130.38,120.6) v2(130.38,119.6) v2(130.38,118.6) v2(130.38,117.6) v2(130.38,116.6) v2(130.38,115.6) v2(130.38,114.6) v2(130.38,113.6) v2(130.38,112.6) v2(130.38,111.6) v2(130.38,109.6) v2(130.38,107.6) v2(130.38,105.6) v2(130.38,103.6) v2(130.38,101.6) v2(130.38,99.6) v2(130.38,97.6) v2(130.38,95.6) v2(130.38,90.6) v2(130.38,85.6) v2(130.55,63.45) v2(130.66,8.51) v2(130.91,127) v2(130.91,126.11) v2(131.07,51.41) v2(131.25,120.1) v2(131.25,115.1) v2(131.25,112.1) v2(131.25,111.1) v2(131.25,110.1) v2(131.25,109.1) v2(131.25,108.1) v2(131.25,107.1) v2(131.25,106.1) v2(131.25,105.1) v2(131.25,104.1) v2(131.25,103.1) v2(131.25,102.1) v2(131.25,101.1) v2(131.25,100.1) v2(131.25,99.1) v2(131.25,98.1) v2(131.25,97.1) v2(131.25,96.1) v2(131.25,95.1) v2(131.25,94.1) v2(131.25,93.1) v2(131.25,91.1) v2(131.25,88.1) v2(131.25,83.1) v2(131.57,10.22) v2(131.93,127) v2(131.93,126.11) v2(132,41.35) v2(132.11,117.6) v2(132.11,112.6) v2(132.11,110.6) v2(132.11,108.6) v2(132.11,106.6) v2(132.11,104.6) v2(132.11,102.6) v2(132.11,100.6) v2(132.11,98.6) v2(132.11,96.6) v2(132.11,94.6) v2(132.11,91.6) v2(132.11,90.6) v2(132.11,85.6) v2(132.07,51.41) v2(132.08,1.27) v2(132.44,41.88) v2(132.59,10.22) v2(132.98,120.1) v2(132.98,115.1) v2(132.98,110.1) v2(132.98,108.1) v2(132.98,106.1) v2(132.98,104.1) v2(132.98,102.1) v2(132.98,100.1) v2(132.98,98.1) v2(132.98,96.1) v2(132.98,94.1) v2(132.98,93.1) v2(132.98,88.1) v2(132.98,83.1) v2(133.07,51.41) v2(133.45,127) v2(133.45,126.11) v2(133.58,8.51) v2(133.84,117.6) v2(133.84,112.6) v2(133.84,111.6) v2(133.84,110.6) v2(133.84,109.6) v2(133.84,108.6) v2(133.84,107.6) v2(133.84,106.6) v2(133.84,105.6) v2(133.84,104.6) v2(133.84,103.6) v2(133.84,102.6) v2(133.84,101.6) v2(133.84,100.6) v2(133.84,99.6) v2(133.84,98.6) v2(133.84,97.6) v2(133.84,96.6) v2(133.84,95.6) v2(133.84,94.6) v2(133.84,93.6) v2(133.84,90.6) v2(133.84,85.6) v2(134.07,51.41) v2(134.47,127) v2(134.47,126.11) v2(134.62,1.27) v2(134.71,122.1) v2(134.71,120.1) v2(134.71,115.1) v2(134.71,112.1) v2(134.71,111.1) v2(134.71,109.1) v2(134.71,107.1) v2(134.71,105.1) v2(134.71,103.1) v2(134.71,101.1) v2(134.71,99.1) v2(134.71,97.1) v2(134.71,95.1) v2(134.71,93.1) v2(134.71,90.1) v2(134.71,89.1) v2(134.71,88.1) v2(134.71,87.1) v2(134.71,86.1) v2(134.71,85.1) v2(134.71,84.1) v2(134.71,83.1) v2(134.71,82.1) v2(134.71,81.1) v2(135.07,51.41) v2(135.4,63.75) v2(135.57,121.6) v2(135.57,117.6) v2(135.57,112.6) v2(135.57,111.6) v2(135.57,109.6) v2(135.57,107.6) v2(135.57,105.6) v2(135.57,103.6) v2(135.57,101.6) v2(135.57,99.6) v2(135.57,97.6) v2(135.57,95.6) v2(135.57,93.6) v2(135.57,92.6) v2(135.57,90.6) v2(135.57,85.6) v2(135.57,81.6) v2(136.07,51.41) v2(136.3,209.14) v2(136.44,122.1) v2(136.44,121.1) v2(136.44,120.1) v2(136.44,119.1) v2(136.44,118.1) v2(136.44,117.1) v2(136.44,116.1) v2(136.44,115.1) v2(136.44,114.1) v2(136.44,113.1) v2(136.44,112.1) v2(136.44,111.1) v2(136.44,110.1) v2(136.44,109.1) v2(136.44,108.1) v2(136.44,107.1) v2(136.44,106.1) v2(136.44,105.1) v2(136.44,104.1) v2(136.44,103.1) v2(136.44,102.1) v2(136.44,101.1) v2(136.44,100.1) v2(136.44,99.1) v2(136.44,98.1) v2(136.44,97.1) v2(136.44,96.1) v2(136.44,95.1) v2(136.44,93.1) v2(136.44,88.1) v2(136.44,83.1) v2(136.44,82.1) v2(136.44,81.1) v2(137.07,51.41) v2(137.16,1.27) v2(137.31,121.6) v2(137.31,120.6) v2(137.31,117.6) v2(137.31,112.6) v2(137.31,110.6) v2(137.31,108.6) v2(137.31,106.6) v2(137.31,104.6) v2(137.31,102.6) v2(137.31,100.6) v2(137.31,98.6) v2(137.31,96.6) v2(137.31,94.6) v2(137.31,93.6) v2(137.31,90.6) v2(137.31,85.6) v2(137.31,82.6) v2(137.31,81.6) v2(137.91,51.41) v2(138.15,63.5) v2(138.17,121.1) v2(138.17,120.1) v2(138.17,115.1) v2(138.17,110.1) v2(138.17,108.1) v2(138.17,106.1) v2(138.17,104.1) v2(138.17,102.1) v2(138.17,100.1) v2(138.17,98.1) v2(138.17,96.1) v2(138.17,94.1) v2(138.17,93.1) v2(138.17,88.1) v2(138.17,83.1) v2(138.17,82.1) v2(138.72,51.41) v2(139.29,63.5) v2(139.57,51.41) v2(139.7,1.27) v2(140.52,144.1) v2(140.52,143.46) v2(140.55,142.85) v2(140.57,51.41) v2(141.43,144.12) v2(141.43,143.48) v2(141.39,77.47) v2(141.57,51.41) v2(141.7,63.63) v2(142.25,144.11) v2(142.25,143.48) v2(142.24,1.27) v2(142.27,142.87) v2(142.57,51.41) v2(142.66,110.71) v2(142.66,108.58) v2(142.66,105.87) v2(142.97,63.5) v2(143.17,110.71) v2(143.17,108.58) v2(143.17,105.87) v2(143.57,51.41) v2(143.68,110.71) v2(143.68,108.58) v2(143.68,105.87) v2(143.93,78.61) v2(144.12,63.5) v2(144.57,51.41) v2(144.65,47.17) v2(144.75,49.23) v2(144.78,1.27) v2(145.34,63.27) v2(145.64,108.01) v2(145.57,51.41) v2(146.57,51.41) v2(146.84,63.39) v2(146.91,108.01) v2(147.32,1.27) v2(147.57,51.41) v2(148.38,107.92) v2(148.41,51.41) v2(148.88,209.55) v2(149.22,51.41) v2(149.76,63.47) v2(149.86,1.27) v2(149.96,124.33) v2(149.96,123.32) v2(149.96,119.76) v2(149.96,118.74) v2(149.96,107.85) v2(150.07,51.41) v2(151.07,51.41) v2(151.31,63.47) v2(152.07,51.41) v2(152.2,208.28) v2(152.4,1.27) v2(153.07,51.41) v2(153.52,63.5) v2(154.07,51.41) v2(154.58,63.5) v2(154.58,41.71) v2(154.94,1.27) v2(155.07,51.41) v2(155.24,41.38) v2(155.55,63.5) v2(156.07,51.41) v2(156.69,136.02) v2(156.69,135) v2(157.37,208.28) v2(157.48,1.27) v2(158.85,146.75) v2(158.76,60.21) v2(159.87,146.75) v2(160.02,1.27) v2(161.9,129.03) v2(162.15,8.51) v2(162.15,5.33) v2(162.56,1.27) v2(164.27,100.78) v2(165.07,98.38) v2(165.07,94.38) v2(165.07,91.18) v2(165.1,1.27) v2(166.08,53.52) v2(166.05,52.32) v2(166.08,48.92) v2(166.08,47.9) v2(166.05,43.69) v2(166.05,42.67) v2(166.67,88.78) v2(167.47,96.78) v2(167.47,94.38) v2(167.47,91.18) v2(167.47,88.78) v2(167.47,87.98) v2(167.61,83.31) v2(167.61,82.55) v2(167.64,1.27) v2(168.27,99.98) v2(168.27,92.78) v2(168.5,83.31) v2(168.5,82.63) v2(169.07,89.58) v2(169.07,87.98) v2(169.65,83.26) v2(169.87,97.58) v2(170.18,1.27) v2(170.53,75.31) v2(170.67,99.98) v2(170.67,94.38) v2(171.15,82.63) v2(171.47,96.78) v2(171.47,93.58) v2(171.47,91.18) v2(171.62,58.72) v2(171.68,76.83) v2(172.16,82.88) v2(172.27,89.58) v2(172.69,76.83) v2(172.72,1.27) v2(173.02,83.13) v2(173.07,97.58) v2(173.48,82.7) v2(173.87,99.98) v2(173.87,95.98) v2(173.87,94.38) v2(173.87,90.38) v2(173.87,87.98) v2(174.09,76.83) v2(175.08,82.96) v2(175.11,76.83) v2(175.26,1.27) v2(175.47,91.98) v2(175.51,82.6) v2(176.38,23.37) v2(176.38,20.07) v2(177.07,97.58) v2(177.07,94.38) v2(177.07,89.58) v2(177.39,83.41) v2(177.42,82.68) v2(177.77,23.37) v2(177.77,20.07) v2(177.8,1.27) v2(177.87,100.78) v2(177.87,87.18) v2(178.15,83.41) v2(178.15,82.68) v2(180.34,1.27) v2(180.82,106.55) v2(180.81,105.81) v2(180.85,70.61) v2(181.46,106.17) v2(181.46,105.41) v2(181.46,48.08) v2(182.88,1.27) v2(182.98,48.08) v2(183.49,65.02) v2(184.33,177.65) v2(185.2,49.15) v2(185.42,1.27) v2(185.6,177.65) v2(186.87,177.65) v2(187.42,48.96) v2(187.71,121.08) v2(187.71,120.19) v2(187.71,119.3) v2(187.71,107.54) v2(187.71,106.65) v2(187.73,104.06) v2(187.73,103.19) v2(187.71,102.41) v2(187.71,95.63) v2(187.71,94.74) v2(187.71,93.85) v2(187.71,91.57) v2(187.71,90.68) v2(187.71,89.38) v2(187.71,88.39) v2(187.71,87.5) v2(187.71,85.22) v2(187.71,84.33) v2(187.71,83.19) v2(187.71,82.04) v2(187.71,81.15) v2(187.71,78.87) v2(187.71,77.99) v2(187.96,1.27) v2(188.14,177.65) v2(188.41,63.63) v2(189.41,177.65) v2(190.5,1.27) v2(190.68,177.65) v2(191.95,177.65) v2(193.04,1.27) v2(193.22,177.65) v2(195.36,57.02) v2(195.36,56.01) v2(195.58,1.27) v2(198.12,1.27) v2(200.66,1.27) v2(203.2,1.27) v2(205.74,1.27) v2(208.28,1.27) v2(210.82,1.27) v2(217.17,210.82) v2(217.17,208.28) v2(217.17,205.74) v2(217.17,203.2) v2(217.17,200.66) v2(217.17,198.12) v2(217.17,195.58) v2(217.17,193.04) v2(217.17,190.5) v2(217.17,187.96) v2(217.17,185.42) v2(217.17,182.88) v2(217.17,180.34) v2(217.17,177.8) v2(217.17,175.26) v2(217.17,172.72) v2(217.17,170.18) v2(217.17,167.64) v2(217.17,165.1) v2(217.17,162.56) v2(217.17,160.02) v2(217.17,157.48) v2(217.17,154.94) v2(217.17,152.4) v2(217.17,149.86) v2(217.17,147.32) v2(217.17,144.78) v2(217.17,142.24) v2(217.17,139.7) v2(217.17,137.16) v2(217.17,134.62) v2(217.17,132.08) v2(217.17,129.54) v2(217.17,127) v2(217.17,124.46) v2(217.17,121.92) v2(217.17,119.38) v2(217.17,116.84) v2(217.17,114.3) v2(217.17,111.76) v2(217.17,109.22) v2(217.17,106.68) v2(217.17,104.14) v2(217.17,101.6) v2(217.17,99.06) v2(217.17,96.52) v2(217.17,93.98) v2(217.17,91.44) v2(217.17,88.9) v2(217.17,86.36) v2(217.17,83.82) v2(217.17,81.28) v2(217.17,78.74) v2(217.17,76.2) v2(217.17,73.66) v2(217.17,71.12) v2(217.17,68.58) v2(217.17,66.04) v2(217.17,63.5) v2(217.17,60.96) v2(217.17,58.42) v2(217.17,55.88) v2(217.17,53.34) v2(217.17,50.8) v2(217.17,48.26) v2(217.17,45.72) v2(217.17,43.18) v2(217.17,40.64) v2(217.17,38.1) v2(217.17,35.56) v2(217.17,33.02) v2(217.17,30.48) v2(217.17,27.94) v2(217.17,25.4) v2(217.17,22.86) v2(217.17,20.32) v2(217.17,17.78) v2(217.17,15.24) v2(217.17,12.7) v2(217.17,10.16) v2(217.17,7.62) v2(217.17,2.54) v3(5.69,187.07) v3(5.69,185.93) v3(5.69,184.66) v3(5.69,183.51) v3(9.6,52.7) v3(9.62,51.84) v3(9.9,111.38) v3(9.95,110.51) v3(10.54,26.08) v3(10.51,24.87) v3(10.84,51.84) v3(10.87,52.68) v3(11.05,111.4) v3(11.12,110.49) v3(11.4,26.06) v3(11.35,24.87) v3(12.39,52.7) v3(12.42,51.84) v3(13.23,111.38) v3(13.33,142.45) v3(13.28,110.49) v3(13.64,51.84) v3(13.66,52.68) v3(14.04,112.57) v3(14.35,111.38) v3(14.4,110.49) v3(15.06,112.62) v3(16.74,111.15) v3(17.14,48.86) v3(17.88,111.51) v3(19,111.15) v3(19.35,45.48) v3(20.42,113.6) v3(20.88,45.42) v3(21.44,57.42) v3(21.69,53.09) v3(21.69,51.82) v3(21.69,50.67) v3(22.35,46.22) v3(22.64,47.09) v3(22.83,53.09) v3(22.83,51.82) v3(22.83,50.67) v3(23.62,22.67) v3(23.85,53.09) v3(23.85,50.67) v3(23.88,51.82) v3(24.64,57.42) v3(24.99,53.09) v3(24.99,51.82) v3(24.99,50.67) v3(25.34,47.09) v3(25.53,22.67) v3(25.7,57.42) v3(25.88,167.51) v3(26.13,53.09) v3(26.13,51.82) v3(26.13,50.67) v3(26.25,47.09) v3(26.77,22.67) v3(26.86,167.51) v3(27.84,166.88) v3(28.91,57.42) v3(28.89,47.09) v3(30.1,159.19) v3(31.53,17.53) v3(31.94,56.62) v3(31.94,55.02) v3(31.94,53.95) v3(31.94,52.35) v3(31.94,51.28) v3(31.94,49.68) v3(31.94,48.59) v3(31.94,46.99) v3(32.36,185.29) v3(34.06,89.08) v3(34.52,22.47) v3(34.67,88.49) v3(35.31,17.21) v3(35.94,22.47) v3(36.45,92.66) v3(36.37,88.98) v3(36.93,98.68) v3(37.06,96.14) v3(37.31,88.39) v3(37.74,92.38) v3(38.23,163.77) v3(38.35,91.79) v3(39.72,101.35) v3(39.72,99.19) v3(39.8,92.38) v3(40.01,163.77) v3(39.98,152.82) v3(40.03,48.72) v3(40.13,161.97) v3(40.06,85.93) v3(40.41,91.79) v3(41.63,53.09) v3(41.63,51.82) v3(41.63,50.67) v3(41.86,92.38) v3(42.47,91.79) v3(42.54,65.96) v3(42.52,65.07) v3(42.77,53.09) v3(42.77,51.82) v3(42.77,50.67) v3(43.03,55.75) v3(43.79,53.09) v3(43.81,51.82) v3(43.79,50.67) v3(44.33,107.75) v3(44.3,76.71) v3(44.3,74.55) v3(44.3,72.39) v3(44.3,70.23) v3(44.3,64.01) v3(44.5,65.96) v3(44.5,65.12) v3(44.93,53.09) v3(44.93,51.82) v3(44.93,50.67) v3(45.44,61.72) v3(45.78,108.91) v3(45.91,55.75) v3(46.14,67.75) v3(46.07,53.09) v3(46.07,51.82) v3(46.07,50.67) v3(46.55,110.87) v3(46.99,55.75) v3(47.47,109.66) v3(47.47,106.87) v3(47.98,60.96) v3(48.36,77.72) v3(48.61,167.31) v3(48.66,97.69) v3(49.12,171.27) v3(49.3,166.55) v3(49.4,113.35) v3(49.5,56.96) v3(49.66,104.33) v3(50.24,110.34) v3(50.32,193.5) v3(50.29,108.41) v3(50.26,101.22) v3(50.67,56.96) v3(50.77,91.19) v3(50.98,174.9) v3(51.23,173.86) v3(51.18,109.35) v3(51.15,88.39) v3(51.15,85.85) v3(51.15,77.72) v3(51.61,99.29) v3(51.56,95.76) v3(51.79,60.96) v3(51.92,174.93) v3(51.94,113.35) v3(51.94,56.96) v3(52.14,110.36) v3(52.09,108.41) v3(52.17,173.86) v3(52.2,104.97) v3(52.45,56.31) v3(53.02,160.02) v3(53.21,56.96) v3(53.31,190.12) v3(53.31,188.59) v3(53.64,99.29) v3(53.59,95.76) v3(53.95,77.72) v3(54.04,91.19) v3(54.46,86.65) v3(54.48,56.96) v3(54.67,93.22) v3(54.67,92.2) v3(55.47,86.65) v3(55.47,61.21) v3(55.63,95.76) v3(55.68,99.29) v3(55.75,56.96) v3(56.31,152.82) v3(57.98,188.72) v3(58.9,77.72) v3(61.56,91.29) v3(62.4,84.71) v3(63.35,96.52) v3(63.78,209.37) v3(63.78,208.76) v3(64.01,75.01) v3(63.98,74.12) v3(64.42,84.45) v3(64.57,209.35) v3(64.57,208.74) v3(65.12,98.37) v3(65.17,99.67) v3(65.21,86.49) v3(65.21,85.47) v3(65.38,104.14) v3(65.38,103) v3(65.54,80.82) v3(65.55,65.66) v3(65.76,75.01) v3(65.89,106.55) v3(65.89,105.54) v3(65.96,66.45) v3(66.19,99.69) v3(66.16,98.42) v3(66.93,209.4) v3(66.93,208.79) v3(67.01,66.42) v3(67.72,209.37) v3(67.89,87.96) v3(68.68,208.61) v3(68.81,117.35) v3(68.81,116.08) v3(68.81,114.55) v3(68.81,113.28) v3(69.09,170.64) v3(69.09,170) v3(69.11,167.59) v3(69.11,166.95) v3(69.65,216.69) v3(69.65,216.08) v3(69.7,117.35) v3(69.7,116.08) v3(69.7,114.55) v3(69.7,113.28) v3(69.72,47.24) v3(69.72,45.97) v3(69.72,44.7) v3(69.72,43.43) v3(70.21,167.79) v3(70.21,167.16) v3(70.36,170.92) v3(70.36,170.28) v3(70.48,216.71) v3(70.48,216.1) v3(70.99,125.22) v3(70.99,123.19) v3(70.99,121.16) v3(70.99,119.13) v3(71.17,217.02) v3(71.45,202.53) v3(73.08,171.42) v3(73.13,170.71) v3(73.12,86.51) v3(73.17,91.06) v3(73.17,88.8) v3(73.48,210.54) v3(73.48,209.52) v3(73.48,208.51) v3(73.48,207.49) v3(73.56,211.63) v3(73.56,206.3) v3(73.6,51.44) v3(73.84,171.42) v3(73.91,170.69) v3(74.21,91.06) v3(74.21,88.77) v3(74.21,86.49) v3(74.83,211.63) v3(74.75,210.54) v3(74.75,209.52) v3(74.75,208.51) v3(74.75,207.49) v3(74.83,206.3) v3(74.75,171.58) v3(74.85,170.84) v3(75.27,52.96) v3(75.51,171.58) v3(75.49,170.84) v3(76.02,210.54) v3(76.02,209.52) v3(76.02,208.51) v3(76.02,207.49) v3(76.05,95.38) v3(76.1,211.63) v3(76.1,206.3) v3(76.96,95.35) v3(78.54,196.01) v3(78.54,195.4) v3(78.59,125.6) v3(78.59,124.59) v3(78.59,123.32) v3(78.59,122.3) v3(78.59,121.03) v3(78.59,120.01) v3(78.59,118.74) v3(78.59,117.73) v3(78.59,116.46) v3(78.59,115.44) v3(78.59,114.17) v3(78.59,113.16) v3(78.81,93.12) v3(78.84,91.34) v3(78.81,89.58) v3(78.92,100.15) v3(78.92,95.12) v3(79.04,97.59) v3(79.14,101.85) v3(79.43,194.72) v3(79.65,82.52) v3(79.73,80.19) v3(79.83,93.12) v3(79.83,89.58) v3(79.78,77.67) v3(79.93,100.15) v3(79.88,97.56) v3(79.93,95.12) v3(79.86,91.34) v3(80.04,194.72) v3(80.16,101.85) v3(80.16,84.25) v3(80.29,85.75) v3(80.46,88.04) v3(80.49,87.02) v3(80.64,190.88) v3(80.67,82.52) v3(80.74,80.19) v3(80.79,77.67) v3(81.03,175.51) v3(81.03,174.75) v3(81.03,173.99) v3(81.03,170.69) v3(81.03,169.93) v3(81.03,169.16) v3(81.08,193.52) v3(81.18,84.25) v3(81.23,43.33) v3(81.23,42.57) v3(81.3,85.75) v3(81.33,49.89) v3(81.53,195.53) v3(81.48,88.04) v3(81.51,87.02) v3(81.69,193.52) v3(81.83,179.45) v3(81.83,178.69) v3(81.79,175.51) v3(81.79,174.75) v3(81.79,173.99) v3(81.79,170.69) v3(81.79,169.93) v3(81.79,169.16) v3(81.92,184.53) v3(81.92,183.77) v3(81.92,181.74) v3(81.92,180.97) v3(81.85,43.27) v3(81.96,42.57) v3(82.45,175.11) v3(82.45,174.35) v3(82.5,179.48) v3(82.5,178.71) v3(82.55,170.69) v3(82.55,169.93) v3(82.55,169.16) v3(82.68,184.53) v3(82.68,183.77) v3(82.68,181.74) v3(82.68,180.97) v3(83.22,43.25) v3(83.24,42.52) v3(83.64,195.88) v3(83.57,40.7) v3(83.67,195.1) v3(83.91,60.83) v3(84.15,30.31) v3(84.38,195.88) v3(84.38,195.07) v3(84.96,40.7) v3(85.09,195.86) v3(85.12,195.07) v3(85.09,127.38) v3(85.22,48.26) v3(85.22,47.5) v3(85.22,46.74) v3(85.19,30.29) v3(85.78,203.44) v3(85.75,195.86) v3(85.75,195.07) v3(85.77,73.94) v3(85.8,72.9) v3(85.85,205.87) v3(85.85,205.23) v3(85.85,204.6) v3(85.98,48.26) v3(85.98,47.5) v3(85.98,46.74) v3(86.18,35.94) v3(86.15,34.14) v3(86.49,205.87) v3(86.49,205.23) v3(86.49,204.6) v3(86.51,194.41) v3(86.59,195.68) v3(86.56,195.05) v3(86.79,73.94) v3(86.81,72.9) v3(86.98,35) v3(87.12,205.87) v3(87.12,205.23) v3(87.12,204.6) v3(87.09,66.04) v3(87.17,202.69) v3(87.25,195.66) v3(87.22,195.02) v3(87.17,194.39) v3(87.38,127.23) v3(87.73,203.12) v3(87.76,210.19) v3(87.81,35.84) v3(87.83,34.16) v3(88.04,195.88) v3(87.98,66.04) v3(88.01,30.29) v3(88.06,195.17) v3(88.67,195.88) v3(88.7,195.17) v3(88.77,210.19) v3(89.15,127.38) v3(89.28,30.29) v3(89.36,195.88) v3(89.38,195.17) v3(89.84,73.84) v3(89.81,72.82) v3(90.07,195.88) v3(90.09,195.17) v3(90.83,72.82) v3(90.85,73.84) v3(91.7,194.39) v3(91.82,216.79) v3(91.82,216.03) v3(91.82,215.26) v3(91.82,214.5) v3(91.9,193.47) v3(92.43,194.37) v3(92.46,216.79) v3(92.46,216.03) v3(92.46,215.26) v3(92.46,214.5) v3(92.84,193.48) v3(93.09,216.79) v3(93.09,216.03) v3(93.09,215.26) v3(93.09,214.5) v3(93.22,127.38) v3(93.4,194.21) v3(93.44,37.78) v3(93.55,48.01) v3(93.6,46.68) v3(93.6,45.29) v3(93.73,216.79) v3(93.73,216.03) v3(93.73,215.26) v3(93.73,214.5) v3(93.73,186.44) v3(94.32,194.2) v3(94.49,190.88) v3(95.13,194.39) v3(95.15,193.6) v3(95.37,45.29) v3(95.45,48.01) v3(95.5,46.68) v3(95.61,37.78) v3(95.74,201.29) v3(95.72,198.9) v3(95.73,197.92) v3(95.86,194.37) v3(95.89,193.58) v3(96.71,38.99) v3(96.71,37.85) v3(96.85,73.99) v3(97.03,213.23) v3(97.48,74.6) v3(97.74,195.38) v3(97.76,194.59) v3(97.92,159.77) v3(98.48,195.38) v3(98.48,194.56) v3(98.52,73.96) v3(98.93,205.87) v3(98.93,205.23) v3(98.93,204.6) v3(98.93,203.96) v3(99.11,74.57) v3(99.19,195.35) v3(99.21,194.56) v3(99.57,205.87) v3(99.57,205.23) v3(99.57,204.6) v3(99.57,203.96) v3(99.85,195.35) v3(99.85,194.56) v3(99.96,202.34) v3(100.2,205.87) v3(100.2,205.23) v3(100.2,204.6) v3(100.2,203.96) v3(100.18,125.98) v3(100.28,73.96) v3(100.61,193.9) v3(100.69,195.17) v3(100.66,194.54) v3(100.84,205.87) v3(100.84,205.23) v3(100.84,204.6) v3(100.84,203.96) v3(100.79,32.77) v3(100.91,74.57) v3(101.32,202.23) v3(101.35,195.15) v3(101.32,194.51) v3(101.27,193.88) v3(101.47,203.2) v3(101.83,202.62) v3(102.11,203.2) v3(102.13,195.38) v3(102.08,134.24) v3(102.08,133.35) v3(102.08,125.98) v3(102.16,194.67) v3(102.54,73.86) v3(102.52,37.72) v3(102.63,200.61) v3(102.77,195.38) v3(102.79,194.67) v3(103.17,74.47) v3(103.35,134.24) v3(103.35,133.35) v3(103.45,195.38) v3(103.48,194.67) v3(103.64,125.99) v3(104.17,195.38) v3(104.19,194.67) v3(104.87,134.24) v3(104.87,133.35) v3(105.19,125.99) v3(105.28,184.78) v3(105.28,184.02) v3(105.41,182.5) v3(105.41,181.74) v3(105.54,170.69) v3(105.54,169.93) v3(105.54,169.16) v3(105.89,194.34) v3(106.01,193.6) v3(106.05,184.78) v3(106.05,184.02) v3(106.1,179.37) v3(106.1,178.61) v3(106.1,175.06) v3(106.1,174.29) v3(106.14,134.24) v3(106.14,133.35) v3(106.17,182.5) v3(106.17,181.74) v3(106.3,170.69) v3(106.3,169.93) v3(106.3,169.16) v3(106.68,216.79) v3(106.68,216.03) v3(106.68,215.26) v3(106.68,214.5) v3(106.72,194.34) v3(106.78,179.4) v3(106.78,178.64) v3(106.85,193.6) v3(106.93,159.89) v3(106.86,125.78) v3(107.06,175.51) v3(107.06,174.75) v3(107.06,173.99) v3(107.06,170.69) v3(107.06,169.93) v3(107.06,169.16) v3(107.31,216.79) v3(107.31,216.03) v3(107.31,215.26) v3(107.31,214.5) v3(107.73,194.13) v3(107.95,216.79) v3(107.95,216.03) v3(107.95,215.26) v3(107.95,214.5) v3(108.33,175.51) v3(108.33,174.75) v3(108.33,173.99) v3(108.39,194.13) v3(108.46,190.88) v3(108.52,179.45) v3(108.52,178.69) v3(108.58,216.79) v3(108.58,216.03) v3(108.58,215.26) v3(108.58,214.5) v3(108.84,170.69) v3(108.84,169.93) v3(108.84,169.16) v3(109.09,175.51) v3(109.09,174.75) v3(109.09,173.99) v3(109.19,179.48) v3(109.19,178.71) v3(109.34,194.34) v3(109.35,184.78) v3(109.35,184.02) v3(109.51,201.29) v3(109.52,200.3) v3(109.6,170.69) v3(109.6,169.93) v3(109.6,169.16) v3(109.8,175.01) v3(109.8,174.24) v3(109.93,194.36) v3(110.11,184.78) v3(110.11,184.02) v3(110.36,170.69) v3(110.36,169.93) v3(110.36,169.16) v3(111.53,195.28) v3(111.56,194.49) v3(112.27,195.28) v3(112.27,194.46) v3(112.52,213.23) v3(112.8,49.81) v3(112.9,205.87) v3(112.9,205.23) v3(112.9,204.6) v3(112.9,203.96) v3(112.98,195.25) v3(113,194.46) v3(113.54,205.87) v3(113.54,205.23) v3(113.54,204.6) v3(113.54,203.96) v3(113.64,195.25) v3(113.64,194.46) v3(113.75,202.03) v3(114.17,205.87) v3(114.17,205.23) v3(114.17,204.6) v3(114.17,203.96) v3(114.3,157.29) v3(114.4,193.8) v3(114.48,195.07) v3(114.45,194.44) v3(114.81,205.87) v3(114.81,205.23) v3(114.81,204.6) v3(114.81,203.96) v3(115.14,195.05) v3(115.11,194.41) v3(115.06,193.78) v3(115.17,202.02) v3(115.19,157.29) v3(115.62,202.51) v3(115.93,195.28) v3(115.95,194.56) v3(116.2,203.07) v3(116.48,201.12) v3(116.56,195.28) v3(116.59,194.56) v3(117.12,38.15) v3(117.25,195.28) v3(117.25,39.55) v3(117.27,194.56) v3(117.96,195.28) v3(117.98,194.56) v3(118.59,39.52) v3(118.57,36.68) v3(119.63,216.79) v3(119.63,216.03) v3(119.63,215.26) v3(119.63,214.5) v3(119.63,194.36) v3(119.6,193.62) v3(119.91,38.13) v3(119.94,36.63) v3(120.19,39.62) v3(120.27,216.79) v3(120.27,216.03) v3(120.27,215.26) v3(120.27,214.5) v3(120.68,160.87) v3(120.9,216.79) v3(120.9,216.03) v3(120.9,215.26) v3(120.9,214.5) v3(120.95,194.11) v3(121.54,216.79) v3(121.54,216.03) v3(121.54,215.26) v3(121.54,214.5) v3(121.61,194.11) v3(122.05,190.88) v3(122.12,75.51) v3(122.12,74.65) v3(122.48,201.73) v3(122.48,201.02) v3(122.83,193.55) v3(122.91,160.9) v3(123.04,194.34) v3(123.14,199.39) v3(123.44,210.69) v3(123.98,160.9) v3(124,75.46) v3(124,74.6) v3(124.64,194.79) v3(124.66,194.01) v3(125.02,160.9) v3(125.37,194.79) v3(125.37,193.98) v3(125.83,75.44) v3(125.83,74.57) v3(125.87,202.03) v3(126.09,194.77) v3(126.11,193.98) v3(126.16,160.9) v3(126.36,205.87) v3(126.36,205.23) v3(126.36,204.6) v3(126.36,203.96) v3(126.49,213.23) v3(126.75,194.77) v3(126.75,193.98) v3(127,210.69) v3(127,205.87) v3(127,205.23) v3(127,204.6) v3(127,203.96) v3(127.36,203.2) v3(127.44,201.87) v3(127.51,193.32) v3(127.64,205.87) v3(127.64,205.23) v3(127.64,204.6) v3(127.64,203.96) v3(127.58,194.59) v3(127.56,193.95) v3(127.61,75.46) v3(127.61,74.6) v3(127.89,202.36) v3(128.24,194.56) v3(128.22,193.93) v3(128.17,193.29) v3(128.4,142.9) v3(128.65,160.9) v3(128.72,65.35) v3(129.03,194.79) v3(129.06,194.08) v3(129.33,203.68) v3(129.34,202.75) v3(129.33,201.37) v3(129.34,200.44) v3(129.67,194.79) v3(129.69,194.08) v3(130.05,210.69) v3(130.35,194.79) v3(130.38,194.08) v3(130.56,216.92) v3(130.56,216.15) v3(130.56,215.39) v3(130.56,214.63) v3(131.06,194.79) v3(131.09,194.08) v3(131.19,216.92) v3(131.19,216.15) v3(131.19,215.39) v3(131.19,214.63) v3(131.83,216.92) v3(131.83,216.15) v3(131.83,215.39) v3(131.83,214.63) v3(131.82,74.37) v3(131.82,73.48) v3(132.13,198.65) v3(132.33,185.04) v3(132.33,184.28) v3(132.33,181.99) v3(132.33,181.23) v3(132.46,216.92) v3(132.46,216.15) v3(132.46,215.39) v3(132.46,214.63) v3(132.46,63.86) v3(132.59,170.69) v3(132.59,169.93) v3(132.59,169.16) v3(132.83,194.16) v3(132.89,74.37) v3(132.89,73.48) v3(132.96,193.42) v3(133.1,185.04) v3(133.1,184.28) v3(133.1,181.99) v3(133.1,181.23) v3(133.15,175.13) v3(133.15,174.37) v3(133.35,179.35) v3(133.35,178.59) v3(133.35,170.69) v3(133.35,169.93) v3(133.35,169.16) v3(133.48,213.23) v3(133.67,194.16) v3(133.66,63.86) v3(133.8,193.42) v3(134.04,179.37) v3(134.04,178.61) v3(134.11,175.51) v3(134.11,174.75) v3(134.11,173.99) v3(134.11,170.69) v3(134.11,169.93) v3(134.11,169.16) v3(134.08,135) v3(134.08,134.11) v3(134.34,34.36) v3(134.43,155.57) v3(134.43,154.31) v3(134.43,153.03) v3(134.43,151.76) v3(134.43,150.5) v3(134.43,147.45) v3(134.43,146.3) v3(134.43,145.03) v3(134.43,143.76) v3(134.43,142.49) v3(134.46,193.93) v3(134.59,148.87) v3(134.85,157.23) v3(134.85,140.84) v3(134.86,206.07) v3(134.86,204.75) v3(134.86,203.5) v3(135.3,193.93) v3(135.35,135) v3(135.35,134.11) v3(136.25,126.11) v3(136.88,135) v3(136.88,134.11) v3(137.54,201.73) v3(137.84,75.11) v3(137.87,74.24) v3(138.15,135) v3(138.15,134.11) v3(138.15,126.11) v3(140.34,199.49) v3(140.97,199.49) v3(141.99,201.73) v3(142.95,199.44) v3(143.59,199.44) v3(144.24,125.35) v3(144.24,124.33) v3(144.24,123.04) v3(144.24,122.05) v3(144.24,120.78) v3(144.24,119.76) v3(144.17,117.5) v3(144.27,118.52) v3(144.5,206.88) v3(144.72,142.11) v3(145.11,116.08) v3(145.95,206.98) v3(145.92,151.13) v3(145.92,150.37) v3(145.97,209.6) v3(146.43,201.73) v3(146.69,151.13) v3(146.69,150.37) v3(146.99,208.91) v3(146.99,207.9) v3(146.96,207.01) v3(146.96,205.99) v3(147.04,116.1) v3(147.16,33.09) v3(147.45,151.13) v3(147.45,150.37) v3(147.93,124.84) v3(147.93,122.55) v3(147.93,120.27) v3(147.93,117.98) v3(149.07,116.08) v3(149.13,30.95) v3(149.42,199.52) v3(149.48,198.63) v3(149.48,127.2) v3(149.63,147.6) v3(149.63,146.84) v3(149.63,146.08) v3(149.68,92.56) v3(150.16,92.08) v3(150.27,127.18) v3(150.28,29.5) v3(150.37,202.44) v3(150.37,201.68) v3(150.37,198.63) v3(150.39,147.6) v3(150.39,146.84) v3(150.39,146.08) v3(150.5,200.79) v3(150.56,134.62) v3(150.56,133.35) v3(150.56,132.08) v3(151.1,116.1) v3(151.26,202.44) v3(151.26,201.68) v3(151.26,200.91) v3(151.26,198.63) v3(151.99,31.69) v3(151.99,28.76) v3(152.55,127.25) v3(152.65,97.66) v3(153.29,201.68) v3(153.39,127.71) v3(153.83,204.47) v3(153.8,36.33) v3(154.21,137.16) v3(154.43,27.06) v3(154.48,93.32) v3(154.79,206.95) v3(154.85,205.49) v3(154.91,32.26) v3(154.91,31.37) v3(154.91,30.35) v3(155.09,92.74) v3(155.57,201.74) v3(155.8,32.26) v3(155.83,31.32) v3(155.8,30.35) v3(155.88,125.37) v3(156.49,125.02) v3(156.46,35.45) v3(156.59,27.06) v3(156.82,124.33) v3(156.82,123.32) v3(156.82,122.05) v3(156.82,121.03) v3(156.82,119.76) v3(156.82,118.74) v3(156.82,32.26) v3(156.82,31.37) v3(156.82,30.35) v3(157.54,148.21) v3(159.32,207.26) v3(159.48,137.03) v3(159.77,201.73) v3(160.08,99.95) v3(160.08,98.68) v3(160.08,97.41) v3(160.18,31.75) v3(160.18,30.73) v3(160.58,95.3) v3(162.28,30.1) v3(162.31,27.15) v3(162.41,35.05) v3(162.41,32.26) v3(162.56,95.3) v3(162.88,208.53) v3(163.25,75.01) v3(163.68,134.11) v3(163.93,73.33) v3(163.93,72.36) v3(164.25,34.29) v3(164.25,33.02) v3(164.25,29.21) v3(164.25,27.94) v3(164.85,74.27) v3(164.8,73.38) v3(165.07,136.91) v3(165.1,135.51) v3(165.07,134.11) v3(165.77,74.42) v3(166.47,136.91) v3(166.47,135.76) v3(167.74,139.95) v3(168.66,201.73) v3(169.24,117.27) v3(169.39,56.83) v3(169.39,54.67) v3(169.49,208.41) v3(170.05,112.83) v3(170.05,111.86) v3(170.05,110.97) v3(170.72,137.03) v3(170.94,117.3) v3(170.94,111.89) v3(170.94,111.02) v3(170.96,112.83) v3(171.83,52.13) v3(171.9,112.83) v3(171.9,111.91) v3(171.9,111.05) v3(172.12,201.07) v3(172.12,200.05) v3(172.2,196.62) v3(172.21,43.78) v3(173.14,201.07) v3(173.14,200.05) v3(173.21,196.62) v3(173.78,60.81) v3(173.84,54.1) v3(174.67,67.26) v3(174.85,60.81) v3(174.85,54.1) v3(175.03,49.3) v3(175.03,48.31) v3(174.98,45.01) v3(175.36,177.49) v3(175.54,67.26) v3(175.56,65.27) v3(175.7,113.28) v3(175.7,110.74) v3(175.93,46.99) v3(176.02,45.01) v3(176.16,71.35) v3(176.22,50.47) v3(176.63,177.49) v3(176.75,65.3) v3(177.16,50.47) v3(177.44,44.91) v3(177.44,43.99) v3(177.47,190.57) v3(177.45,72.77) v3(177.77,65.28) v3(178.28,46.61) v3(178.53,67.94) v3(178.53,67.06) v3(178.53,41.85) v3(178.74,190.57) v3(178.81,71.27) v3(178.94,208.53) v3(178.94,206.38) v3(179.3,132.88) v3(179.27,131.99) v3(179.27,131.15) v3(180.04,208.41) v3(180.01,207.59) v3(180.01,205.71) v3(180.01,190.57) v3(180.01,59.64) v3(180.01,58.47) v3(180.01,57.3) v3(180.01,56.13) v3(180.01,54.97) v3(180.01,53.8) v3(180.01,52.63) v3(180.13,132.82) v3(180.11,131.09) v3(180.34,131.7) v3(180.64,205.71) v3(180.64,204.7) v3(180.67,208.41) v3(180.69,65.28) v3(180.85,171.32) v3(180.85,170.56) v3(181.24,207.65) v3(181.24,206.63) v3(181.18,59.64) v3(181.18,58.47) v3(181.18,57.3) v3(181.18,56.13) v3(181.18,54.97) v3(181.18,53.8) v3(181.18,52.63) v3(181.28,205.71) v3(181.28,190.57) v3(181.43,208.41) v3(182.19,208.41) v3(182.35,59.64) v3(182.35,58.47) v3(182.35,57.3) v3(182.35,56.13) v3(182.35,54.97) v3(182.35,53.8) v3(182.35,52.63) v3(183.51,59.64) v3(183.51,58.47) v3(183.51,57.3) v3(183.51,56.13) v3(183.51,54.97) v3(183.51,53.8) v3(183.51,52.63) v3(184.12,64.01) v3(184.3,197.71) v3(184.33,190.22) v3(184.68,194.97) v3(184.68,193.95) v3(184.68,59.64) v3(184.68,58.47) v3(184.68,57.3) v3(184.68,56.13) v3(184.68,54.97) v3(184.68,53.8) v3(184.68,52.63) v3(184.76,64.64) v3(185.32,194.97) v3(185.32,193.95) v3(185.6,190.22) v3(185.65,64.9) v3(185.85,59.64) v3(185.85,58.47) v3(185.85,57.3) v3(185.85,56.13) v3(185.85,54.97) v3(185.85,53.8) v3(185.85,52.63) v3(185.95,194.97) v3(185.95,193.95) v3(186.51,67.84) v3(186.87,190.22) v3(187.02,59.64) v3(187.02,58.47) v3(187.02,57.3) v3(187.02,56.13) v3(187.02,54.97) v3(187.02,53.8) v3(187.02,52.63) v3(187.37,67.84) v3(187.58,211.52) v3(187.55,65.28) v3(187.71,173.74) v3(187.71,172.97) v3(187.71,172.21) v3(188.14,190.22) v3(188.35,71.48) v3(188.47,173.74) v3(188.47,172.97) v3(188.47,172.21) v3(189.23,173.74) v3(189.23,172.97) v3(189.23,172.21) v3(189.41,190.22) v3(189.43,132) v3(189.4,131.29) v3(189.39,130.59) v3(189.99,173.74) v3(189.99,172.97) v3(189.99,172.21) v3(189.99,134.18) v3(190.22,47.75) v3(190.22,46.74) v3(190.17,45.47) v3(190.17,44.4) v3(190.47,8.25) v3(190.47,6.48) v3(190.6,19.18) v3(190.6,16.51) v3(190.68,190.22) v3(190.75,173.74) v3(190.75,172.97) v3(190.75,172.21) v3(190.88,211.52) v3(191.23,13.33) v3(191.34,132.08) v3(191.53,71.48) v3(191.49,17.91) v3(191.94,7.37) v3(191.95,190.22) v3(192.06,43.05) v3(192.38,19.18) v3(192.38,16.51) v3(192.5,67.97) v3(193.04,133.35) v3(193.12,198.63) v3(193.14,197.92) v3(193.22,190.22) v3(193.27,8.13) v3(193.27,6.48) v3(193.37,67.97) v3(193.84,199.25) v3(193.92,198.54) v3(194.94,62.81) v3(194.92,52.45) v3(194.97,60.63) v3(195.45,69.06) v3(195.45,68.2) v3(195.58,27.35) v3(195.93,52.45) v3(195.96,62.81) v3(195.98,60.63) v3(196.82,27.35) v3(198.37,25.72) v3(198.56,27.3) v3(199.01,67.24) v3(199.01,64.2) v3(199.01,59.25) v3(199.01,55.18) v3(199.01,51.12) v3(199.64,25.72) v3(203.96,15.06) v3(204.57,18.6) v3(204.95,6.35) v3(205.08,7.24) v3(205.46,5.59) v3(205.97,6.35) v3(206.09,7.24) v3(213.04,24.89) v3(213.04,22.35) v3(213.04,17.53) v3(213.04,16.26) v3(213.04,14.99) v4(8.51,31.88) v4(8.57,30.35) v4(8.64,28.96) v4(9.53,30.35) v4(10.41,31.75) v4(10.37,30.31) v4(10.41,28.96) v4(12.95,152.95) v4(12.95,151.8) v4(14.15,153.12) v4(14.15,151.98) v4(15.6,150.28) v4(15.6,149.14) v4(15.72,32.09) v4(15.72,30.95) v4(15.72,29.71) v4(15.72,28.56) v4(16.87,32.14) v4(16.87,31) v4(16.92,29.88) v4(16.92,28.74) v4(19.33,153.67) v4(19.33,152.23) v4(19.33,150.88) v4(20.22,152.15) v4(21.11,153.67) v4(21.15,152.14) v4(21.11,150.88) v4(26.04,28.7) v4(25.97,27.3) v4(26.04,25.91) v4(26.92,27.3) v4(27.81,28.7) v4(27.77,27.26) v4(27.81,25.91) v4(31.22,140.84) v4(31.19,139.85) v4(33.12,29.04) v4(33.12,27.9) v4(33.22,26.56) v4(33.22,25.41) v4(34.26,29.1) v4(34.26,27.95) v4(34.42,26.73) v4(34.42,25.59) v4(43.24,29.46) v4(43.28,30.84) v4(43.28,28.04) v4(44.17,29.44) v4(45.04,29.42) v4(45.06,30.84) v4(45.06,28.04) v4(50.39,31.2) v4(50.39,30.06) v4(50.62,28.84) v4(50.62,27.7) v4(51.54,31.25) v4(51.54,30.11) v4(51.82,29.02) v4(51.82,27.88) v4(78.09,12.65) v4(78.09,11.43) v4(78.87,19.74) v4(78.87,17.86) v4(78.98,12.7) v4(79.24,11.43) v4(80.02,12.55) v4(80.31,19.75) v4(80.26,18.75) v4(80.27,17.95) v4(80.91,12.6) v4(80.96,11.46) v4(81.76,19.76) v4(81.76,17.88) v4(82.11,11.46) v4(97.68,12.55) v4(97.73,11.4) v4(98.58,12.62) v4(98.89,11.25) v4(98.98,19.41) v4(98.98,17.53) v4(99.61,12.34) v4(100.04,11.25) v4(100.38,18.41) v4(100.41,17.65) v4(100.45,19.45) v4(100.75,12.34) v4(101.1,11.46) v4(101.88,19.43) v4(101.88,17.55) v4(122.54,13.23) v4(122.59,12.19) v4(123.55,13.23) v4(123.6,12.19) v4(123.57,11.15) v4(123.75,19.3) v4(123.75,17.42) v4(124.52,12.29) v4(124.64,11.1) v4(125.15,18.31) v4(125.19,19.32) v4(125.15,17.52) v4(125.67,12.29) v4(126.64,19.33) v4(126.64,17.45) v4(126.94,12.6) v4(138.2,166.6) v4(138.25,165.63) v4(138.94,166.04) v4(139.62,165.4) v4(139.7,166.65) v4(141.15,166.47) v4(141.17,165.53) v4(142.65,166.62) v4(142.67,165.38) v4(142.93,185.57) v4(142.93,184.56) v4(143.03,191.34) v4(143.03,190.32) v4(143.03,188.42) v4(143.03,187.4) v4(143.38,166.07) v4(143.69,185.57) v4(143.69,184.56) v4(143.79,191.34) v4(143.79,190.32) v4(143.79,188.42) v4(143.79,187.4) v4(144.15,166.67) v4(144.07,165.43) v4(145.68,12.67) v4(145.68,11.56) v4(145.8,166.4) v4(145.82,165.46) v4(146.82,12.67) v4(146.82,11.56) v4(146.96,19.35) v4(146.96,17.48) v4(147.7,166.57) v4(147.73,165.33) v4(147.71,12.17) v4(148.29,11.05) v4(148.43,19.37) v4(148.36,18.36) v4(148.39,17.57) v4(148.49,166.14) v4(148.86,12.17) v4(149.12,165.38) v4(149.2,166.62) v4(149.38,186.33) v4(149.38,185.06) v4(149.38,183.79) v4(149.38,182.52) v4(149.86,19.38) v4(149.86,17.5) v4(150.18,12.6) v4(150.65,188.87) v4(150.65,186.33) v4(150.65,185.06) v4(150.65,183.79) v4(150.65,182.52) v4(150.95,165.48) v4(151.18,166.19) v4(151.92,187.6) v4(151.92,186.33) v4(151.92,185.06) v4(151.92,183.79) v4(151.92,182.52) v4(151.92,166.57) v4(152.65,101.47) v4(152.81,165.33) v4(152.78,100.84) v4(153.19,187.6) v4(153.19,186.33) v4(153.19,185.06) v4(153.19,183.79) v4(153.19,182.52) v4(153.16,166.42) v4(153.64,102.6) v4(154.2,165.38) v4(154.28,166.62) v4(154.46,183.79) v4(154.46,182.52) v4(154.46,181.25) v4(154.46,179.98) v4(155.73,183.79) v4(155.73,182.52) v4(155.73,181.25) v4(155.73,179.98) v4(156.03,166.47) v4(156.06,165.53) v4(157,183.79) v4(157,182.52) v4(157,181.25) v4(157,179.98) v4(157.94,166.6) v4(157.96,165.35) v4(158.27,183.79) v4(158.27,182.52) v4(158.67,166.04) v4(159.44,166.65) v4(159.36,165.4) v4(159.54,187.6) v4(159.54,186.33) v4(159.54,185.06) v4(159.54,183.79) v4(159.54,182.52) v4(160.3,93.29) v4(160.59,166.53) v4(160.81,188.87) v4(160.81,187.6) v4(160.81,186.33) v4(160.81,185.06) v4(160.81,183.79) v4(160.81,182.52) v4(161.14,165.38) v4(162.08,188.87) v4(162.08,186.33) v4(162.08,185.06) v4(162.08,183.79) v4(162.08,182.52) v4(162.38,166.5) v4(162.56,93.3) v4(163.02,165.38) v4(163.35,186.33) v4(163.35,185.06) v4(163.35,183.79) v4(163.35,182.52) v4(163.53,166.49) v4(163.68,105.41) v4(164.41,165.43) v4(164.49,166.67) v4(164.49,104.52) v4(165.32,166.42) v4(166.14,166.4) v4(166.17,165.46) v4(167.41,104.44) v4(168.02,166.62) v4(168.05,165.38) v4(168.53,187.25) v4(168.53,186.23) v4(168.53,184.45) v4(168.53,183.44) v4(168.76,166.07) v4(169.29,187.25) v4(169.29,186.23) v4(169.29,184.45) v4(169.29,183.44) v4(169.44,165.43) v4(169.52,166.67) v4(170.51,184.38) v4(170.54,183.46) v4(170.51,104.47) v4(170.64,187.3) v4(170.61,105.41) v4(170.66,186.39) v4(171.17,166.34) v4(171.2,165.4) v4(171.7,183.44) v4(171.7,182.68) v4(171.86,184.25) v4(172.54,183.49) v4(172.54,182.73) v4(172.59,184.28) v4(173.33,183.54) v4(173.33,182.78) v4(173.41,184.3) v4(173.45,105.41) v4(173.48,104.47) v4(174.12,183.57) v4(174.12,182.8) v4(174.17,184.3) v4(177.9,105.41) v4(177.9,104.39) v4(187.11,194.49) v4(187.13,193.22) v4(188.57,201.47) v4(188.57,200.03) v4(188.59,198.73) v4(189.38,201.45) v4(189.38,200) v4(189.51,198.78) v4(189.92,203.87) v4(189.92,202.68) v4(190.96,200.08) v4(191.19,203.9) v4(191.19,202.7) v4(191.26,201.36) v4(191.36,131.06) v4(192.43,203.92) v4(192.43,202.73) v4(192.48,200.08) v4(192.53,131.04) v4(192.76,118.21) v4(192.99,132.36) v4(193.66,118.24) v4(194.18,133.46) v4(194.16,132.33) v4(194.59,215.11) v4(194.59,214.22) v4(194.59,213.36) v4(195.22,152.04) v4(195.22,151.16) v4(195.22,150.29) v4(195.43,215.14) v4(195.43,214.25) v4(195.43,213.39) v4(196.06,152.07) v4(196.06,151.18) v4(196.06,150.32) v4(196.34,134.65) v4(196.34,133.38) v4(196.34,132.11) v4(196.34,130.84) v4(196.37,215.09) v4(196.37,214.2) v4(196.37,213.33) v4(196.41,116.59) v4(197,152.02) v4(197,151.13) v4(197,150.27) v4(197.23,215.09) v4(197.23,214.2) v4(197.23,213.33) v4(197.5,184) v4(197.55,182.47) v4(197.52,116.61) v4(197.61,137.19) v4(197.61,134.65) v4(197.61,133.38) v4(197.61,132.11) v4(197.61,130.84) v4(197.74,200.15) v4(197.74,198.88) v4(197.74,197.61) v4(197.74,196.34) v4(197.82,150.29) v4(197.87,152.02) v4(197.87,151.13) v4(198.41,184) v4(198.4,116.55) v4(198.42,115.43) v4(198.67,182.5) v4(198.81,147.42) v4(198.88,148.23) v4(198.88,135.92) v4(198.88,134.65) v4(198.88,133.38) v4(198.88,132.11) v4(198.88,130.84) v4(199.01,202.69) v4(199.01,200.15) v4(199.01,198.88) v4(199.01,197.61) v4(199.01,196.34) v4(199.03,144.93) v4(199.03,143.79) v4(199.34,166.75) v4(199.45,213.13) v4(199.8,209.91) v4(200.08,213.66) v4(200.08,212.52) v4(200.15,135.92) v4(200.15,134.65) v4(200.15,133.38) v4(200.15,132.11) v4(200.15,130.84) v4(200.28,201.42) v4(200.28,200.15) v4(200.28,198.88) v4(200.28,197.61) v4(200.28,196.34) v4(200.43,210.44) v4(200.43,209.3) v4(200.61,166.75) v4(201.42,132.11) v4(201.42,130.84) v4(201.42,129.57) v4(201.42,128.3) v4(201.55,201.42) v4(201.55,200.15) v4(201.55,198.88) v4(201.55,197.61) v4(201.55,196.34) v4(201.88,173.1) v4(201.88,169.29) v4(201.88,168.02) v4(201.88,166.75) v4(201.88,165.48) v4(201.88,159.13) v4(202.68,185.55) v4(202.68,184.61) v4(202.69,132.11) v4(202.69,130.84) v4(202.69,129.57) v4(202.69,128.3) v4(202.82,197.61) v4(202.82,196.34) v4(202.82,195.07) v4(202.82,193.8) v4(202.9,157.14) v4(202.91,156.04) v4(202.9,154.22) v4(202.91,153.12) v4(203.03,179.11) v4(203.03,178.01) v4(203.03,176.19) v4(203.03,175.09) v4(203.15,173.1) v4(203.15,171.83) v4(203.15,170.56) v4(203.15,161.67) v4(203.15,160.4) v4(203.15,159.13) v4(203.68,185.5) v4(203.76,184.63) v4(203.96,132.11) v4(203.96,130.84) v4(203.96,129.57) v4(204.09,197.61) v4(204.09,196.34) v4(204.09,195.07) v4(204.09,193.8) v4(204.37,181.17) v4(204.37,180.13) v4(204.42,179.11) v4(204.42,173.1) v4(204.42,171.83) v4(204.42,170.56) v4(204.42,161.67) v4(204.42,160.4) v4(204.42,159.13) v4(204.42,157.14) v4(204.43,156.04) v4(204.42,154.22) v4(204.43,153.12) v4(204.55,176.19) v4(204.56,175.09) v4(205.23,132.11) v4(205.23,130.84) v4(205.36,197.61) v4(205.36,196.34) v4(205.36,195.07) v4(205.36,193.8) v4(205.47,181.17) v4(205.47,180.13) v4(205.53,179.13) v4(205.69,173.1) v4(205.69,171.83) v4(205.69,170.56) v4(205.69,162.94) v4(205.69,161.67) v4(205.69,160.4) v4(205.69,159.13) v4(206.5,135.92) v4(206.5,134.65) v4(206.5,133.38) v4(206.5,132.11) v4(206.5,130.84) v4(206.63,197.61) v4(206.63,196.34) v4(206.96,179.11) v4(206.97,178.01) v4(206.96,176.19) v4(206.97,175.09) v4(206.96,173.1) v4(206.96,171.83) v4(206.96,161.67) v4(206.96,160.4) v4(206.96,159.13) v4(206.96,157.01) v4(206.97,155.91) v4(206.96,154.22) v4(206.97,153.12) v4(206.96,151.42) v4(206.97,150.32) v4(207.62,148.39) v4(207.62,147.24) v4(207.62,145.72) v4(207.62,144.58) v4(207.62,142.67) v4(207.62,141.53) v4(207.7,139.9) v4(207.72,138.89) v4(207.77,137.19) v4(207.77,135.92) v4(207.77,134.65) v4(207.77,133.38) v4(207.77,132.11) v4(207.77,130.84) v4(207.9,201.42) v4(207.9,200.15) v4(207.9,198.88) v4(207.9,197.61) v4(207.9,196.34) v4(208.23,179.11) v4(208.24,178.01) v4(208.23,176.19) v4(208.24,175.09) v4(208.23,171.83) v4(208.23,160.4) v4(208.25,147.86) v4(208.36,157.01) v4(208.37,155.91) v4(208.36,154.22) v4(208.37,153.12) v4(208.36,151.29) v4(208.37,150.19) v4(208.51,211.15) v4(208.51,210.26) v4(209.04,208.13) v4(209.04,207.24) v4(209.04,137.19) v4(209.04,134.65) v4(209.04,133.38) v4(209.04,132.11) v4(209.04,130.84) v4(209.12,205.28) v4(209.12,204.39) v4(209.17,202.69) v4(209.17,201.42) v4(209.17,200.15) v4(209.17,198.88) v4(209.17,197.61) v4(209.17,196.34) v4(209.32,148.42) v4(209.33,147.3) v4(209.37,145.7) v4(209.38,144.58) v4(209.42,142.75) v4(209.45,141.27) v4(209.45,140.39) v4(209.5,173.1) v4(209.5,171.83) v4(209.5,170.56) v4(209.5,169.29) v4(209.5,162.94) v4(209.5,161.67) v4(209.5,160.4) v4(209.5,159.13) v4(210.31,134.65) v4(210.31,133.38) v4(210.31,132.11) v4(210.31,130.84) v4(210.44,202.69) v4(210.44,200.15) v4(210.44,198.88) v4(210.44,197.61) v4(210.44,196.34) v4(210.82,209.14) v4(210.82,208.25) v4(210.85,206.78) v4(210.85,205.89) v4(210.77,168.02) v4(210.77,166.75) v4(210.77,165.48) v4(210.77,164.21) v4(211.71,200.15) v4(211.71,198.88) v4(211.71,197.61) v4(211.71,196.34) v4(211.81,181.91) v4(211.81,115.39) v4(211.91,116.76) v4(212.83,142.42) v4(212.88,181.97) v4(212.85,143.59) v4(212.88,141.12) v4(212.86,139.95) v4(212.88,115.44) v4(212.98,116.81) v4(213.34,133.37) v4(213.39,135.84) v4(213.36,134.54) v4(213.72,202.74) v4(213.67,201.47) v4(213.72,200.03) v4(213.69,198.85) v4(213.66,132.3) v4(213.68,131.31) v4(214.33,143.54) v4(214.3,142.36) v4(214.33,139.9) v4(214.35,141.07) v4(214.61,180.94) v4(214.74,182.3) v4(214.74,179.9) v4(214.83,134.49) v4(214.81,133.32) v4(214.78,132.32) v4(214.8,131.33) v4(214.94,202.74) v4(214.89,201.47) v4(214.94,200.03) v4(214.91,198.85) v4(214.86,135.79) v4(215.05,196.8) v4(215.06,115.34) v4(215.16,116.71) v4(215.71,180.95) v4(215.84,179.9) v4(215.86,182.27) v4(215.89,132.39) v4(215.91,131.27) v4(216.03,199.03) v4(216.13,115.39) v4(216.23,116.76) v4(216.26,202.67) v4(216.26,201.45) v4(216.35,196.84) v4(216.89,182.14) v5(13.94,216.53) v5(13.94,213.99) v5(16.48,216.53) v5(16.48,213.99) v5(19.02,216.53) v5(19.02,213.99) v5(20.32,188.93) v5(20.38,186.07) v5(21.56,216.53) v5(21.56,213.99) v5(22.35,188.56) v5(22.28,186.08) v5(24.1,216.53) v5(24.1,213.99) v5(24.1,186.05) v5(24.85,188.62) v5(26.64,216.53) v5(26.64,213.99) v5(26.64,186.05) v5(27.06,189.09) v5(29.18,216.53) v5(29.18,213.99) v5(31.72,216.53) v5(31.72,213.99) v5(34.26,216.53) v5(34.26,213.99) v5(36.8,216.53) v5(36.8,213.99) v5(38.71,185.42) v5(39.24,190.52) v5(41.45,190.6) v5(43.48,190.6) v5(43.76,193.04) v5(45.08,189.71) v5(47.42,189.74) v5(51.41,216.53) v5(51.41,213.99) v5(53.95,216.53) v5(53.95,213.99) v5(54.74,191.9) v5(56.39,193.04) v5(59.05,216.41) v5(59.05,214.12) v5(59.69,187.96) v5(59.94,190.12) v5(61.59,216.41) v5(61.59,214.12) v5(61.59,211.58) v5(61.59,209.04) v5(61.59,206.5) v5(61.59,203.96) v5(61.59,201.42) v5(62.23,193.22) v5(62.2,190.5) v5(62.2,187.96) v5(63.25,210.62) v5(63.7,214.35) v5(63.7,212.29) v5(63.93,216.46) v5(64.59,193.14) v5(64.74,190.5) v5(64.74,187.96) v5(65.15,210.87) v5(65.28,215.01) v5(65.74,212.75) v5(65.99,216.51) v5(66.7,214.1) v5(68.33,216.56) v5(189.84,20.95) v5(189.84,14.99) v5(189.84,10.79) v5(189.84,3.81) v5(192.38,20.95) v5(192.38,14.99) v5(192.38,10.79) v5(192.38,3.81) v5(204.44,3.17) v5(207.62,5.08) v5(207.62,3.17) v6(29.86,123.34) v6(29.86,119.34) v6(30.15,124.04) v6(30.15,122.63) v6(30.15,120.04) v6(30.15,118.63) v6(30.86,124.34) v6(30.86,122.34) v6(30.86,120.34) v6(30.86,118.34) v6(31.56,124.04) v6(31.56,122.63) v6(31.56,120.04) v6(31.56,118.63) v6(34.15,124.04) v6(34.15,122.63) v6(34.15,120.04) v6(34.15,118.63) v6(34.86,124.34) v6(34.86,122.34) v6(34.86,120.34) v6(34.86,118.34) v6(35.56,124.04) v6(35.56,122.63) v6(35.56,120.04) v6(35.56,118.63) v6(35.86,123.34) v6(35.86,119.34) v6(37.86,123.34) v6(37.86,119.34) v6(38.15,124.04) v6(38.15,122.63) v6(38.15,120.04) v6(38.15,118.63) v6(38.86,124.34) v6(38.86,122.34) v6(38.86,120.34) v6(38.86,118.34) v6(39.56,124.04) v6(39.56,122.63) v6(39.56,120.04) v6(39.56,118.63) v6(42.15,124.04) v6(42.15,122.63) v6(42.15,120.04) v6(42.15,118.63) v6(42.86,124.34) v6(42.86,122.34) v6(42.86,120.34) v6(42.86,118.34) v6(43.56,124.04) v6(43.56,122.63) v6(43.56,120.04) v6(43.56,118.63) v6(43.86,123.34) v6(43.86,119.34) v6(45.86,123.34) v6(45.86,119.34) v6(46.15,124.04) v6(46.15,122.63) v6(46.15,120.04) v6(46.15,118.63) v6(46.86,124.34) v6(46.86,122.34) v6(46.86,120.34) v6(46.86,118.34) v6(47.56,124.04) v6(47.56,122.63) v6(47.56,120.04) v6(47.56,118.63) v6(50.15,124.04) v6(50.15,122.63) v6(50.15,120.04) v6(50.15,118.63) v6(50.86,124.34) v6(50.86,122.34) v6(50.86,120.34) v6(50.86,118.34) v6(51.56,124.04) v6(51.56,122.63) v6(51.56,120.04) v6(51.56,118.63) v6(51.86,123.34) v6(51.86,119.34) v6(53.86,123.34) v6(53.86,119.34) v6(54.15,124.04) v6(54.15,122.63) v6(54.15,120.04) v6(54.15,118.63) v6(54.86,124.34) v6(54.86,122.34) v6(54.86,120.34) v6(54.86,118.34) v6(55.56,124.04) v6(55.56,122.63) v6(55.56,120.04) v6(55.56,118.63) v6(58.15,124.04) v6(58.15,122.63) v6(58.15,120.04) v6(58.15,118.63) v6(58.86,124.34) v6(58.86,122.34) v6(58.86,120.34) v6(58.86,118.34) v6(59.56,124.04) v6(59.56,122.63) v6(59.56,120.04) v6(59.56,118.63) v6(59.86,123.34) v6(59.86,119.34)
