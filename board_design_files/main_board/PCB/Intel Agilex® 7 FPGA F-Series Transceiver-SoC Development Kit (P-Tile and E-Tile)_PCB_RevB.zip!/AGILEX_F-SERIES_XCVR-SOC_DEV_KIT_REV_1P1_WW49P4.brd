# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_DBIN0: length 34
  TOP w0.137: U3.E7 v2(86.94,144.12)
  ART07 w0.135: v2(86.94,144.12) 87.48,143.58 87.48,139.85 87.34,139.71 86.8,139.71 86.66,139.58 86.66,139.25 86.8,139.12 87.34,139.12 87.48,138.98 87.48,138.66 87.34,138.53 86.8,138.53 86.66,138.39 86.66,138.07 86.8,137.94 87.34,137.94 87.48,137.8 87.48,137.48 87.34,137.34 86.8,137.34 86.66,137.21 86.66,136.89 86.8,136.75 87.34,136.75 87.48,136.62 87.48,136.29 87.34,136.16 86.8,136.16 86.66,136.03 86.66,135.7 86.8,135.57 87.34,135.57 87.48,135.43 87.48,135.11 87.34,134.98 86.8,134.98 86.66,134.84 86.66,134.52 86.8,134.38 87.34,134.38 87.48,134.25 87.48,129.03 88.52,127.99 89.46,127.99 89.76,127.68 89.76,123.82 90.98,122.6 90.98,120.04 v2(90.54,119.6)
DDR4_COMP_DBIN1: length 28.8
  TOP w0.137: U3.E2 v2(90.94,144.12)
  ART05 w0.135: v2(90.54,121.6) 90.54,121.18 91.05,120.67 91.67,120.67 91.87,120.88 91.87,123.54 90.52,124.89 90.52,131.47 90,131.99 90,133.13 88.82,134.31 88.82,143.43 89.1,143.71 90.54,143.71 v2(90.94,144.12)
DDR4_COMP_DBIN2: length 34.6
  TOP w0.137: U4.E7 v2(98.37,144.12)
  ART07 w0.135: v2(96.6,119.1) 97.03,119.52 97.03,131.8 96.87,131.96 96.5,131.96 96.37,132.09 96.37,132.41 96.5,132.55 96.87,132.55 97,132.68 97,133.01 96.87,133.14 96.5,133.14 96.37,133.28 96.37,133.6 96.5,133.73 96.87,133.73 97,133.87 97,134.19 96.87,134.32 96.5,134.32 96.37,134.46 96.37,134.78 96.5,134.92 96.87,134.92 97,135.05 97,135.37 96.87,135.51 96.5,135.51 96.37,135.64 96.37,136.17 96.5,136.31 97.4,136.31 97.53,136.44 97.53,136.76 97.4,136.9 96.5,136.9 96.37,137.03 96.37,137.35 96.5,137.49 97.4,137.49 97.53,137.62 97.53,137.95 97.4,138.08 96.5,138.08 96.37,138.22 96.37,139.04 96.57,139.24 96.76,139.24 96.89,139.12 97.08,139.12 97.31,139.34 97.31,139.53 97.18,139.66 97.18,139.85 97.99,140.66 97.99,143.74 v2(98.37,144.12)
DDR4_COMP_DBIN3: length 30.7
  TOP w0.137: U4.E2 v2(102.37,144.12)
  ART05 w0.135: v2(96.6,122.1) 96.6,121.83 96.16,121.39 96.16,120.88 96.47,120.57 96.7,120.57 97.13,120.14 97.69,120.14 97.88,120.34 97.88,137.84 99.57,139.52 99.57,143 100.28,143.71 101.97,143.71 v2(102.37,144.12)
DDR4_COMP_DBIN4: length 43.7
  TOP w0.137: U5.E7 v2(109.8,144.12)
  ART07 w0.135: v2(102.67,114.6) 103.12,115.06 103.12,126.24 108.02,131.14 108.02,132.64 107.34,133.32 107.34,133.6 107.47,133.73 108.4,133.73 108.53,133.87 108.53,134.19 108.4,134.33 107.47,134.33 107.34,134.46 107.34,134.78 107.47,134.92 108.4,134.92 108.53,135.05 108.53,135.38 108.4,135.51 107.47,135.51 107.34,135.64 107.34,135.97 107.47,136.1 108.4,136.1 108.53,136.24 108.53,136.56 108.4,136.69 107.47,136.69 107.34,136.83 107.34,137.15 107.47,137.29 108.4,137.29 108.53,137.42 108.53,137.74 108.4,137.88 107.47,137.88 107.34,138.01 107.34,138.58 108.04,139.29 108.23,139.29 108.8,138.71 109,138.71 109.22,138.94 109.22,139.13 108.65,139.7 108.65,139.9 109.41,140.65 109.41,143.72 v2(109.8,144.12)
DDR4_COMP_DBIN5: length 41.8
  TOP w0.137: U5.E2 v2(113.8,144.12)
  ART05 w0.135: v2(113.8,144.12) 113.26,143.71 107.18,143.71 106.81,143.4 106.28,142.66 106.05,142.18 105.44,140.66 104.89,139.94 102.36,137.41 101.59,134.63 101.59,129.35 100.73,128.5 100.73,123.9 100.48,123.65 100.48,119.81 100.25,119.58 99.97,119.58 99.67,119.28 99.67,115.86 99.88,115.65 100.76,115.19 101.16,115.19 101.96,115.68 102.37,116.09 102.37,116.3 v2(102.67,116.6)
DDR4_COMP_DBIN6: length 54.5
  TOP w0.137: U6.E7 v2(121.23,144.12)
  ART07 w0.135: v2(121.23,144.12) 121.64,143.71 121.64,135.64 120.18,134.17 118.35,134.17 117.23,133.06 117.23,132.87 117.91,132.2 117.91,132.01 117.68,131.78 117.49,131.78 116.82,132.45 116.63,132.45 116.4,132.22 116.4,132.03 117.13,131.3 117.13,131.11 116.91,130.88 116.72,130.88 115.98,131.61 115.79,131.61 115.56,131.39 115.56,131.2 116.3,130.46 116.3,130.27 116.07,130.04 115.88,130.04 115.14,130.78 114.95,130.78 114.72,130.55 114.72,130.36 115.46,129.62 115.46,129.43 115.23,129.2 115.04,129.2 114.3,129.94 114.11,129.94 113.89,129.71 113.89,129.52 114.62,128.79 114.62,128.59 114.4,128.37 114.2,128.37 113.47,129.1 113.28,129.1 113.05,128.88 113.05,128.68 113.79,127.95 113.79,127.76 113.56,127.53 113.37,127.53 112.63,128.27 112.44,128.27 112.21,128.04 112.21,127.85 112.95,127.11 112.95,126.92 112.72,126.69 112.53,126.69 111.79,127.43 111.6,127.43 111.33,127.15 111.33,126.67 112.39,125.6 112.39,125.14 112.01,124.76 111.55,124.76 110.06,123.27 110.06,115.39 109.73,115.06 109.4,115.06 108.73,114.39 v2(108.73,114.1)
DDR4_COMP_DBIN7: length 41.9
  TOP w0.137: U6.E2 v2(125.23,144.12)
  ART05 w0.135: v2(108.73,117.1) 108.73,116.43 109.08,115.48 109.47,115.09 109.69,115.09 arc(109.88,115.01) 110.03,114.85 110.03,114.85 arc(110.21,114.67) 110.46,114.6 110.46,114.6 arc(110.71,114.67) 110.89,114.85 110.9,114.85 arc(111.08,115.03) 111.33,115.1 arc(111.57,115.17) 111.76,115.35 111.76,115.35 arc(111.94,115.53) 112.19,115.6 arc(112.44,115.67) 112.62,115.85 112.63,115.85 arc(112.81,116.03) 113.06,116.1 113.06,116.1 arc(113.31,116.17) 113.49,116.35 113.49,116.35 arc(113.68,116.53) 113.92,116.6 113.93,116.6 arc(114.18,116.67) 114.36,116.85 114.36,117.89 116.11,119.64 116.82,121.65 117.7,122.53 117.7,126.19 118.03,126.52 118.56,126.52 118.84,126.8 118.84,127.13 123.95,132.23 123.95,133.17 126.44,135.66 126.44,143.51 126.24,143.71 125.86,143.71 v2(125.23,144.12)
DDR4_COMP_DBIN8: length 65.5
  TOP w0.137: U7.E7 v2(75.51,144.12)
  ART07 w0.135: v2(90.54,114.6) 90.45,114.7 89.46,114.7 89.16,114.4 89.07,114.25 arc(88.92,114.1) 88.71,114.05 88.47,114.05 88.23,113.8 arc(88.04,113.67) 87.81,113.62 87.35,113.16 86.84,113.16 86.46,113.54 86.21,113.54 85.57,114.17 83.41,114.17 79.37,118.21 77.95,118.21 77.57,118.59 77.57,121.67 76.43,122.81 75.41,122.81 74.7,123.52 74.7,124.47 74.56,124.61 74.15,124.61 74.01,124.74 74.01,125.06 74.15,125.2 74.56,125.2 74.7,125.33 74.7,125.66 74.56,125.79 74.15,125.79 74.01,125.93 74.01,126.25 74.15,126.38 74.56,126.38 74.7,126.52 74.7,126.92 74.24,127.38 74,127.38 73.33,126.7 73.14,126.7 72.91,126.93 72.91,127.12 73.61,127.82 73.61,128.01 73.41,128.21 73.22,128.21 72.37,127.36 72.17,127.36 71.95,127.59 71.95,127.78 72.8,128.63 72.8,128.82 72.57,129.05 72.38,129.05 71.53,128.2 71.34,128.2 71.11,128.43 71.11,128.62 71.96,129.47 71.96,129.66 71.73,129.89 71.54,129.89 70.69,129.04 70.5,129.04 70.27,129.27 70.27,129.46 71.12,130.31 71.12,130.5 70.9,130.73 70.71,130.73 69.85,129.87 69.66,129.87 69.44,130.1 69.44,130.29 70.29,131.14 70.29,131.33 69.36,132.26 69.36,141.07 72.79,144.5 75.13,144.5 v2(75.51,144.12)
DDR4_COMP_DQ0: length 35.4
  TOP w0.137: U3.G2 v2(90.94,145.72)
  ART07 w0.114: v2(92.28,119.6) arc(92.3,119.78) 92.37,119.96 92.63,120.4 arc(92.68,120.6) 92.63,120.8 92.62,120.81 arc(92.55,121.1) 92.63,121.4 arc(92.68,121.6) 92.63,121.8 arc(92.56,121.97) 92.55,122.14 arc(92.55,122.35) 92.52,122.55
  ART07 w0.135: v2(90.94,145.72) 90.52,145.3 90.52,136.26 90.39,136.12 89.74,136.12 89.61,135.99 89.61,135.67 89.74,135.53 90.39,135.53 90.52,135.4 90.52,135.07 90.39,134.94 89.74,134.94 89.61,134.81 89.61,134.48 89.74,134.35 90.39,134.35 90.52,134.21 90.52,133.89 90.39,133.76 89.74,133.76 89.61,133.62 89.61,133.3 89.74,133.16 90.39,133.16 90.52,133.03 90.52,132.71 90.39,132.57 89.74,132.57 89.61,132.44 89.61,132.12 89.74,131.98 90.39,131.98 90.52,131.85 90.52,131.52 90.39,131.39 89.74,131.39 89.61,131.25 89.61,130.93 89.74,130.8 90.39,130.8 90.52,130.66 90.52,129.36 91.67,128.22 91.67,124.31 92.43,123.54 92.43,122.63 92.52,122.55
DDR4_COMP_DQ1: length 34.7
  TOP w0.137: U3.F7 v2(86.94,144.92)
  ART07 w0.135: v2(86.94,144.92) 86.55,144.53 85.87,144.53 85.75,144.4 85.75,133.75 85.88,133.62 86.68,133.62 86.81,133.48 86.81,133.16 86.68,133.03 85.88,133.03 85.75,132.89 85.75,132.57 85.88,132.43 86.68,132.43 86.81,132.3 86.81,131.98 86.68,131.84 85.88,131.84 85.75,131.71 85.75,131.39 85.88,131.25 86.68,131.25 86.81,131.12 86.81,130.79 86.68,130.66 85.88,130.66 85.75,130.52 85.75,129.82 88.39,127.18 88.39,124.59 90.14,122.83 90.14,119.56 v2(89.68,119.1)
DDR4_COMP_DQ2: length 36.7
  TOP w0.137: U3.H3 v2(89.33,146.52)
  ART07 w0.114: 93.49,122.98 93.49,122.3 arc(93.55,122.1) 93.49,121.9 arc(93.41,121.6) 93.49,121.3 arc(93.55,121.1) 93.49,120.9 arc(93.41,120.6) 93.49,120.31 93.49,120.3 arc(93.55,120.1) 93.49,119.9 93.24,119.46 arc(93.17,119.28) v2(93.14,119.1)
  ART07 w0.135: v2(89.33,146.52) 89.74,146.11 90.3,146.11 90.51,146.33 90.51,146.62 90.83,146.94 92.05,146.94 92.81,146.18 92.81,140.74 91.82,139.75 91.82,136.24 91.95,136.11 92.57,136.11 92.71,135.98 92.71,135.65 92.57,135.52 91.95,135.52 91.82,135.38 91.82,135.06 91.95,134.93 92.57,134.93 92.71,134.79 92.71,134.47 92.57,134.33 91.95,134.33 91.82,134.2 91.82,133.88 91.95,133.74 92.57,133.74 92.71,133.61 92.71,124.71 93.36,124.07 93.36,123.12 93.49,122.98
DDR4_COMP_DQ3: length 35.1
  TOP w0.137: U3.H7 v2(86.94,146.52)
  ART07 w0.135: v2(89.68,118.1) 89.68,118.45 89.25,118.87 89.25,122.58 87.88,123.95 87.88,125.83 85.21,128.5 85.21,133.99 85.08,134.13 84.74,134.13 84.6,134.26 84.6,134.59 84.74,134.72 85.08,134.72 85.21,134.86 85.21,135.18 85.08,135.31 84.74,135.31 84.6,135.45 84.6,135.77 84.74,135.9 85.08,135.9 85.21,136.04 85.21,136.36 85.08,136.5 84.74,136.5 84.6,136.63 84.6,136.95 84.74,137.09 85.08,137.09 85.21,137.22 85.21,139.78 84.92,140.06 84.92,145.06 85.15,145.29 85.55,145.29 85.72,145.46 85.72,145.95 85.87,146.1 86.52,146.1 v2(86.94,146.52)
DDR4_COMP_DQ4: length 35
  TOP w0.137: U3.H2 v2(90.94,146.52)
  ART07 w0.114: v2(92.28,118.6) 92.54,118.86 arc(92.56,118.89) 92.57,118.91 92.85,119.59 arc(92.86,119.64) 92.86,119.7 arc(92.84,119.8) 92.79,119.9 arc(92.74,120.1) 92.79,120.3 arc(92.87,120.6) 92.79,120.9 arc(92.74,121.1) 92.79,121.3 arc(92.87,121.6) 92.79,121.89 92.79,121.9 arc(92.74,122.1) 92.79,122.3 arc(92.85,122.45) 92.87,122.6 92.87,122.62
  ART07 w0.135: 92.87,122.62 92.87,123.74 92.2,124.41 92.2,128.37 91.44,129.13 91.44,129.89 91.57,130.02 92.17,130.02 92.3,130.16 92.3,130.48 92.17,130.61 91.57,130.61 91.44,130.75 91.44,131.07 91.57,131.21 92.17,131.21 92.3,131.34 92.3,131.66 92.17,131.8 91.57,131.8 91.44,131.93 91.44,132.26 91.57,132.39 92.17,132.39 92.3,132.52 92.3,132.85 92.17,132.98 91.57,132.98 91.44,133.12 91.44,139.88 92.3,140.74 92.3,145.86 92.04,146.12 91.34,146.12 v2(90.94,146.52)
DDR4_COMP_DQ5: length 33.5
  TOP w0.137: U3.H8 v2(85.33,146.52)
  ART07 w0.135: v2(88.81,119.6) 88.36,120.05 88.36,122.3 86.23,124.43 86.23,126.97 84.12,129.08 84.12,129.88 84.26,130.02 84.7,130.02 84.83,130.15 84.83,130.48 84.7,130.61 84.26,130.61 84.12,130.75 84.12,131.07 84.26,131.2 84.7,131.2 84.83,131.34 84.83,131.66 84.7,131.79 84.26,131.79 84.12,131.93 84.12,132.25 84.26,132.39 84.7,132.39 84.83,132.52 84.83,132.84 84.7,132.98 84.26,132.98 84.12,133.11 84.12,145.11 84.33,145.31 84.71,145.31 84.96,145.56 84.96,145.85 84.96,145.85 84.96,145.9 85.29,146.22 85.29,146.26 85.33,146.31 v2(85.33,146.52)
DDR4_COMP_DQ6: length 36.4
  TOP w0.137: U3.J3 v2(89.33,147.32)
  ART07 w0.114: v2(93.14,118.1) 93.14,118.16 arc(93.15,118.22) 93.18,118.27 93.56,118.64 arc(93.74,119) 93.66,119.4 arc(93.6,119.6) 93.66,119.8 arc(93.74,120.1) 93.66,120.4 arc(93.6,120.6) 93.66,120.8 arc(93.74,121.1) 93.66,121.39 93.66,121.4 arc(93.6,121.6) 93.66,121.8 arc(93.72,121.95) 93.74,122.1 93.74,122.59 93.83,122.68
  ART07 w0.135: v2(89.33,147.32) 89.33,147.16 89.58,146.91 90.31,146.91 90.53,147.13 90.53,147.51 90.71,147.69 92.05,147.69 93.29,146.46 93.29,137.75 93.06,137.51 92.51,137.51 92.3,137.3 92.3,137.06 92.44,136.92 93.06,136.92 93.19,136.79 93.19,128.45 93.98,127.66 93.98,122.83 93.83,122.68
DDR4_COMP_DQ7: length 34.2
  TOP w0.137: U3.J7 v2(86.94,147.32)
  ART07 w0.135: v2(86.94,147.32) 86.54,146.91 85.16,146.91 84.96,146.71 84.96,146.35 84.75,146.14 84.3,146.14 83.72,145.56 83.2,144.44 83.2,143.93 83.72,142.39 83.72,127.96 85.67,126.01 85.67,123.7 87.54,121.83 87.54,119.85 87.88,119.51 88.24,119.51 88.81,118.93 v2(88.81,118.6)
DDR4_COMP_DQ8: length 29.9
  TOP w0.137: U3.A3 v2(89.33,140.92)
  ART05 w0.135: v2(92.28,121.6) 92.17,121.7 92.17,124.36 91.77,124.76 91.77,127.61 91.44,127.94 91.08,127.94 90.98,128.04 90.98,128.41 91.11,128.55 91.71,128.55 91.84,128.68 91.84,128.96 91.71,129.09 91.11,129.09 90.98,129.22 90.98,129.5 91.11,129.63 91.71,129.63 91.84,129.77 91.84,130.04 91.71,130.17 91.11,130.17 90.98,130.31 90.98,130.58 91.11,130.71 91.71,130.71 91.84,130.85 91.84,131.12 91.71,131.25 91.11,131.25 90.98,131.39 90.98,131.89 91.11,132.02 91.71,132.02 91.84,132.16 91.84,132.43 91.71,132.56 90.61,132.56 90.47,132.7 90.47,132.97 90.61,133.1 91.71,133.1 91.84,133.24 91.84,133.51 91.71,133.65 90.23,133.65 89.33,134.54 v2(89.33,140.92)
DDR4_COMP_DQ9: length 27.3
  TOP w0.137: U3.B8 v2(85.33,141.72)
  ART05 w0.135: v2(88.81,120.6) 89.24,121.03 89.24,121.91 89.18,121.97 89.18,122.77 86.46,125.49 86.46,128.57 86.15,128.88 86.15,134.01 85.21,134.95 85.21,138.01 85.08,138.15 84.31,138.15 84.17,138.28 84.17,138.55 84.31,138.69 85.08,138.69 85.21,138.82 85.21,139.1 85.08,139.23 84.31,139.23 84.17,139.37 84.17,139.64 84.31,139.77 85.08,139.77 85.21,139.91 85.21,140.26 84.94,140.53 84.94,141.32 v2(85.33,141.72)
DDR4_COMP_DQ10: length 30.1
  TOP w0.137: U3.C3 v2(89.33,142.52)
  ART05 w0.135: v2(89.33,142.52) 89.76,142.09 89.76,137.15 89.9,137.02 90.31,137.02 90.45,136.88 90.45,136.61 90.31,136.48 89.9,136.48 89.76,136.34 89.76,135.79 89.99,135.56 92.09,135.56 92.22,135.42 92.22,135.02 92.09,134.88 90.35,134.88 90.22,134.75 90.22,134.47 90.35,134.34 92.09,134.34 92.22,134.21 92.22,124.84 92.53,124.54 92.53,122.05 92.71,121.87 92.71,121.03 92.28,120.6 v2(92.28,120.6)
DDR4_COMP_DQ11: length 27.2
  TOP w0.137: U3.C7 v2(86.94,142.52)
  ART05 w0.135: v2(86.94,142.52) 86.53,142.1 86.53,140.67 87.09,140.11 87.09,139.82 86.96,139.68 86.21,139.68 86.08,139.55 86.08,139.28 86.21,139.14 86.96,139.14 87.09,139.01 87.09,138.73 86.96,138.6 86.21,138.6 86.08,138.47 86.08,138.19 86.21,138.06 86.96,138.06 87.09,137.92 87.09,130.15 88.57,128.67 88.57,124.89 90.08,123.38 90.08,121.5 v2(89.68,121.1)
DDR4_COMP_DQ12: length 29.9
  TOP w0.137: U3.C2 v2(90.94,142.52)
  ART05 w0.135: v2(90.94,142.52) 91.33,142.13 91.33,140.62 91.69,140.26 93.16,140.26 93.34,140.08 93.34,139.67 93.21,139.54 92.36,139.54 92.22,139.4 92.22,139.16 92.38,139 93.21,139 93.34,138.86 93.34,138.59 93.21,138.45 92.36,138.45 92.22,138.32 92.22,138.07 92.38,137.91 93.21,137.91 93.34,137.78 93.34,137.51 93.21,137.37 92.36,137.37 92.22,137.24 92.22,136.99 92.36,136.86 93.06,136.86 93.24,136.68 93.24,128.32 93.72,127.84 93.72,122.07 93.14,121.49 v2(93.14,121.1)
DDR4_COMP_DQ13: length 26.8
  TOP w0.137: U3.C8 v2(85.33,142.52)
  ART05 w0.135: v2(88.81,121.6) 88.63,121.6 88.49,121.73 88.49,122.79 85.75,125.54 85.75,133.65 83.69,135.71 83.69,136.62 83.83,136.76 84.7,136.76 84.83,136.89 84.83,137.16 84.7,137.3 83.83,137.3 83.69,137.43 83.69,141.58 84.23,142.11 84.93,142.11 v2(85.33,142.52)
DDR4_COMP_DQ14: length 29.6
  TOP w0.137: U3.D3 v2(89.33,143.32)
  ART05 w0.135: v2(89.33,143.32) 89.75,142.9 90.35,142.9 90.53,142.72 90.53,140.66 90.93,140.26 90.93,139.85 90.79,139.71 90.25,139.71 90.12,139.58 90.12,139.31 90.25,139.17 91.53,139.17 91.67,139.04 91.67,138.76 91.53,138.63 90.25,138.63 90.12,138.49 90.12,138.22 90.25,138.09 90.79,138.09 90.93,137.95 90.93,137.67 91.06,137.54 91.48,137.54 91.62,137.4 91.62,137.13 91.48,137 91.06,137 90.93,136.86 90.93,136.32 91.21,136.04 92.53,136.04 92.66,135.91 92.66,124.99 93.14,124.51 v2(93.14,122.1)
DDR4_COMP_DQ15: length 27.1
  TOP w0.137: U3.D7 v2(86.94,143.32)
  ART05 w0.135: v2(86.94,143.32) 86.93,143.32 86.54,142.93 85.93,142.93 85.72,142.72 85.72,137.48 85.86,137.34 86.45,137.34 86.59,137.21 86.59,136.94 86.45,136.8 85.96,136.8 85.83,136.67 85.83,136.39 85.96,136.26 86.45,136.26 86.59,136.13 86.59,135.85 86.45,135.72 85.96,135.72 85.83,135.58 85.83,135.21 85.96,135.08 86.55,135.08 86.69,134.94 86.69,129.52 88.11,128.09 88.11,124.63 89.68,123.06 v2(89.68,122.1)
DDR4_COMP_DQ16: length 36.2
  TOP w0.137: U4.G2 v2(102.37,145.72)
  ART07 w0.114: 98.69,122.52 98.69,122.3 arc(98.74,122.1) 98.69,121.9 arc(98.61,121.6) 98.69,121.3 arc(98.74,121.1) 98.69,120.9 arc(98.61,120.6) 98.69,120.31 98.69,120.3 arc(98.74,120.1) 98.69,119.9 98.43,119.46 arc(98.36,119.28) v2(98.34,119.1)
  ART07 w0.135: v2(102.37,145.72) 101.95,145.3 101.95,144.7 101.78,144.53 100.3,144.53 99.95,144.17 99.95,138.15 98.75,136.96 98.75,135.05 98.4,134.7 98.4,134.26 98.53,134.13 99.91,134.13 100.05,133.99 100.05,133.67 99.91,133.54 98.53,133.54 98.4,133.4 98.4,133.08 98.53,132.94 99.91,132.94 100.05,132.81 100.05,132.49 99.91,132.35 98.53,132.35 98.4,132.22 98.4,131.75 98.53,131.62 98.54,131.62 98.67,131.49 98.67,131.16 98.54,131.03 98.53,131.03 98.4,130.89 98.4,122.81 98.69,122.52
DDR4_COMP_DQ17: length 32.7
  TOP w0.137: U4.F7 v2(98.37,144.92)
  ART07 w0.135: v2(98.37,144.92) 98.01,144.55 97.38,144.55 97.15,144.32 97.15,140.49 95.96,139.29 95.96,131.3 96.09,131.16 96.51,131.16 96.64,131.03 96.64,130.7 96.51,130.57 96.14,130.57 96.01,130.44 96.01,130.11 96.14,129.98 96.51,129.98 96.64,129.84 96.64,129.52 96.51,129.39 96.14,129.39 96.01,129.25 96.01,128.93 96.14,128.79 96.51,128.79 96.64,128.66 96.64,128.34 96.51,128.2 96.14,128.2 96.01,128.07 96.01,127.75 96.14,127.61 96.51,127.61 96.64,127.48 96.64,127.15 96.51,127.02 96.14,127.02 96.01,126.88 96.01,126.39 96.59,125.81 96.59,123.04 96.14,122.58 96.14,119 v2(95.74,118.6)
DDR4_COMP_DQ18: length 36.3
  TOP w0.137: U4.H3 v2(100.76,146.52)
  ART07 w0.135: v2(99.2,119.6) 99.67,120.06 99.67,122.05 99.41,122.3 99.41,123.67 99.13,123.95 99.13,130.3 99.39,130.56 99.58,130.56 99.8,130.34 99.99,130.34 100.22,130.57 100.22,130.76 100,130.98 100,131.17 101.11,132.28 101.11,137.69 101.76,138.33 101.76,138.53 101.17,139.11 101.17,139.3 101.4,139.53 101.59,139.53 102.18,138.94 102.52,138.94 104.06,140.49 104.06,146.35 103.5,146.91 101.16,146.91 v2(100.76,146.52)
DDR4_COMP_DQ19: length 32.7
  TOP w0.137: U4.H7 v2(98.37,146.52)
  ART07 w0.135: v2(95.74,119.6) 95.32,120.02 95.32,121.92 95.47,122.06 95.47,123.49 95.6,123.62 96.13,123.62 96.26,123.75 96.26,124.08 96.13,124.21 95.6,124.21 95.47,124.35 95.47,124.67 95.6,124.8 96.13,124.8 96.26,124.94 96.26,125.26 96.13,125.4 95.48,125.4 95.35,125.53 95.35,140.12 95.66,140.44 96.2,140.44 96.34,140.57 96.34,145.06 96.62,145.34 97.81,145.34 97.97,145.5 97.97,146.11 v2(98.37,146.52)
DDR4_COMP_DQ20: length 36.2
  TOP w0.137: U4.H2 v2(102.37,146.52)
  ART07 w0.114: 98.93,122.81 98.93,122.1 arc(98.91,121.95) 98.85,121.8 arc(98.8,121.6) 98.85,121.4 98.85,121.39 arc(98.93,121.1) 98.85,120.8 arc(98.8,120.6) 98.85,120.4 arc(98.93,120.1) 98.85,119.8 arc(98.8,119.6) 98.85,119.4 arc(98.91,119.26) 98.93,119.12 arc(98.93,119.06) 98.91,119.01 98.7,118.49 arc(98.67,118.44) 98.64,118.4 v2(98.34,118.1)
  ART07 w0.135: v2(102.37,146.52) 102.67,146.22 102.67,146.22 102.76,146.13 103.43,146.13 103.68,145.87 103.68,140.61 103.15,140.08 101.39,140.08 100.64,139.33 100.64,137.12 100.51,136.99 99.98,136.99 99.84,136.85 99.84,136.53 99.98,136.4 100.51,136.4 100.64,136.26 100.64,135.94 100.51,135.8 99.85,135.8 99.72,135.67 99.72,135.35 99.85,135.21 100.51,135.21 100.64,135.08 100.64,132.29 98.78,130.43 98.78,122.96 98.93,122.81
DDR4_COMP_DQ21: length 32.3
  TOP w0.137: U4.H8 v2(96.76,146.52)
  ART07 w0.114: 94.76,122.55 94.52,122.31 94.52,122.3 arc(94.47,122.1) 94.52,121.9 arc(94.6,121.6) 94.52,121.3 arc(94.47,121.1) 94.52,120.9 arc(94.6,120.6) 94.52,120.31 94.52,120.3 arc(94.47,120.1) 94.52,119.9 94.78,119.46 arc(94.85,119.28) v2(94.87,119.1)
  ART07 w0.135: v2(96.76,146.52) 96.76,146.26 96.61,146.1 95.26,146.1 94.89,145.73 94.89,145.09 95.03,144.95 95.33,144.95 95.52,144.77 95.52,143.31 95.38,143.18 95.03,143.18 94.89,143.04 94.89,142.72 95.03,142.59 95.29,142.59 95.43,142.45 95.43,142.13 95.29,141.99 95.03,141.99 94.89,141.86 94.89,141.54 95.03,141.4 95.29,141.4 95.43,141.27 95.43,140.94 95.29,140.81 95.03,140.81 94.89,140.68 94.89,122.85 94.76,122.72 94.76,122.55
DDR4_COMP_DQ22: length 36.1
  TOP w0.137: U4.J3 v2(100.76,147.32)
  ART07 w0.114: 104.44,146.86 103.6,147.7 101.15,147.7 v2(100.76,147.32)
  ART07 w0.135: 104.44,146.86 104.44,140.26 101.57,137.39 101.57,131.27 99.57,129.26 99.57,124.33 99.77,124.13 99.77,123.21 100.56,122.43 100.56,119.89 100.3,119.63 100,119.63 99.76,119.39 arc(99.74,119.35) 99.72,119.3 99.59,119.1 arc(99.41,118.84) v2(99.2,118.6)
DDR4_COMP_DQ23: length 33.2
  TOP w0.137: U4.J7 v2(98.37,147.32)
  ART07 w0.114: 94.51,123.13 94.51,122.66 94.36,122.39 arc(94.28,122.1) 94.36,121.8 arc(94.41,121.6) 94.36,121.4 94.36,121.39 arc(94.28,121.1) 94.36,120.8 arc(94.41,120.6) 94.36,120.4 arc(94.28,120.1) 94.36,119.8 arc(94.41,119.6) 94.36,119.4 arc(94.28,119.1) 94.36,118.8 94.48,118.6 arc(94.66,118.34) v2(94.87,118.1)
  ART07 w0.135: v2(98.37,147.32) 97.99,146.94 95.6,146.94 94.51,145.85 94.51,123.13
DDR4_COMP_DQ24: length 32.8
  TOP w0.137: U4.A3 v2(100.76,140.92)
  ART05 w0.135: v2(98.34,122.1) 98.34,122.84 98.31,122.87 98.31,127.38 98.45,127.51 98.8,127.51 98.93,127.64 98.93,127.92 98.8,128.05 98.45,128.05 98.31,128.19 98.31,128.46 98.45,128.59 98.8,128.59 98.93,128.73 98.93,129 98.8,129.13 98.45,129.13 98.31,129.27 98.31,129.87 98.45,130 99.3,130 99.44,130.14 99.44,130.41 99.3,130.55 98.45,130.55 98.31,130.68 98.31,130.95 98.45,131.09 99.3,131.09 99.44,131.22 99.44,131.49 99.3,131.63 98.45,131.63 98.31,131.76 98.31,132.03 98.45,132.17 99.3,132.17 99.44,132.3 99.44,132.57 99.3,132.71 98.45,132.71 98.31,132.84 98.31,133.12 98.45,133.25 99.3,133.25 99.44,133.39 99.44,133.66 99.3,133.79 98.45,133.79 98.31,133.93 98.31,134.2 98.45,134.33 99.3,134.33 99.44,134.47 99.44,134.74 99.3,134.87 98.45,134.87 98.31,135.01 98.31,137.71 99.92,139.32 99.92,141.12 100.07,141.27 100.41,141.27 v2(100.76,140.92)
DDR4_COMP_DQ25: length 28.8
  TOP w0.137: U4.B8 v2(96.76,141.72)
  ART05 w0.135: v2(94.87,122.1) 94.87,128.72 94.41,129.18 94.41,142.06 94.31,142.16 93.88,142.16 93.72,142.32 93.72,142.54 93.88,142.7 94.16,142.7 94.29,142.83 94.29,143.02 94.06,143.26 93.8,143.26 93.67,143.38 93.67,143.68 93.81,143.81 94.1,143.81 95.12,142.79 95.12,141.5 95.3,141.32 96.37,141.32 v2(96.76,141.72)
DDR4_COMP_DQ26: length 32.2
  TOP w0.137: U4.C3 v2(100.76,142.52)
  ART05 w0.135: v2(100.76,142.52) 101.17,142.11 101.17,140.56 100.97,140.36 100.56,140.36 100.39,140.19 100.39,139.94 100.53,139.8 101.36,139.8 101.5,139.67 101.5,139.4 101.36,139.26 100.53,139.26 100.39,139.13 100.39,138.9 100.73,138.56 100.73,138.37 100.54,138.18 100.35,138.18 99.93,138.6 99.74,138.6 99.54,138.41 99.54,138.22 100.04,137.72 100.04,137.53 99.85,137.34 99.66,137.34 99.16,137.83 98.97,137.83 98.7,137.57 98.7,136.77 98.84,136.64 99.84,136.64 100,136.48 100,136.23 99.86,136.1 98.84,136.1 98.7,135.96 98.7,135.69 98.84,135.56 99.68,135.56 99.82,135.42 99.82,129.79 99.34,129.31 99.34,127.18 98.7,126.54 98.7,123.32 98.75,123.27 98.75,121.87 98.34,121.45 v2(98.34,121.1)
DDR4_COMP_DQ27: length 30.8
  TOP w0.137: U4.C7 v2(98.37,142.52)
  ART05 w0.135: v2(98.37,142.52) 97.99,142.14 97.99,140.25 97.57,139.83 96.16,139.83 95.75,139.41 95.36,139.41 95.22,139.28 95.22,139.06 95.36,138.92 96.46,138.92 96.59,138.79 96.59,138.52 96.46,138.38 95.41,138.38 95.22,138.19 95.22,137.97 95.36,137.84 96.46,137.84 96.59,137.7 96.59,137.43 96.46,137.3 95.41,137.3 95.22,137.11 95.22,136.84 95.36,136.71 95.67,136.71 95.81,136.57 95.81,136.3 95.67,136.17 95.36,136.17 95.22,136.03 95.22,135.76 95.36,135.62 95.67,135.62 95.81,135.49 95.81,135.22 95.67,135.08 95.36,135.08 95.22,134.95 95.22,134.68 95.36,134.54 95.67,134.54 95.81,134.41 95.81,121.67 v2(95.74,121.6)
DDR4_COMP_DQ28: length 33.3
  TOP w0.137: U4.C2 v2(102.37,142.52)
  ART05 w0.135: v2(99.2,120.6) 99.62,121.01 99.62,126.11 100.2,126.69 100.2,128.85 100.94,129.59 100.94,137.03 104.62,140.72 104.62,142.61 104.75,142.74 105.3,142.74 105.43,142.88 105.43,143.15 105.3,143.28 104.75,143.28 104.62,143.42 104.62,143.69 104.75,143.82 105.3,143.82 105.43,143.96 105.43,144.32 105.23,144.53 102.94,144.53 102.78,144.36 102.78,142.92 v2(102.37,142.52)
DDR4_COMP_DQ29: length 29.2
  TOP w0.137: U4.C8 v2(96.76,142.52)
  ART05 w0.135: v2(94.87,121.1) 94.87,121.42 94.36,121.94 94.36,128.6 94,128.95 94,140.74 93.27,141.48 93.27,144.06 93.4,144.19 94.32,144.19 95.53,142.99 95.53,142.34 95.75,142.11 96.36,142.11 v2(96.76,142.52)
DDR4_COMP_DQ30: length 32.8
  TOP w0.137: U4.D3 v2(100.76,143.32)
  ART05 w0.135: v2(99.2,121.6) 99.2,126.38 99.77,126.95 99.77,129.06 100.43,129.72 100.43,137.49 101.88,138.94 101.88,140.3 102.01,140.44 102.35,140.44 102.48,140.3 102.48,139.83 102.62,139.7 102.89,139.7 103.02,139.83 103.02,140.3 103.16,140.44 103.4,140.44 104.24,141.27 104.24,143.87 104.14,143.97 103.76,143.97 103.63,143.83 103.63,142.34 103.4,142.11 102.18,142.11 101.96,142.34 101.96,142.72 101.78,142.9 101.18,142.9 v2(100.76,143.32)
DDR4_COMP_DQ31: length 30.4
  TOP w0.137: U4.D7 v2(98.37,143.32)
  ART05 w0.135: v2(95.74,120.6) 95.74,120.86 95.29,121.31 95.29,121.86 95.43,121.99 95.43,128.88 94.79,129.51 94.79,129.95 94.92,130.08 95.32,130.08 95.45,130.21 95.45,130.49 95.32,130.62 94.92,130.62 94.79,130.76 94.79,131.03 94.92,131.16 95.32,131.16 95.45,131.3 95.45,131.57 95.32,131.7 94.92,131.7 94.79,131.84 94.79,132.11 94.92,132.24 95.32,132.24 95.45,132.38 95.45,132.65 95.32,132.78 94.92,132.78 94.79,132.92 94.79,133.19 94.92,133.33 95.32,133.33 95.45,133.46 95.45,133.73 95.32,133.87 94.92,133.87 94.79,134 94.79,139.72 95.5,140.44 96.82,140.44 97.16,140.77 97.16,142.72 97.36,142.93 97.97,142.93 98.36,143.32 v2(98.37,143.32)
DDR4_COMP_DQ32: length 45.5
  TOP w0.137: U5.G2 v2(113.8,145.72)
  ART07 w0.114: 104.75,118.6 104.75,117.8 arc(104.8,117.6) 104.75,117.4 arc(104.67,117.1) 104.75,116.8 arc(104.8,116.6) 104.75,116.4 arc(104.67,116.1) 104.75,115.81 104.75,115.8 arc(104.8,115.6) 104.75,115.4 104.49,114.96 arc(104.42,114.78) v2(104.4,114.6)
  ART07 w0.135: 104.75,118.6 104.75,118.6 104.75,120.4 105.38,121.03 105.38,121.94 105.89,122.45 105.89,126.49 106.07,126.67 106.07,126.86 105.97,126.96 105.97,127.15 106.2,127.38 106.39,127.38 106.49,127.28 106.68,127.28 106.91,127.51 106.91,127.7 106.8,127.8 106.8,127.99 107.03,128.22 107.22,128.22 107.32,128.12 107.52,128.12 107.74,128.34 107.74,128.53 107.64,128.64 107.64,128.83 107.87,129.06 108.06,129.06 108.16,128.95 108.35,128.95 108.58,129.18 108.58,129.37 108.48,129.47 108.48,129.66 108.71,129.89 108.9,129.89 109,129.79 109.19,129.79 111.11,131.71 111.11,131.9 110.06,132.96 110.06,133.15 110.28,133.37 110.47,133.37 111.53,132.32 112.15,132.32 114.4,134.57 114.4,136.63 112.83,138.19 111.71,138.19 111.58,138.33 111.58,138.67 111.74,138.83 112.51,138.83 112.65,138.97 112.65,139.31 112.49,139.47 112.25,139.47 112.11,139.6 112.11,139.93 112.25,140.06 112.49,140.06 112.62,140.2 112.62,144.3 112.88,144.55 113.21,144.55 113.38,144.73 113.38,145.3 v2(113.8,145.72)
DDR4_COMP_DQ33: length 42.4
  TOP w0.137: U5.F7 v2(109.8,144.92)
  ART07 w0.135: v2(109.8,144.92) 109.41,144.53 108.76,144.53 108.58,144.35 108.58,140.49 106.75,138.66 106.75,137.3 106.62,137.17 105.26,137.17 105.13,137.03 105.13,136.71 105.26,136.58 106.62,136.58 106.75,136.44 106.75,134.95 106.58,134.77 105.66,134.77 105.38,134.49 105.38,132.73 105.52,132.6 107.38,132.6 107.52,132.47 107.52,132.14 107.38,132.01 105.64,132.01 105.51,131.87 105.51,129.18 102.69,126.36 102.69,118.21 102.21,117.73 102.21,114.51 v2(101.8,114.1)
DDR4_COMP_DQ34: length 44.7
  TOP w0.137: U5.H3 v2(112.19,146.52)
  ART07 w0.135: v2(112.19,146.52) 112.59,146.91 114.83,146.91 115.54,146.2 115.54,139.11 115.12,138.7 115.12,137.22 115.26,137.09 115.97,137.09 116.1,136.95 116.1,136.63 115.97,136.5 115.26,136.5 115.12,136.36 115.12,136.04 115.26,135.91 115.97,135.91 116.1,135.77 116.1,135.45 115.97,135.31 115.26,135.31 115.12,135.18 115.12,134.2 107.67,126.75 107.67,121.92 107.41,121.67 106.78,121.67 106.57,121.45 106.57,119.29 106.4,119.13 106.02,119.13 105.62,118.72 105.62,117.3 arc(105.67,117.1) 105.62,116.9 arc(105.54,116.6) 105.62,116.3 arc(105.67,116.1) 105.62,115.9 arc(105.54,115.6) 105.61,115.31 105.62,115.3 arc(105.67,115.1) 105.62,114.9 105.36,114.46 arc(105.29,114.28) v2(105.26,114.1)
DDR4_COMP_DQ35: length 42.2
  TOP w0.137: U5.H7 v2(109.8,146.52)
  ART07 w0.135: v2(100.94,113.6) 101.35,114.01 101.35,117.63 102.33,118.62 102.33,123.3 101.56,124.08 101.56,126.2 104.29,128.94 104.29,135.02 104.5,135.23 106.24,135.23 106.37,135.37 106.37,135.69 106.24,135.83 104.5,135.83 104.37,135.96 104.37,137.03 107.77,140.44 107.77,145.04 108.05,145.33 109.2,145.33 109.37,145.5 109.37,146.09 v2(109.8,146.52)
DDR4_COMP_DQ36: length 45.6
  TOP w0.137: U5.H2 v2(113.8,146.52)
  ART07 w0.114: 104.91,114.9 arc(104.86,115.1) 104.91,115.3 arc(104.99,115.6) 104.91,115.9 arc(104.86,116.1) 104.91,116.3 arc(104.99,116.6) 104.92,116.89 104.91,116.9 arc(104.86,117.1) 104.91,117.3 104.98,117.41 arc(105.03,117.53) 105.04,117.65
  ART07 w0.135: 105.04,117.65 105.13,117.73 105.13,119.13 105.71,119.71 105.71,121.77 106.27,122.33 106.27,125.96 114.74,134.43 114.74,138.09 114.42,138.4 113.14,138.4 113,138.54 113,138.99 113.14,139.13 114.82,139.13 114.96,139.26 114.96,139.58 114.82,139.72 113.14,139.72 113,139.85 113,140.26 113.15,140.41 114.75,140.41 115.03,140.69 115.03,145.97 114.87,146.14 114.18,146.14 v2(113.8,146.52) ; v2(104.4,113.6) 104.4,113.71 arc(104.41,113.78) 104.45,113.83 104.87,114.26 arc(104.92,114.31) 104.95,114.37 arc(104.99,114.64) 104.91,114.9
DDR4_COMP_DQ37: length 42.2
  TOP w0.137: U5.H8 v2(108.19,146.52)
  ART07 w0.135: v2(108.19,146.52) 107.82,146.14 107.09,146.14 106.96,146 106.96,142.76 106.82,142.62 106.3,142.62 106.17,142.49 106.17,142.17 106.3,142.03 106.82,142.03 106.96,141.9 106.96,141.58 106.82,141.44 106.3,141.44 106.17,141.31 106.17,140.98 106.3,140.85 106.82,140.85 106.96,140.71 106.96,140.49 103.99,137.51 103.99,136.98 103.85,136.84 103.23,136.84 103.1,136.71 103.1,136.39 103.23,136.25 103.85,136.25 103.99,136.12 103.99,135.79 103.85,135.66 103.23,135.66 103.1,135.52 103.1,135.2 103.23,135.07 103.77,135.07 103.91,134.93 103.91,129.54 101.09,126.72 101.09,123.95 101.83,123.21 101.83,120.7 101.32,120.19 101.32,118.62 100.48,117.78 100.48,115.05 v2(100.94,114.6)
DDR4_COMP_DQ38: length 45.9
  TOP w0.137: U5.J3 v2(112.19,147.32)
  ART07 w0.135: v2(112.19,147.32) 112.63,147.75 114.73,147.75 116.13,146.35 116.13,139.62 116.71,139.04 116.71,138.48 116.58,138.35 115.73,138.35 115.59,138.22 115.59,137.89 115.73,137.76 116.58,137.76 116.71,137.62 116.71,135.23 108.18,126.69 108.18,121.41 107.67,120.9 107.67,118.87 107.41,118.62 106.78,118.62 106.54,118.38 106.54,114.44 106.27,114.17 106.02,114.17 105.84,113.99 arc(105.8,113.94) 105.78,113.87 arc(105.77,113.83) 105.74,113.79 105.32,113.37 arc(105.28,113.31) 105.26,113.25 v2(105.26,113.1)
DDR4_COMP_DQ39: length 42.7
  TOP w0.137: U5.J7 v2(109.8,147.32)
  ART07 w0.135: v2(109.8,147.32) 109.4,146.91 106.88,146.91 105.66,145.69 105.66,139.88 102.72,136.93 102.72,129.34 100.66,127.28 100.66,123.82 101.14,123.34 101.14,120.66 100.94,120.46 100.94,119.25 100.3,118.62 99.92,118.62 99.67,118.36 99.67,114.91 100.05,114.53 100.28,114.53 100.48,114.32 100.48,113.38 100.68,113.18 101.72,113.18 v2(101.8,113.1)
DDR4_COMP_DQ40: length 42.8
  TOP w0.137: U5.A3 v2(112.19,140.92)
  ART05 w0.135: v2(104.4,115.6) 103.98,116.02 103.98,117.89 104.29,118.21 104.29,118.55 104.16,118.68 104,118.68 103.86,118.81 103.86,119.08 104,119.22 104.16,119.22 104.29,119.35 104.29,120.4 103.94,120.75 103.94,121.62 105.1,122.78 105.1,123.82 105.26,123.98 105.78,123.98 105.92,124.11 105.92,124.83 105.78,124.96 105.18,124.96 105.02,125.12 105.02,125.37 105.15,125.51 105.78,125.51 105.92,125.64 105.92,126.29 105.79,126.41 105.59,126.41 105.43,126.57 105.43,126.87 105.93,127.37 106.12,127.37 106.33,127.17 106.52,127.17 106.71,127.36 106.71,127.55 106.51,127.75 106.51,127.94 108.81,130.25 108.81,131.34 109.55,132.08 109.55,133.07 108.89,133.73 108.89,137.29 108.98,137.37 108.98,138.19 109.28,138.5 109.48,138.5 109.82,138.15 110.01,138.15 110.2,138.35 110.2,138.54 109.86,138.88 109.86,139.07 110.13,139.34 110.32,139.34 111.13,138.53 111.32,138.53 111.52,138.72 111.52,138.91 110.7,139.72 110.7,139.91 110.9,140.11 111.09,140.11 112.53,138.66 112.72,138.66 112.92,138.85 112.92,139.04 111.35,140.6 111.35,140.97 111.5,141.12 111.99,141.12 v2(112.19,140.92)
DDR4_COMP_DQ41: length 40.3
  TOP w0.137: U5.B8 v2(108.19,141.72)
  ART05 w0.135: v2(108.19,141.72) 107.78,141.3 106.98,141.3 106.42,140.74 106.42,140.17 106.6,139.99 106.79,139.99 107.24,140.44 107.46,140.44 107.59,140.31 107.59,140.07 106.76,139.25 106.57,139.25 106.18,139.65 105.99,139.65 105.8,139.45 105.8,139.26 106.19,138.87 106.19,138.68 106,138.49 105.81,138.49 105.41,138.88 105.22,138.88 105.03,138.69 105.03,138.5 105.42,138.1 105.42,137.91 105.23,137.72 105.04,137.72 104.65,138.11 104.46,138.11 104.27,137.92 104.27,137.73 104.66,137.34 104.66,137.15 104.47,136.96 104.28,136.96 103.88,137.35 103.69,137.35 103.22,136.88 103.22,136.55 103.32,136.45 104.72,136.45 104.9,136.27 104.9,135.86 104.77,135.74 104.07,135.74 103.93,135.6 103.93,129.89 103.63,129.59 103.63,129.23 103.93,128.93 103.93,128.73 101.5,126.29 101.5,123.34 101.22,123.06 101.22,118.19 101.34,118.06 101.34,116.01 v2(100.94,115.6)
DDR4_COMP_DQ42: length 42.9
  TOP w0.137: U5.C3 v2(112.19,142.52)
  ART05 w0.135: v2(104.4,116.6) 104.8,117 104.8,121.69 106.27,123.16 106.27,126.39 107.36,127.48 107.36,127.67 107.13,127.9 107.13,128.09 107.33,128.28 107.52,128.28 107.96,127.84 108.15,127.84 108.34,128.03 108.34,128.22 107.9,128.67 107.9,128.86 108.09,129.05 108.28,129.05 108.74,128.59 108.93,128.59 109.12,128.78 109.12,128.97 108.66,129.43 108.66,129.62 108.86,129.81 109.05,129.81 109.49,129.37 109.68,129.37 110,129.68 110,129.87 109.55,130.32 109.55,130.51 109.74,130.7 109.93,130.7 110.4,130.23 110.59,130.23 110.95,130.59 110.95,130.78 110.46,131.27 110.46,131.46 110.65,131.66 110.84,131.66 111.33,131.16 111.52,131.16 111.82,131.46 111.82,131.71 110.98,132.56 110.79,132.56 110.46,132.23 110.27,132.23 110.07,132.42 110.07,132.61 110.3,132.84 110.3,133.03 109.24,134.09 109.24,137.13 109.83,137.72 110.13,137.72 110.56,138.15 113.03,138.15 113.28,138.4 113.28,139.3 112.6,139.98 112.6,142.11 v2(112.19,142.52)
DDR4_COMP_DQ43: length 40.3
  TOP w0.137: U5.C7 v2(109.8,142.52)
  ART05 w0.135: v2(101.8,116.1) 102.26,116.56 102.26,119.3 102.54,119.58 102.54,122.25 102.92,122.63 102.92,122.89 102.78,123.02 102.37,123.02 102.23,123.16 102.23,123.43 102.37,123.56 103.52,123.56 103.63,123.67 103.63,123.95 103.55,124.03 103.07,124.03 102.92,124.18 102.92,124.78 103.08,124.94 103.65,124.94 103.78,125.08 103.78,125.37 103.63,125.53 103.2,125.53 103.02,125.7 103.02,126.26 103.25,126.49 103.76,126.49 103.86,126.59 103.86,126.95 103.73,127.08 103.73,127.35 103.93,127.56 104.34,127.56 104.7,127.91 104.7,128.19 104.92,128.42 105.29,128.42 105.43,128.56 105.43,128.9 105.29,129.03 104.9,129.03 104.75,129.18 104.75,129.53 104.88,129.67 105.5,129.67 105.64,129.8 105.64,130.94 105.38,131.19 105.38,131.63 105.52,131.76 106.17,131.76 106.31,131.9 106.31,132.17 106.17,132.3 105.52,132.3 105.38,132.44 105.38,134.95 105.74,135.3 105.74,136.1 105.87,136.23 105.93,136.23 106.07,136.37 106.07,136.64 105.74,136.97 105.74,137.21 106.75,138.23 107.01,138.23 107.26,137.97 107.54,137.97 107.77,138.2 107.77,138.91 109.42,140.57 109.42,141.89 109.63,142.09 109.98,142.09 109.98,142.1 110.49,142.1 110.59,142.2 110.59,142.38 110.45,142.52 v2(109.8,142.52)
DDR4_COMP_DQ44: length 43
  TOP w0.137: U5.C2 v2(113.8,142.52)
  ART05 w0.135: v2(113.8,142.52) 113.52,142.52 113.39,142.38 113.39,140.49 113.52,140.36 114.11,140.36 114.25,140.22 114.25,139.3 114.38,139.16 115.1,139.16 115.24,139.03 115.24,138.76 115.1,138.62 113.92,138.62 113.79,138.49 113.79,138.22 113.92,138.08 115.1,138.08 115.24,137.95 115.24,137.67 115.1,137.54 114.08,137.54 113.94,137.41 113.94,137.13 114.08,137 115.1,137 115.24,136.86 115.24,136.59 115.1,136.46 114.38,136.46 114.25,136.32 114.25,136.05 114.38,135.92 115.1,135.92 115.24,135.78 115.24,135.51 115.1,135.38 114.38,135.38 114.25,135.24 114.25,134.97 114.38,134.83 115.1,134.83 115.24,134.7 115.24,134.43 115.1,134.29 114.38,134.29 114.25,134.16 114.25,133.4 107.34,126.49 107.34,126.01 107.47,125.88 107.94,125.88 108.07,125.74 108.07,125.47 107.94,125.34 107.47,125.34 107.34,125.2 107.34,124.93 107.47,124.8 107.94,124.8 108.07,124.66 108.07,124.39 107.94,124.26 107.4,124.26 107.26,124.12 107.26,123.42 105.66,121.82 105.66,119.71 105.26,119.31 v2(105.26,117.1)
DDR4_COMP_DQ45: length 40.3
  TOP w0.137: U5.C8 v2(108.19,142.52)
  ART05 w0.135: v2(100.94,116.6) 100.53,117 100.53,118.77 100.86,119.1 100.86,123.39 101.09,123.62 101.09,126.49 101.72,127.13 101.72,127.35 101.09,127.99 101.09,128.19 101.27,128.37 101.46,128.37 102.18,127.64 102.37,127.64 102.56,127.84 102.56,128.03 101.84,128.75 101.84,128.94 102.03,129.13 102.22,129.13 102.94,128.41 103.13,128.41 103.33,128.6 103.33,128.79 102.6,129.52 102.6,131.48 102.77,131.65 103.25,131.65 103.38,131.77 103.38,132.11 103.24,132.24 102.06,132.24 101.93,132.38 101.93,132.65 102.06,132.78 102.71,132.78 102.84,132.92 102.84,134.75 102.71,134.88 102.27,134.88 102.13,135.01 102.13,135.29 102.27,135.42 103.34,135.42 103.5,135.58 103.5,135.94 103.38,136.07 102.85,136.07 102.72,136.2 102.72,136.93 106.02,140.23 106.02,141.04 107.11,142.14 107.82,142.14 v2(108.19,142.52)
DDR4_COMP_DQ46: length 43.3
  TOP w0.137: U5.D3 v2(112.19,143.32)
  ART05 w0.135: v2(112.19,143.32) 112.6,142.91 114.94,142.91 115.16,142.7 115.16,142.52 115.3,142.38 116.04,142.38 116.18,142.25 116.18,141.98 116.04,141.84 115.3,141.84 115.16,141.71 115.16,141.44 115.3,141.3 115.99,141.3 116.13,141.17 116.13,140.89 115.99,140.76 115.3,140.76 115.16,140.62 115.16,139.93 115.62,139.47 115.62,139.21 115.75,139.07 116.45,139.07 116.58,138.94 116.58,138.67 116.45,138.53 115.75,138.53 115.62,138.4 115.62,138.13 115.75,137.99 116.45,137.99 116.58,137.86 116.58,137.58 116.45,137.45 115.75,137.45 115.62,137.32 115.62,137.04 115.75,136.91 116.45,136.91 116.58,136.77 116.58,136.5 116.45,136.37 115.75,136.37 115.62,136.23 115.62,134.06 108.33,126.77 108.33,123.95 106.54,122.16 106.54,119.24 106.38,119.08 105.94,119.08 105.71,118.85 105.71,116.55 v2(105.26,116.1)
DDR4_COMP_DQ47: length 40.4
  TOP w0.137: U5.D7 v2(109.8,143.32)
  ART05 w0.135: v2(109.8,143.32) 111.34,143.32 111.48,143.18 111.48,141.56 111.34,141.43 111.08,141.43 110.94,141.56 110.94,142.67 110.72,142.89 109.16,142.89 109.16,142.9 108.85,142.9 108.63,142.68 108.63,142.67 108.62,142.67 108.62,140.63 105.13,137.13 105.13,136.7 105.33,136.5 105.33,135.58 105.1,135.36 104.57,135.36 104.37,135.15 104.37,132.55 104.5,132.42 104.91,132.42 105.04,132.28 105.04,132.01 104.91,131.88 104.5,131.88 104.37,131.74 104.37,128.5 102.56,126.69 102.56,124.14 102.43,124 102.08,124 101.88,123.8 101.88,123.24 101.66,123.02 101.66,122.83 101.8,122.7 102.02,122.7 102.16,122.56 102.16,122.29 102.02,122.16 101.78,122.16 101.65,122.02 101.65,121.69 101.78,121.56 102.05,121.56 102.18,121.42 102.18,121.15 102.05,121.02 101.78,121.02 101.65,120.88 101.65,120.62 101.75,120.52 102.03,120.52 102.2,120.36 102.2,119.88 101.8,119.48 v2(101.8,117.1)
DDR4_COMP_DQ48: length 56.5
  TOP w0.137: U6.G2 v2(125.23,145.72)
  ART07 w0.135: v2(125.23,145.72) 124.81,145.3 124.81,140.64 124.46,140.28 124.46,139.91 124.59,139.78 125.08,139.78 125.22,139.65 125.22,139.32 125.08,139.19 124.59,139.19 124.46,139.05 124.46,138.73 124.59,138.6 125.08,138.6 125.22,138.46 125.22,138.14 125.08,138 124.59,138 124.46,137.87 124.46,137.55 124.59,137.41 125.08,137.41 125.22,137.28 125.22,136.96 125.08,136.82 124.59,136.82 124.46,136.69 124.46,136.36 124.59,136.23 125.08,136.23 125.22,136.09 125.22,135.77 125.08,135.64 124.59,135.64 124.46,135.5 124.46,135.18 124.59,135.05 125.08,135.05 125.22,134.91 125.22,134.59 125.08,134.45 124.59,134.45 124.46,134.32 124.46,134 124.59,133.86 125.08,133.86 125.22,133.73 125.22,133.4 125.08,133.27 124.59,133.27 124.46,133.14 124.46,132.81 124.59,132.68 125.08,132.68 125.22,132.54 125.22,132.22 125.08,132.09 124.59,132.09 124.46,131.95 124.46,131.52 124.61,131.37 125.01,131.37 125.14,131.23 125.14,130.94 125.01,130.81 124,130.81 123.68,131.13 123.31,131.13 122.98,130.81 122.98,130.62 123.68,129.92 123.68,129.73 123.45,129.5 123.26,129.5 122.57,130.2 122.38,130.2 122.15,129.97 122.15,129.78 122.85,129.08 122.85,128.89 122.62,128.66 122.43,128.66 121.73,129.36 121.54,129.36 121.02,128.84 117.18,128.84 115.49,127.15 115.49,125.07 115.06,124.64 115.06,123.57 112.6,121.11 112.6,114.76 112.38,114.54 111.95,114.54 111.51,114.1 v2(110.46,114.1)
DDR4_COMP_DQ49: length 55.6
  TOP w0.137: U6.F7 v2(121.23,144.92)
  ART07 w0.135: v2(107.86,114.6) 108.3,115.04 108.3,115.65 109.15,116.5 109.15,117.85 109.58,118.28 109.58,124.11 109.83,124.36 110.56,124.36 110.69,124.48 110.69,124.84 110.41,125.12 110.22,125.12 110.04,124.95 109.85,124.95 109.62,125.17 109.62,125.36 109.8,125.54 109.8,125.73 109.6,125.93 109.6,126.12 109.84,126.35 110.03,126.35 111.28,125.09 111.47,125.09 111.7,125.32 111.7,125.51 110.44,126.77 110.44,126.96 118.16,134.67 119.23,134.67 119.68,135.13 119.68,135.73 119.82,135.86 121.15,135.86 121.28,136 121.28,136.32 121.15,136.46 119.82,136.46 119.68,136.59 119.68,136.91 119.82,137.05 121.15,137.05 121.28,137.18 121.28,137.51 121.15,137.64 119.82,137.64 119.68,137.77 119.68,138.1 119.82,138.23 121.15,138.23 121.28,138.37 121.28,138.69 121.15,138.82 119.82,138.82 119.68,138.96 119.68,139.28 119.82,139.42 121.15,139.42 121.28,139.55 121.28,139.87 121.15,140.01 119.82,140.01 119.68,140.14 119.68,140.41 120.01,140.74 120.01,145.13 120.2,145.31 120.84,145.31 v2(121.23,144.92)
DDR4_COMP_DQ50: length 57.8
  TOP w0.137: U6.H3 v2(123.62,146.52)
  ART07 w0.135: v2(123.62,146.52) 124.03,146.12 124.03,135.33 123.89,135.2 123.4,135.2 123.26,135.06 123.26,134.74 123.4,134.61 123.89,134.61 124.03,134.47 124.03,133.6 123.4,132.98 123.4,132.79 124.11,132.07 124.11,131.88 123.88,131.66 123.69,131.66 122.98,132.37 122.79,132.37 122.56,132.14 122.56,131.95 122.92,131.59 122.92,131.4 122.69,131.17 122.5,131.17 122.14,131.53 121.95,131.53 121.72,131.3 121.72,131.11 122.08,130.76 122.08,130.57 121.71,130.2 121.42,130.2 119.82,131.8 119.63,131.8 119.4,131.57 119.4,131.38 120.93,129.86 120.93,129.67 120.59,129.33 120.3,129.33 118.84,130.79 118.65,130.79 118.41,130.55 118.41,130.36 118.98,129.79 118.98,129.6 118.75,129.37 118.56,129.37 117.99,129.94 117.8,129.94 114.27,126.41 114.27,125.97 114.41,125.84 114.92,125.84 115.06,125.7 115.06,125.38 114.92,125.25 114.41,125.25 114.27,125.11 114.27,124.18 114.63,123.82 114.63,123.63 114.41,123.4 114.22,123.4 113.78,123.83 113.59,123.83 113.36,123.6 113.36,122.63 113.19,122.46 112.84,122.46 112.67,122.63 112.67,123.24 112.49,123.42 111.89,123.42 111.76,123.28 111.76,115.03 v2(111.33,114.6)
DDR4_COMP_DQ51: length 54.3
  TOP w0.137: U6.H7 v2(121.23,146.52)
  ART07 w0.114: 107.84,116.13 107.51,115.8 arc(107.46,115.6) 107.51,115.4 arc(107.59,115.1) 107.51,114.8 arc(107.46,114.6) 107.51,114.4
  ART07 w0.135: v2(107,113.1) 107,113.26 107.41,113.67 arc(107.47,113.73) 107.51,113.8 arc(107.59,114.1) 107.51,114.4 ; v2(121.23,146.52) 120.84,146.13 117.86,146.13 117.7,145.97 117.7,145.46 117.83,145.34 118.31,145.34 118.41,145.24 118.41,143.89 118.16,143.64 118.16,142.42 117.6,141.86 117.6,141.4 117.73,141.27 117.73,140.77 117.86,140.64 118.05,140.64 118.18,140.5 118.18,140.18 118.05,140.05 117.86,140.05 117.73,139.91 117.73,139.49 117.86,139.35 119.12,139.35 119.25,139.22 119.25,138.89 119.12,138.76 117.86,138.76 117.73,138.63 117.73,138.3 117.86,138.17 119.12,138.17 119.25,138.03 119.25,137.71 119.12,137.58 117.86,137.58 117.73,137.44 117.73,137.12 117.86,136.98 119.12,136.98 119.25,136.85 119.25,136.53 119.12,136.39 117.86,136.39 117.73,136.26 117.73,135.94 117.86,135.8 119.12,135.8 119.25,135.67 119.25,135.34 119.12,135.21 117.86,135.21 117.73,135.07 117.73,134.87 109.17,126.31 109.17,118.58 108.3,117.71 108.3,116.38 108.05,116.13 107.84,116.13
DDR4_COMP_DQ52: length 56.9
  TOP w0.137: U6.H2 v2(125.23,146.52)
  ART07 w0.135: v2(110.46,113.1) 110.53,113.03 111.55,113.03 111.9,112.69 112.58,112.69 112.91,113.02 113.22,113.02 113.71,113.51 114.09,113.51 114.35,113.77 114.35,118.13 115.22,119.01 115.22,120.36 115.09,120.49 114.51,120.49 114.37,120.63 114.37,120.95 114.51,121.08 115.09,121.08 115.22,121.22 115.22,121.4 115.52,121.69 116.69,121.69 117.9,122.91 117.9,127.15 118.29,127.53 119.65,127.53 119.78,127.4 119.78,125.74 119.92,125.6 120.18,125.6 120.32,125.74 120.32,127.28 120.57,127.53 122.07,127.53 122.2,127.4 122.2,125.84 122.34,125.7 122.66,125.7 122.8,125.84 122.8,127.4 122.93,127.53 124.33,127.53 125.52,128.73 125.52,129.59 126.44,130.5 126.44,146.68 126.21,146.91 125.63,146.91 125.53,146.82 125.53,146.82 v2(125.23,146.52)
DDR4_COMP_DQ53: length 53.8
  TOP w0.137: U6.H8 v2(119.62,146.52)
  ART07 w0.114: v2(107,114.1) 107,114.52 107.29,114.81 arc(107.29,114.83) 107.3,114.85 107.34,114.91 arc(107.39,115.11) 107.34,115.31 107.28,115.42 arc(107.22,115.61) 107.28,115.8 107.35,115.94 arc(107.4,116.05) 107.41,116.17
  ART07 w0.135: v2(119.62,146.52) 119.62,146.7 119.86,146.94 120.72,146.94 120.83,147.04 120.83,147.57 120.67,147.73 119.21,147.73 119.09,147.84 116.07,147.84 115.87,147.65 115.87,147.23 116.4,146.71 116.86,146.71 117.09,146.94 117.44,146.94 117.62,146.75 117.62,146.37 117.56,146.3 116.74,146.3 116.61,146.17 116.61,145.94 116.74,145.81 117.08,145.81 117.22,145.67 117.22,145.37 117.06,145.21 116.74,145.21 116.61,145.08 116.61,144.76 116.74,144.62 117.21,144.62 117.37,144.46 117.37,144.16 117.24,144.03 116.74,144.03 116.61,143.9 116.61,143.57 116.74,143.44 117.59,143.44 117.73,143.3 117.73,142.98 117.59,142.85 116.74,142.85 116.61,142.71 116.61,142.39 116.74,142.25 117.01,142.25 117.14,142.12 117.14,141.32 117.35,141.12 117.35,140.95 117.21,140.82 116.77,140.82 116.63,140.68 116.63,140.36 116.77,140.22 117.21,140.22 117.35,140.09 117.35,135.05 108.73,126.44 108.73,120.9 108.31,120.47 108.31,118.62 107.41,117.73 107.41,116.17
DDR4_COMP_DQ54: length 58.4
  TOP w0.137: U6.J3 v2(123.62,147.32)
  ART07 w0.135: v2(111.33,113.6) 111.36,113.56 112.24,113.56 112.72,114.05 113.23,114.05 113.51,114.32 113.51,118.16 113.38,118.29 113.08,118.29 112.93,118.44 112.93,118.72 113.07,118.87 114.49,118.87 114.63,119 114.63,119.32 114.49,119.46 113.18,119.46 113.03,119.61 113.03,119.93 113.16,120.07 113.36,120.07 113.5,120.2 113.5,120.52 113.36,120.66 113.17,120.66 113.03,120.79 113.03,120.98 114.12,122.07 114.31,122.07 114.64,121.74 114.83,121.74 115.06,121.97 115.06,122.16 114.73,122.49 114.73,122.68 115.04,123 115.24,123 116.05,122.18 116.24,122.18 116.47,122.41 116.47,122.6 115.65,123.42 115.65,123.61 115.8,123.75 116.1,123.75 116.66,123.19 116.89,123.19 117.06,123.36 117.06,123.55 116.53,124.08 116.53,127.43 117.42,128.32 123.46,128.32 123.85,127.93 124.04,127.93 124.27,128.16 124.27,128.35 123.88,128.74 123.88,128.93 124.1,129.16 124.29,129.16 124.69,128.77 124.88,128.77 125.11,128.99 125.11,129.18 124.71,129.58 124.71,129.77 125.63,130.68 125.63,146 125.5,146.13 125.05,146.13 124.82,146.35 124.82,146.71 124.58,146.94 124,146.94 v2(123.62,147.32)
DDR4_COMP_DQ55: length 55.8
  TOP w0.137: U6.J7 v2(121.23,147.32)
  ART07 w0.135: v2(107.86,113.6) 107.88,113.6 108.4,113.08 109.78,113.08 110.26,112.6 110.64,112.6 111.12,112.11 111.5,112.11 111.94,111.68 112.44,111.68 112.85,112.09 113.33,112.09 113.81,112.57 114.02,112.57 115.24,113.79 115.24,118.32 116.88,121.23 119.09,123.44 123.25,123.44 123.8,123.99 123.8,124.43 124.03,124.66 124.48,124.66 124.91,125.09 125.14,126.85 125.21,127 126.87,130.57 126.87,147.04 126.16,147.75 123.09,147.75 122.65,147.32 v2(121.23,147.32)
DDR4_COMP_DQ56: length 44.1
  TOP w0.137: U6.A3 v2(123.62,140.92)
  ART05 w0.135: v2(123.62,140.92) 123.62,136.88 122.15,135.41 122.15,135.22 122.62,134.75 122.62,134.56 122.43,134.37 122.24,134.37 121.77,134.84 121.58,134.84 121.33,134.59 121.33,134.4 121.78,133.96 121.78,133.77 121.59,133.58 121.4,133.58 120.95,134.02 120.76,134.02 120.57,133.83 120.57,133.64 121.01,133.19 121.01,133 120.82,132.81 120.63,132.81 120.19,133.26 119.99,133.26 119.8,133.06 119.8,132.87 120.25,132.43 120.25,132.24 120.06,132.05 119.86,132.05 119.42,132.49 119.23,132.49 119.04,132.3 119.04,132.11 119.48,131.66 119.48,131.47 119.29,131.28 119.1,131.28 118.66,131.73 118.46,131.73 118.27,131.53 118.27,131.34 118.72,130.9 118.72,130.71 118.52,130.52 118.33,130.52 117.89,130.96 117.7,130.96 117.51,130.77 117.51,130.58 117.95,130.13 117.95,129.94 117.76,129.75 117.57,129.75 117.12,130.19 116.93,130.19 116.74,130 116.74,129.81 117.19,129.37 117.19,129.18 117,128.99 116.78,128.99 116.38,129.39 116.15,129.39 111.73,124.97 111.73,124.49 111.87,124.36 112.94,124.36 113.08,124.22 113.08,123.95 112.94,123.82 111.87,123.82 111.73,123.68 111.73,119.2 110.46,117.93 v2(110.46,117.1)
DDR4_COMP_DQ57: length 40.9
  TOP w0.137: U6.B8 v2(119.62,141.72)
  ART05 w0.135: v2(119.62,141.72) 119.23,141.32 118.54,141.32 118.39,141.17 117.98,141.17 117.65,140.84 117.65,140.33 117.78,140.2 119.14,140.2 119.28,140.06 119.28,139.79 119.14,139.65 117.78,139.65 117.65,139.52 117.65,139.25 117.78,139.11 119.14,139.11 119.28,138.98 119.28,138.71 119.14,138.57 117.78,138.57 117.65,138.44 117.65,138.17 117.78,138.03 119.14,138.03 119.28,137.9 119.28,137.62 119.14,137.49 117.78,137.49 117.65,137.36 117.65,134.19 109.52,126.06 109.52,122.17 108.13,120.78 108.13,119.05 107.44,118.36 107.44,116.54 v2(107,116.1)
DDR4_COMP_DQ58: length 44.1
  TOP w0.137: U6.C3 v2(123.62,142.52)
  ART05 w0.135: v2(110.46,116.1) 110.91,116.55 110.91,117.79 111.68,118.57 112.32,118.57 113.41,119.66 113.41,120.12 113.27,120.26 112.96,120.26 112.82,120.39 112.82,120.66 112.96,120.8 113.27,120.8 113.41,120.93 113.41,121.2 113.27,121.34 112.96,121.34 112.82,121.47 112.82,121.75 112.96,121.88 113.27,121.88 113.41,122.01 113.41,122.29 113.27,122.42 112.96,122.42 112.82,122.56 112.82,122.83 112.96,122.96 113.27,122.96 113.41,123.1 113.41,126.06 116.13,128.78 116.35,128.78 116.65,128.48 117.1,128.48 117.51,128.89 117.7,128.89 118.13,128.46 118.33,128.46 118.52,128.65 118.52,128.84 118.09,129.28 118.09,129.47 118.28,129.66 118.47,129.66 118.9,129.23 119.09,129.23 119.28,129.42 119.28,129.61 118.85,130.04 118.85,130.23 119.04,130.42 119.23,130.42 119.67,129.99 119.86,129.99 120.05,130.18 120.05,130.37 119.62,130.81 119.62,131 119.81,131.19 120,131.19 120.43,130.76 120.62,130.76 120.81,130.95 120.81,131.14 120.38,131.57 120.38,131.76 123.29,134.67 123.29,134.86 122.8,135.36 122.8,135.55 122.99,135.74 123.18,135.74 123.67,135.25 123.87,135.25 124.05,135.43 124.05,142.11 123.65,142.52 v2(123.62,142.52)
