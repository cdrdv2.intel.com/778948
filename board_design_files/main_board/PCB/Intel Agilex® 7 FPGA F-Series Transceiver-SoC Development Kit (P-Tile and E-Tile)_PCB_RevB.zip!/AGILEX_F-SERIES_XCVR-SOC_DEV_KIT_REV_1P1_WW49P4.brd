# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EN0_1.8V_R: length 243.4
  ART03 w0.114: v1(202.69,123.22) v1(203.96,124.49)
  ART07 w0.114: v2(136.83,162.89) 139.95,159.77 146.94,159.77 149.21,157.49 158.64,157.49 163.48,152.65 167.39,152.65 168.07,151.97 171.27,151.97 173.35,154.05 174.37,154.05 174.92,153.5 176.32,153.5 177.17,152.65 181.19,152.65 181.95,151.89 187.96,151.89 188.87,150.98 188.87,148.46 181.1,140.69 181.1,134.37 182.75,132.72 182.75,129.03 183.64,128.14 187.02,128.14 188.08,127.08 189.53,127.08 189.75,126.86 v2(189.76,126.86)
  ART16 w0.114: v1(202.69,123.22) 201.8,122.33 201.8,119.66 201.59,119.44 196.41,119.44 195.9,119.95 195.9,120.81 193.78,122.93 193.46,122.93 192.18,124.22 192.18,125.27 190.59,126.86 v2(189.76,126.86)
  ART18 w0.114: v2(38.38,145.41) 38.96,146 39.73,146 40.87,147.14 41.58,147.14 42.14,147.7 42.14,149.61 42.77,150.24 42.77,151.76 44.04,153.03 44.04,155.9 45.01,156.87 45.01,157.61 44.78,157.83 44.78,158.65 47.75,161.62 55.57,161.62 58.7,158.5 97.79,158.5 100.2,156.08 104.65,156.08 107.19,158.62 130.94,158.62 133.09,160.78 135.25,160.78 136.83,162.35 v2(136.83,162.89)
  BOTTOM w0.109: v1(202.69,123.22) 202.11,123.8 200.91,123.8 200.69,123.57 200.69,123.06 200.36,122.73 R641.1 ; R639.1 R640.1 31.4,147.26 31.93,147.78 34.18,147.78 35.91,146.05 37.64,146.05 38.28,145.41 v2(38.38,145.41)
EN0_3.3V_R: length 245.4
  ART03 w0.114: v1(204.09,188.72) v1(205.36,189.99)
  ART20 w0.114: v2(33.67,148.74) 32.84,149.57 32.84,154.12 35.1,156.39 35.1,158.01 38.14,161.05 38.14,162.27 39.54,163.67 39.54,163.96 40.74,165.16 40.74,167.31 40.94,167.51 42.06,167.51 42.32,167.77 42.32,168.05 42.62,168.35 43.01,168.35 43.13,168.46 43.13,169.7 42.92,169.9 42.52,169.9 42.34,170.08 42.34,170.51 42.14,170.71 41.63,170.71 41.53,170.81 41.53,180.21 41.66,180.34 59.61,180.34 59.87,180.09 67.94,180.09 68.71,180.85 69.85,180.85 70.71,179.98 70.71,179 71.21,178.5 71.21,169.2 77.72,162.69 96.65,162.69 100.2,166.24 105.16,166.24 108.58,162.81 129.92,162.81 131.06,161.67 133.1,161.67 135.13,159.64 162.94,159.64 163.58,160.27 166.37,160.27 168.91,162.81 172.09,162.81 173.63,164.36 173.63,164.97 174.4,165.74 175.51,165.74 179.32,169.54 182.63,169.54 183.77,170.69 183.77,177.8 187.53,181.56 194.72,181.56 196.34,183.18 201.7,183.18 202.46,183.94 203.8,183.94 204.27,184.42 204.27,184.74 204.73,185.2 204.73,186.23 204.09,186.87 v1(204.09,188.72)
  BOTTOM w0.109: R565.1 201.75,187.96 202.21,188.42 202.21,188.85 202.59,189.23 203.58,189.23 v1(204.09,188.72) ; R555.1 v2(33.67,148.74)
EN_1.2V: length 196.1
  TOP w0.109: v2(48.04,19.48) 47.53,18.97 R791.2 ; U23.T1 v2(44.34,165.52)
  ART03 w0.114: v2(19.84,54.56) 18.9,53.62 18.9,49 21.64,46.25 21.64,42.29 22.58,41.35 22.58,40.16 21.93,39.5 21.76,39.5 21.46,39.2 21.46,30.28 22.35,29.39 22.35,26.42 24.61,24.16 44.6,24.16 47.75,21.01 47.77,21.01 48.04,20.74 v2(48.04,19.48)
  ART05 w0.114: v2(19.84,54.56) 19.35,55.04 19.35,62.55 26.05,69.25 26.05,89.72 26.06,89.72 26.06,118.76 26.44,119.14 26.44,135.46 27.73,136.75 39.42,136.75 45.13,142.47 45.13,144.3 45.79,144.96 v3(45.79,145.11) 47.06,146.38 47.06,147.47 47.8,148.21 47.8,148.79 46.68,149.91 46.68,153.6 45.66,154.62 45.66,160.03 45.16,160.53 45.16,164.52 44.75,164.92 44.75,165.1 v2(44.34,165.52)
  BOTTOM w0.109: U25.10 45.15,144.46 v3(45.79,145.11)
EN_1.8V: length 317.2
  TOP w0.109: U23.P2 v2(42.74,166.32)
  ART05 w0.114: v2(42.74,166.32) 42.34,165.92 42.34,165.25 42.92,164.67 43.43,164.67 44.14,163.96 44.14,162.03 43.15,161.04 43.15,159.61 42.21,158.67 42.21,153.57 42.75,153.03 42.75,150.52 44.32,148.94 44.32,147.75 43.84,147.27 43.84,145.69 v3(43.25,145.11)
  ART07 w0.114: v2(161.93,26.49) 152.65,26.49 151.61,25.45 151.61,12.57 149.19,10.15 145.75,10.15 145.11,10.79 125.12,10.79 124.84,10.52 122.59,10.52 121.88,11.23 103.91,11.23 101.96,13.18 97.15,13.18 95.68,11.7 94.52,11.7 94.46,11.76 83.59,11.76 83.38,11.97 71.14,11.97 61.44,21.67 61.44,38.66 68.22,45.44 68.22,51.37 61.17,58.42 48.26,58.42 46.02,60.66 45.77,60.66 44.32,62.1 39.62,62.1 32.33,69.4 32.33,78.49 31.21,79.6 31.21,106.27 28.03,109.45 28.03,126.13 32.03,130.12 32.03,139.96 31.72,140.27 31.72,140.7 31.73,140.71 31.73,141.06 31.5,141.29 31.5,142.54 32.49,143.54 32.77,143.54 33.25,144.02 33.25,145.7 33.55,146 36.22,146 36.83,146.61 38.33,146.61 38.94,146 39.53,146 39.86,146.33 41.68,146.33 42.57,145.44 42.93,145.44 v3(43.25,145.11)
  BOTTOM w0.109: U25.8 43.88,144.48 v3(43.25,145.11) ; R770.2 v2(161.93,26.49)
EN_2.5V: length 269.8
  TOP w0.109: U23.L7 v2(40.34,170.32)
  ART05 w0.114: v2(95.22,22.83) 97.56,20.5 97.56,16.88 97.4,16.72 97.4,14.67 95.76,13.03 94.72,13.03 93.01,11.33 84.28,11.33 82.19,13.41 71.43,13.41 65.25,19.59 65.25,35.59 64.31,36.53 58.7,36.53 52.83,42.39 48.56,42.39 47.55,41.38 47.55,41.1 47.02,40.56 37.57,40.56 37.24,40.23 35.59,40.23 33.68,38.33 20.22,38.33 18.21,40.34 18.21,43.07 18.18,43.09 18.18,46.62 17.75,47.04 17.75,56.01 18.95,57.2 18.95,63.37 23.07,67.49 23.07,87.37 25.61,89.91 25.61,135.14 27.68,137.2 39.23,137.2 44.51,142.48 v3(44.51,144.24) 45.29,145.01 45.29,145.26 46.25,146.23 46.25,148.8 45.01,150.05 45.01,157.53 44.73,157.81 44.73,158.8 44.85,158.93 44.85,164.39 43.91,165.33 43.91,167.64 43.23,168.32 42.43,168.32 42.31,168.44 42.31,169.77 42.14,169.95 40.7,169.95 v2(40.34,170.32)
  BOTTOM w0.109: U25.9 v3(44.51,144.24) ; R779.2 v2(95.22,22.83)
EN_3.3V: length 33.5
  TOP w0.109: U23.G6 v2(36.33,169.52)
  ART05 w0.114: v3(29.94,145.29) 31.09,146.43 31.09,146.76 31.5,147.17 v2(31.5,148.18) 32.23,148.92 32.23,150.64 31.52,151.35 31.52,155.47 33.7,157.66 33.7,160.81 32.51,162 32.51,164.26 33.04,164.79 33.88,164.79 34.36,165.28 34.36,168.93 34.54,169.11 35.76,169.11 36.17,169.52 v2(36.33,169.52)
  BOTTOM w0.109: R555.2 31.56,148.25 v2(31.5,148.18) ; v3(29.94,145.29) 30.54,144.69 U24.3
EN_12V: length 229.7
  TOP w0.109: U23.D4 v2(33.94,167.92)
  TOP w0.305: R537.2 49.5,184.78 49.4,184.78 v2(49.28,184.91) ; R544.2 v2(180.67,194.97)
  ART05 w0.114: v2(33.94,167.92) 33.53,167.51 33.53,165.25 33.41,165.14 32.93,165.14 31.91,164.12 31.91,162.77 29.44,160.29 29.44,155.6 31.21,153.82 31.21,151.23 31.29,151.14 31.29,151.13 31.91,150.51 31.91,149.2 31.09,148.39 31.09,148.36 31.08,148.35 31.08,148.05 29.44,146.4 29.44,144.78 v3(29.91,144.31)
  ART05 w0.305: v2(49.28,184.91) 76.71,184.91 77.72,183.9 77.72,180.47 80.85,177.34 133.94,177.34 134.72,178.13 134.72,187.88 134.8,187.88 137.74,190.83 137.74,195.34 146.43,204.03 151.7,204.03 153.16,202.56 156.21,202.56 160.81,197.97 169.52,197.97 171.96,195.53 180.11,195.53 v2(180.67,194.97)
  ART20 w0.114: v2(49.28,184.91) 46.48,187.71 36.93,187.71 35.97,186.74 35.97,185.67 34.33,184.03 32.34,184.03 31.14,182.83 31.14,169.29 32.13,168.3 33.57,168.3 v2(33.94,167.92)
  BOTTOM w0.109: U24.2 v3(29.91,144.31)
EN_VCC_FPGA_VID: length 154.9
  TOP w0.109: U54.20 75.61,212.82 75.61,213.14 75.7,213.23 v2(75.7,213.95) 76.31,213.95 76.61,214.25 77.05,214.25 C1637.2 R1075.1 ; v2(32.4,165.21) 32.4,165.49 32.74,165.83 U23.B1
  ART05 w0.114: v2(32.4,165.21) 31.98,165.21 31.34,164.57 31.34,163.3 28.24,160.2 28.24,155.96 29.56,154.63 29.56,151.97 28.24,150.65 28.24,148.02 27.96,147.74 27.96,144.56 28.29,144.23 28.69,144.23 29.15,143.76 30.63,143.76 v3(31.18,144.31)
  ART16 w0.199: v2(75.7,213.95) 75.37,213.63 75.25,213.63 73.76,212.14 73.35,212.14 73.05,211.84 73.05,211.43 72.57,210.95 72.57,204.58 72.3,204.31 72.3,202.53 74.14,200.69 74.14,191.49 69.09,186.44 48.51,186.44 47.43,187.52 41.21,187.52 40.39,188.34 36.96,188.34 35.05,186.44 30.99,186.44 28.32,183.77 27.56,183.77 27.43,183.64 20.91,183.64 19.68,182.42 19.68,180.76 17.4,178.48 17.4,175.18 15.88,173.65 15.88,170.14 23.71,162.31 30.73,162.31 31.75,163.32 31.75,164.57 v2(32.4,165.21)
  BOTTOM w0.109: U24.4 v3(31.18,144.31)
EN_VCCCLK_GXE_FPGA_2.5V: length 41.2
  TOP w0.109: U23.M1 v2(41.14,165.52) ; R732.2 54.2,145.85 54.07,145.98 v2(54.07,146.43)
  ART05 w0.114: v2(41.14,165.52) 41.14,163.36 41.48,163.02 41.48,161.06 40.15,159.74 40.15,153.39 40.54,153.01 40.54,150.29 40.66,150.16 40.66,145.95 41.3,145.31 41.3,144.83 41.03,144.56 41.03,144.52 v3(40.7,144.19)
  ART07 w0.114: v2(54.07,146.43) 54.07,145.81 51.66,143.4 48.41,143.4 48.19,143.18 41.65,143.18 41.03,143.8 41.03,143.87 v3(40.7,144.19)
  BOTTOM w0.109: U25.3 v3(40.7,144.19)
EN_VCCFUSEWR_SDM_FPGA_2.4V: length 216.8
  TOP w0.109: U23.K8 v2(39.54,171.12) ; R740.2 v2(67.37,50.99)
  ART05 w0.114: v2(39.54,171.12) 39.95,170.7 39.95,168.45 40.1,168.3 40.54,168.3 40.71,168.12 40.71,165.35 40.82,165.25 40.82,163.37 40.49,163.04 40.49,162.36 40.82,162.03 40.82,161.01 39.79,159.98 39.79,158.05 39.11,157.38 39.11,156.44 39.44,156.11 39.44,154.31 39.53,154.22 39.53,153.88 39.44,153.79 39.44,151.32 39.88,150.87 39.88,148.85 39.44,148.4 39.44,147.29 39.93,146.81 39.93,145.9 v3(40.71,145.11) 40.71,144.98 40.1,144.37 40.1,141.81 36.2,137.9 27.1,137.9 24.62,135.41 24.62,126.24 24.26,125.89 24.26,123.39 24.16,123.28 24.16,90.12 22.56,88.52 22.56,88.44 22.45,88.34 22.45,67.94 18.03,63.52 18.03,58.29 15.9,56.16 15.9,50.98 15.37,50.44 15.37,48.71 15.47,48.6 15.47,45.74 15.53,45.69 15.53,45.35 15.47,45.3 15.47,44.38 15.34,44.25 15.34,40.46 15.72,40.08 16.15,40.08 20.44,35.79 33.93,35.79 36.07,37.92 48.95,37.92 50.22,39.19 50.77,39.19 51.64,40.06 51.64,40.24 v2(52.8,41.4)
  ART07 w0.114: v2(52.8,41.4) 63.09,41.4 67.37,45.68 v2(67.37,50.99)
  BOTTOM w0.109: U25.4 41.34,144.48 v3(40.71,145.11)
EN_VCCH_FPGA_0.9V: length 225.5
  TOP w0.109: U23.E5 v2(34.73,168.72) ; R1141.1 v2(173.05,177.8)
  ART05 w0.114: v3(31.19,145.49) 31.71,146.01 31.71,146.69 32.58,147.56 32.58,150.72 31.98,151.33 31.98,155.5 34.47,157.99 34.47,164.67 35.13,165.33 35.13,168.25 34.73,168.64 v2(34.73,168.72)
  ART20 w0.114: v2(34.73,168.72) 34.34,169.11 34.34,172.29 34.77,172.72 36.42,172.72 36.74,173.04 36.74,180.12 38.23,181.61 38.23,181.99 39.5,183.26 40.39,183.26 40.7,183.58 40.7,184.21 41.66,185.17 45.59,185.17 48.26,182.5 51.44,182.5 52.2,183.26 66.55,183.26 67.56,182.25 70.36,182.25 72.54,180.06 72.54,170.15 76.07,166.62 81.28,166.62 81.66,167 98.77,167 99.28,167.51 106.21,167.51 106.71,167 129.64,167 135.81,160.84 162.07,160.84 162.8,161.56 164.48,161.56 167.13,164.21 170.89,164.21 175.89,169.21 176.88,169.21 177.42,169.75 177.42,170.49 180.81,173.88 180.81,178.08 180.5,178.39 174.96,178.39 174.37,177.8 v2(173.05,177.8)
  BOTTOM w0.109: v3(31.19,145.49) 31.81,144.87 U24.5
EN_VCCH_FPGA_0.9V_R: length 25.6
  TOP w0.109: R1140.1 v2(170.59,172.52) ; R1141.2 v2(170.51,177.8) ; R1130.2 v2(167.57,175.44)
  ART05 w0.114: v2(170.59,172.52) 171.63,173.56 171.63,176.68 v2(170.51,177.8) 170.35,177.96 169.53,177.96 167.57,176 v2(167.57,175.44) 157.73,175.44 v4(157,176.17) v4(155.73,174.9)
EN_VCCH_GXE_FPGA_1.1V: length 147.3
  TOP w0.109: U23.K2 v2(39.54,166.32)
  ART05 w0.114: v2(39.54,166.32) 39.95,165.9 39.95,165.02 39.52,164.59 39.52,163.02 39.34,162.84 39.34,160.63 37.18,158.47 37.18,157.52 36.7,157.04 36.7,152.68 36.08,152.06 36.08,151.76 34.97,150.65 34.97,149.43 35.76,148.64 35.76,145.08 v3(34.99,144.31) 35.46,143.84 35.46,140.18 34.22,138.94 27.05,138.94 24,135.89 24,128.18 22.89,127.07 22.89,122.36 22.4,121.87 22.4,89.38 21.67,88.65 21.67,88.53 21.66,88.53 21.66,81.62 21.67,81.62 21.67,68.15 17.32,63.8 17.32,58.93 14.81,56.41 14.81,50.6 14.96,50.44 14.96,46.43 14.66,46.13 9.78,46.13 8.53,44.88 v2(6.63,44.88)
  BOTTOM w0.109: U24.10 v3(34.99,144.31) ; R701.2 v2(6.63,44.88)
EN_VCCIO_FPGA_1.2V: length 27.1
  TOP w0.109: U23.F1 v2(35.53,165.52)
  ART05 w0.114: v2(35.53,165.52) 35.53,165.1 35.3,164.86 35.3,163.34 35.46,163.18 35.46,161.82 35.05,161.42 35.05,157.65 34.39,156.99 34.39,156.69 32.28,154.59 32.28,151.46 32.89,150.85 32.89,147.43 32.02,146.56 32.02,145.93 v3(32.46,145.49)
  BOTTOM w0.109: R662.1 32.62,145.49 v3(32.46,145.49) 33.08,144.87 U24.7
EN_VCCIO_FPGA_1.5V: length 157.7
  TOP w0.109: U23.L1 v2(40.34,165.52)
  ART05 w0.114: v2(40.34,165.52) 40.34,164.44 40.49,164.29 40.49,163.55 39.65,162.71 39.65,160.28 39.48,160.11 39.48,159.39 37.01,156.92 37.01,152.55 36.39,151.94 36.39,151.63 35.28,150.52 35.28,149.61 36.07,148.82 36.07,145.23 37.03,144.27 v3(39.57,144.27) 39.57,143.58 34.62,138.63 27.3,138.63 24.31,135.64 24.31,126.37 23.27,125.32 23.27,123.56 23.63,123.2 23.63,90.06 21.97,88.41 21.97,68.02 21.97,68.02 21.97,67.93 17.7,63.66 17.7,58.6 15.34,56.24 v2(15.34,51.41)
  ART07 w0.114: v2(15.34,51.41) 17.09,49.66 30.15,49.66 v2(33.6,46.2)
  BOTTOM w0.109: v2(33.6,46.2) 33.86,45.95 R722.2 ; v3(39.57,144.27) 40.07,143.77 U25.2
EN_VCCIO_FPGA_1.8V: length 56.2
  TOP w0.109: U23.K4 v2(39.54,167.92)
  ART03 w0.114: v3(35,145.49) 34.44,144.93 34.44,144.22 33.68,143.46 32.77,143.46 26.97,137.67 26.97,130.56 28.45,129.09 28.45,125.46 27.67,124.68 27.67,124.4 27.55,124.28 27.41,124.28 27.4,124.28 27.26,124.28 v2(27.09,124.1)
  ART05 w0.114: v2(39.54,167.92) 38.94,167.33 38.94,164.74 38.61,164.41 38,164.41 37.67,164.08 37.67,163.32 38.07,162.91 38.07,159.8 36.87,158.59 36.87,157.68 35.78,156.58 35.78,151.89 34.67,150.78 34.67,149.3 35.45,148.52 35.45,145.95 v3(35,145.49)
  BOTTOM w0.109: U24.11 35.62,144.87 v3(35,145.49) ; R1014.2 v2(27.09,124.1)
EN_VCCL_HPS_FPGA_0.9V: length 147.5
  TOP w0.109: v2(25.25,44.15) 25.25,45.63 23.15,47.73 19.81,47.73 19.25,48.29 19.25,48.97 17.25,50.98 v2(14.17,50.98) ; v2(37.93,167.12) 38.33,166.72 U23.J2
  ART05 w0.109: v2(37.93,167.12) 38.4,166.65 38.4,165.02
  ART05 w0.114: v2(14.17,50.98) 14.17,56.39 16.99,59.2 16.99,63.96 21.36,68.33 21.36,81.49 21.36,81.49 21.36,88.66 21.36,88.66 21.36,88.77 21.44,88.85 21.44,88.88 21.87,89.31 21.87,120.35 21.08,121.14 21.08,125.95 23.7,128.57 23.7,136.02 26.93,139.25 28.66,139.25 v3(33.72,144.31) 34.44,145.03 34.44,149.09 34.36,149.18 34.36,151.85 35.43,152.92 35.43,156.67 36.57,157.81 36.57,158.72 37.77,159.92 37.77,162.36 36.8,163.32 36.8,163.58 36.8,163.58 36.8,163.92 36.8,163.93 36.8,164.21 37.34,164.74 38.12,164.74 38.4,165.02
  BOTTOM w0.109: R680.2 25.03,43.93 v2(25.25,44.15) ; U24.8 v3(33.72,144.31)
EN_VCCL_SDM_FPGA_0.8V: length 275.7
  TOP w0.109: U23.J6 v2(37.93,169.52)
  ART05 w0.114: v2(37.93,169.52) 37.51,169.1 37.51,165.89 35.91,164.28 35.91,163.6 36.15,163.35 36.31,163.35 36.8,162.86 36.8,159.39 36.26,158.85 36.26,157.93 35.03,156.7 35.03,156.44 33.78,155.19 33.78,149.21 34.14,148.86 34.14,145.9 v3(33.73,145.49)
  ART07 w0.114: v2(140.11,22.83) 139.85,23.09 124.82,23.09 121.44,19.71 120.93,19.71 119.84,18.62 119.84,17.86 115.86,13.87 112.95,13.87 112.55,14.27 97.1,14.27 95.5,12.67 92.79,12.67 92.39,13.07 83.5,13.07 83.16,13.41 70.2,13.41 61.8,21.81 61.8,38.51 68.53,45.24 68.53,51.49 61.24,58.77 48.41,58.77 45.97,61.21 45.97,61.98 45.47,62.48 40.15,62.48 32.66,69.98 32.66,78.62 31.54,79.74 31.54,106.41 28.35,109.61 28.35,109.68 28.34,109.68 28.34,125.8 33.43,130.89 33.43,136.86 35.61,139.04 35.61,142.11 34.52,143.2 34.52,144.69 v3(33.73,145.49)
  BOTTOM w0.109: U24.9 34.35,144.87 v3(33.73,145.49) ; R693.2 v2(140.11,22.83)
EN_VCCPT_FPGA_1.8V: length 29.6
  TOP w0.109: U23.G3 v2(36.33,167.12)
  ART05 w0.089: 35.94,165.02 35.96,165.05
  ART05 w0.114: v2(36.33,167.12) 36.33,166.94 35.96,166.57 35.96,165.05 ; v3(32.45,144.31) 33.2,145.06 33.2,151.8 32.59,152.41 32.59,154.46 34.7,156.56 34.7,156.81 35.35,157.46 35.35,161.29 35.83,161.77 35.83,163.24 35.6,163.47 35.6,164.69 35.94,165.02
  BOTTOM w0.109: R640.2 31.72,145.99 31.72,145.41 32.45,144.69 v3(32.45,144.31) U24.6
EN_VDD_SODIMM: length 284.2
  TOP w0.109: U23.R3 v2(43.53,167.12)
  ART05 w0.114: v2(115.37,22.83) 115.14,23.06 104.45,23.06 103.56,22.17 103.56,15.8 101.9,14.15 97.74,14.15 94.54,10.95 83.85,10.95 82.78,12.01 72.11,12.01 64.87,19.26 64.87,35.38 64.26,35.99 58.8,35.99 52.8,41.99 50.78,41.99 50.16,41.36 50.16,41.04 48.39,39.27 35.89,39.27 33.73,37.11 20.42,37.11 16.59,40.94 16.59,42.72 15.85,43.46 15.85,45.97 16.64,46.76 16.64,55.88 18.39,57.64 18.39,63.37 22.76,67.74 22.76,88.21 24.46,89.91 24.46,123.15 24.57,123.26 24.57,125.76 24.92,126.11 24.92,135.19 27.33,137.59 37.9,137.59 43.24,142.94 v3(43.24,144.24) 43.24,144.36 44.35,145.46 44.35,146.23 45.77,147.65 45.77,148.51 43.21,151.07 43.21,154.09 42.97,154.33 42.97,156.77 42.64,157.1 42.64,157.45 42.97,157.78 42.97,158.9 43.46,159.39 43.46,160.76 44.47,161.77 44.47,164.18 43.65,165.01 43.37,165.01 43.13,165.25 43.13,166.72 v2(43.53,167.12)
  BOTTOM w0.109: R754.2 v2(115.37,22.83) ; U25.7 v3(43.24,144.24)
EN_VTT_DDR4_0.6V: length 162
  TOP w0.127: U23.N1 v2(41.93,165.52)
  ART03 w0.114: v2(128.76,156.09) 131.28,156.09 131.95,155.42 131.95,153.9 132.35,153.5 146.73,153.5 148.11,152.12 148.11,147.96 142.47,142.32 141.81,142.32 141.01,141.52 141.01,140.34 v2(141.88,139.47)
  ART05 w0.114: v3(41.97,144.24) 42.54,144.8 42.54,145.36 41.63,146.28 41.63,147.33 42.12,147.83 42.12,151.47 41.42,152.17 41.42,153.26 40.98,153.71 40.98,157.92 42.71,159.65 42.71,161.4 42.43,161.67 42.43,162.05 42.98,162.6 42.98,162.92 43.18,163.12 43.18,164.06 42.9,164.34 42.57,164.34 41.93,164.97 v2(41.93,165.52)
  ART20 w0.114: v2(41.93,165.52) 41.93,165.53 42.32,165.91 42.32,166.47 42.56,166.71 46.92,166.71 48.08,167.87 49.05,167.87 49.31,167.62 50.03,167.62 50.77,168.36 51.35,168.36 53.21,166.5 56.13,166.5 65.99,156.64 97.46,156.64 99.16,154.94 105.26,154.94 106.14,155.83 111.12,155.83 111.38,155.57 116.46,155.57 118.11,157.23 128.98,157.23 129.23,156.97 129.23,156.58 128.76,156.11 v2(128.76,156.09)
  BOTTOM w0.109: U25.5 v3(41.97,144.24)
  BOTTOM w0.254: R766.2 v2(141.88,139.47)
EN_VTT_SODIMM_0.6V: length 166.9
  TOP w0.109: U23.M4 v2(41.14,167.92)
  ART05 w0.114: v2(41.14,167.92) 41.53,167.53 41.53,164.74 42.06,164.21 42.06,163.68 42.57,163.17 42.57,162.86 41.78,162.08 41.78,160.93 41.68,160.83 41.68,160.1 41.6,160.02 41.6,159.49 40.6,158.48 40.6,153.58 40.97,153.21 40.97,150.52 41.17,150.32 41.17,146.1 41.98,145.29 v3(41.98,145.11)
  ART07 w0.114: v3(41.98,145.11) 41.21,145.88 40.39,145.88 39.01,144.5 39.01,143.66 41.04,141.63 41.04,130.77 39.92,129.64 33.37,129.64 28.65,124.92 28.65,109.81 31.9,106.56 31.9,79.89 33.02,78.77 33.02,70.49 40.64,62.87 45.85,62.87 46.35,62.36 46.35,61.34 48.57,59.13 61.32,59.13 70.29,50.16 v3(73.6,50.16)
  BOTTOM w0.109: v3(41.98,145.11) 42.61,144.48 U25.6
ETH_INTN: length 268.4
  TOP w0.109: U16.A3 36.64,20.07 v2(36.77,20.19)
  ART16 w0.114: v2(160.4,73.28) 160.02,72.9 149.86,72.9 149.22,73.53 139.32,73.53 138.81,73.03 137.67,73.03 136.78,73.91 136.78,76.58 132.53,80.83 132.53,85.65 v2(132.98,86.1)
  ART20 w0.114: v2(160.4,73.28) 160.4,71.88 160.66,71.63 160.66,65.15 157.89,62.38 157.89,60.99 155.88,58.98 155.88,56.64 158.75,53.78 158.75,42.82 162.12,39.45 167.72,39.45 168.37,38.79 168.37,15.47 164.31,11.41 162.53,11.41 157.71,6.59 147.09,6.59 146.35,5.84 121.89,5.84 117.75,9.98 114.66,9.98 113.98,10.67 109.26,10.67 105.13,6.54 49.83,6.54 45.63,10.74 45.63,11.47 44.22,12.88 41.22,12.88 40.64,13.46 31.9,13.46 31.06,14.3 31.06,19.13 31.44,19.51 36.08,19.51 v2(36.77,20.19)
ETH_IO_TSN: length 311
  TOP w0.109: v2(35.31,18.1) R251.1
  ART16 w0.089: v2(164.27,99.18) 163.45,99.18
  ART16 w0.114: v2(151.9,97.12) 151.9,102.29 153.49,103.89 160.94,103.89 162.02,102.8 162.02,101.98 162.79,101.22 162.79,99.84 163.45,99.18
  ART20 w0.114: v2(151.9,97.12) 151.9,92.58 153.29,91.19 153.29,79.15 157.38,75.06 161.16,75.06 161.98,74.24 161.98,61.52 159.74,59.28 159.74,43.81 162.91,40.64 168.43,40.64 170.59,38.48 170.59,15.62 167.95,12.98 167.36,12.98 164.87,10.49 162.92,10.49 158.09,5.66 147.55,5.66 144.04,2.16 120.9,2.16 119.3,3.76 119.3,6.4 116.71,8.99 109.1,8.99 105.58,5.47 49.53,5.47 46.92,8.08 46.89,8.1 46.02,8.97 41.15,8.97 38.96,6.78 29.31,6.78 27.33,8.76 27.33,10.85 28.37,11.89 28.37,19.02 29.16,19.81 29.16,21.77 31.04,23.65 37.79,23.65 38.33,23.11 38.33,18.54 37.88,18.1 v2(35.31,18.1)
  BOTTOM w0.109: v2(35.31,18.1) 35.31,19.38 v2(34.67,20.01)
ETH_LED_LINK10: length 26.3
  TOP w0.109: v2(23.75,9.65) 24.29,10.2 U15.59 ; v2(27.79,13) 28.25,12.54 U15.76
  ART03 w0.114: v2(23.75,9.65) 24.13,9.27 29.06,9.27 29.44,9.65 30.07,9.65 30.45,10.03 30.45,10.79 30.04,11.2 29.59,11.2 v2(27.79,13)
  BOTTOM w0.163: R267.1 38.01,9.03 37.52,9.52 33.91,9.52 33.35,10.08 31.07,10.08 29.8,11.35 29.44,11.35 v2(27.79,13)
ETH_LED_LINK100: length 7.5
  TOP w0.163: U15.74 28.99,11.39 v2(29.91,10.48)
  BOTTOM w0.163: v2(29.91,10.48) 30.85,9.53 33.04,9.53 33.79,8.77 R266.1
ETH_LED_LINK1000: length 11
  TOP w0.109: U15.73 28.49,10.8 28.75,10.54 v2(29.09,10.54) ; U15.60 24.59,11.98 v2(24.26,12.32)
  ART03 w0.114: v2(24.26,12.32) 24.82,11.76 27.87,11.76 28.75,10.87 28.76,10.87 v2(29.09,10.54)
  BOTTOM w0.163: v2(29.09,10.54) 29.42,10.21 29.42,9.97 30.62,8.76 R265.1
ETH_LED_RX: length 9.9
  TOP w0.109: v2(23.43,12.38) 23.99,11.82 U15.58 ; v2(27.78,9.75) 27.29,10.24 U15.69
  ART03 w0.114: v2(27.78,9.75) 27.18,10.35 27.18,11.01 26.87,11.32 24.5,11.32 v2(23.43,12.38)
  BOTTOM w0.163: R264.1 28.74,9.27 28.26,9.75 v2(27.78,9.75)
ETH_LED_TX: length 4.5
  TOP w0.109: U15.68 26.99,11.98 27.07,12.06 v2(27.07,12.29)
  BOTTOM w0.163: R263.1 27.15,9.46 27.15,11.7 27.04,11.8 27.04,12.03 27.06,12.05 27.06,12.28 v2(27.07,12.29)
ETH_MDC: length 284.8
  TOP w0.109: U16.A2 36,20.57 v2(36.77,21.34)
  ART16 w0.114: v2(127.78,87.1) 128.24,86.64 128.24,81.15 129.13,80.26 132.5,80.26 136.4,76.37 136.4,73.66 141.38,68.68 145.77,68.68 149.61,72.52 160.66,72.52 v2(160.91,72.77)
  ART20 w0.114: v2(160.91,72.77) 160.91,71.88 161.04,71.75 161.04,64.9 158.24,62.1 158.24,60.76 156.34,58.85 156.34,56.77 159.05,54.05 159.05,43.2 162.43,39.83 168.07,39.83 168.88,39.02 168.88,15.55 164.44,11.1 162.66,11.1 157.84,6.28 147.22,6.28 146.4,5.46 121.64,5.46 117.45,9.65 108.68,9.65 105.26,6.23 49.64,6.23 47.31,8.56 47.28,8.58 46.28,9.58 40.89,9.58 40.89,9.58 40.56,9.58 40.56,9.58 38.43,9.58 36.55,7.69 36.47,7.62 31.21,7.62 30.43,8.41 30.43,10.69 29.03,12.09 29.03,17.6 30.12,18.69 30.12,19.61 30.83,20.32 30.86,20.32 31.37,20.83 32.81,20.83 33.12,21.13 36.56,21.13 v2(36.77,21.34)
ETH_MDIO: length 296.9
  TOP w0.109: v2(36.77,22.61) 35.23,21.07 U16.A1
  ART16 w0.114: v2(124.32,90.1) 124.32,89.78 125.07,89.03 125.45,89.03 125.83,88.65 126.21,88.65 126.72,88.14 126.97,88.14 127.35,87.76 127.35,80.9 128.37,79.88 132.27,79.88 134.49,77.66 134.49,74.93 141.14,68.28 145.88,68.28 149.73,72.14 161.29,72.14 v2(161.42,72.26)
  ART20 w0.114: v2(36.77,22.61) 36.44,22.94 33.45,22.94 32.53,22.02 31.04,22.02 29.99,20.98 29.99,20.04 28.7,18.74 28.7,10.95 28.55,10.8 28.55,8.63 30.02,7.16 38.58,7.16 40.69,9.27 41.02,9.27 41.02,9.27 46.15,9.27 47.09,8.34 47.11,8.32 49.58,5.85 105.42,5.85 108.89,9.32 117.01,9.32 119.81,6.52 119.81,4.04 121.06,2.79 144.17,2.79 147.35,5.97 157.96,5.97 162.79,10.8 164.74,10.8 170.28,16.34 170.28,38.35 168.37,40.26 162.76,40.26 159.43,43.59 159.43,59.74 161.42,61.72 v2(161.42,72.26)
ETH_RSET: length 0.6
  TOP w0.109: U15.30 21.51,17.22 v2(21.97,17.22)
ETH_RSTN: length 257.2
  TOP w0.109: v2(36.77,18.8) 35.99,19.57 U16.A4
  ART16 w0.114: v2(159.64,73.66) 159.38,73.91 138.94,73.91 138.56,73.53 137.83,73.53 137.29,74.08 137.29,76.71 133.43,80.57 133.43,86.65 v2(132.98,87.1)
  ART20 w0.114: v2(36.77,18.8) 35.28,18.8 34.77,18.29 33.5,18.29 32.26,17.05 32.26,14.63 32.76,14.13 44.29,14.13 44.93,13.49 44.93,12.62 45.95,11.6 45.95,10.87 49.96,6.86 104.57,6.86 108.79,11.07 114.02,11.07 114.8,10.3 118.5,10.3 122.58,6.22 145.95,6.22 146.81,7.09 157.76,7.09 163.12,12.45 163.12,13.23 165.57,15.68 165.57,34.97 158.29,42.24 158.29,53.75 155.45,56.59 155.45,59.28 157.56,61.39 157.56,62.56 160.27,65.28 160.27,71.5 159.64,72.14 v2(159.64,73.66)
ETH_SGMII_RXN: length 129.4
  TOP w0.089: v3(33.5,12.08) 33.15,12.43 32.94,12.43 C631.2
  ART16 w0.094: v2(102.67,89.6) 102.67,89.36 102.55,89.24 101.59,89.24 101.22,88.87 101.22,88.47 100.33,87.58 100.33,85.37 100.58,85.12 100.58,82.89 99.67,81.97 99.67,80.59 97.84,78.77 94.59,78.77 90.35,74.52 89.22,74.52 80.53,65.84 67.36,65.84 62.33,60.81 62.33,54.61 61.67,53.95 61.67,48.44 60.93,47.7 56.72,47.7 51.18,42.16 51.18,34.08 52.43,32.83 52.43,26.68 42.59,16.84 39.72,16.84 36.79,13.92 32.95,13.92 32.53,13.5 32.53,12.7 32.84,12.4 33.19,12.4 v3(33.5,12.08)
  BOTTOM w0.089: R40.2 102.61,89.66 v2(102.67,89.6) ; v3(33.5,12.08) 33.16,12.42 32.93,12.42 C631.2
ETH_SGMII_RXP: length 129.4
  TOP w0.089: v3(33.5,12.96) 33.26,12.72 32.94,12.72 C630.2
  ART16 w0.094: v2(102.67,88.6) 102.67,88.95 102.57,89.04 102.34,89.04 102.24,88.93 102.05,88.93 101.94,89.04 101.68,89.04 101.42,88.78 101.42,88.38 100.53,87.5 100.53,85.46 100.79,85.2 100.79,82.8 99.87,81.89 99.87,80.51 97.92,78.56 94.68,78.56 90.44,74.32 89.3,74.32 80.62,65.63 67.44,65.63 62.53,60.72 62.53,60.4 62.64,60.29 62.64,60.11 62.53,60 62.53,54.53 61.87,53.87 61.87,48.35 61.02,47.5 56.8,47.5 51.38,42.08 51.38,34.17 52.63,32.92 52.63,26.6 42.67,16.64 39.8,16.64 36.88,13.72 36.26,13.72 36.15,13.61 35.96,13.61 35.86,13.72 35.67,13.72 35.56,13.61 35.37,13.61 35.27,13.72 35.08,13.72 34.97,13.61 34.79,13.61 34.68,13.72 34.49,13.72 34.38,13.61 34.2,13.61 34.09,13.72 33.88,13.72 33.77,13.61 33.59,13.61 33.48,13.72 33.04,13.72 32.74,13.42 32.74,12.79 32.93,12.6 33.14,12.6 v3(33.5,12.96)
  BOTTOM w0.089: R23.1 102.55,88.77 R46.2 ; v3(33.5,12.96) 33.28,12.74 32.92,12.74 C630.2
ETH_SGMII_TXN: length 125.8
  TOP w0.089: C629.2 32.45,14.8 32.62,14.97 33.03,14.97 v3(33.4,14.6)
  ART16 w0.094: v2(103.53,90.1) 103.53,89.77 103.6,89.71 arc(103.76,89.77) 103.88,89.9 103.88,89.9 arc(103.93,90.1) 103.88,90.3 103.07,91.11 102.36,91.11 102.19,90.93 102.19,90.78 102.05,90.65 101.9,90.65 101.77,90.52 101.77,90.37 101.64,90.23 101.49,90.23 101.35,90.1 101.35,89.95 101.22,89.82 101.07,89.82 100.94,89.68 100.94,89.53 100.8,89.4 100.65,89.4 100.52,89.27 100.52,89.12 100.39,88.98 100.24,88.98 100.1,88.85 100.1,88.7 99.97,88.57 99.82,88.57 99.69,88.43 99.69,88.28 99.55,88.15 99.4,88.15 99.27,88.02 99.27,87.87 99.14,87.73 99.01,87.73 98.92,87.64 98.92,86.89 99.81,86 99.81,85.37 98.92,84.49 98.92,80.85 97.65,79.58 90.92,79.58 86.68,75.34 74.16,75.34 61.51,62.69 61.51,57.56 60.35,56.4 60.35,54.38 53.95,47.98 53.95,46.52 50.11,42.69 50.11,32.63 49.61,32.12 49.61,24.86 42.6,17.86 39.62,17.86 36.7,14.94 33.74,14.94 v3(33.4,14.6)
ETH_SGMII_TXP: length 125.7
  TOP w0.089: C628.2 32.45,15.45 32.65,15.26 33.18,15.26 v3(33.4,15.48)
  ART16 w0.094: v2(103.53,89.1) 103.53,89.43 103.61,89.5 arc(103.62,89.51) 103.63,89.51 arc(103.88,89.61) 104.05,89.8 arc(104.13,90.1) 104.05,90.4 103.14,91.31 102.28,91.31 98.93,87.97 98.93,87.94 98.72,87.72 98.72,86.81 99.61,85.92 99.61,85.46 98.72,84.57 98.72,80.94 97.56,79.78 90.84,79.78 86.59,75.54 74.07,75.54 61.3,62.77 61.3,57.65 60.14,56.49 60.14,54.46 53.75,48.06 53.75,46.61 49.91,42.77 49.91,32.72 49.4,32.21 49.4,24.94 42.52,18.06 39.53,18.06 36.61,15.14 33.74,15.14 v3(33.4,15.48)
ETH_T_INTN: length 14.4
  TOP w0.109: v2(22.48,20.83) 21.89,20.24 U15.23
  TOP w0.163: U16.C3 32.45,20.07 v2(32.45,20.07)
  ART03 w0.114: v2(22.48,20.83) 24,19.3 28.98,19.3 29.11,19.43 31.81,19.43 v2(32.45,20.07)
ETH_T_RSTN: length 15.4
  TOP w0.109: R1000.2 32.42,18.77 v2(32.45,18.8) ; v2(23.14,18.08) 22.53,18.08 22.1,17.65 21.84,17.65 21.55,17.94 U15.28
  TOP w0.163: U16.C4 33.22,19.57 v2(32.45,18.8)
  ART03 w0.114: v2(32.45,18.8) 31.84,18.19 29.03,18.19 28.47,18.75 23.8,18.75 v2(23.14,18.08)
ETH_T_SGMII_RXN: length 2.8
  TOP w0.089: C631.1 31.08,12.41 29.2,12.41 29.03,12.24 U15.75
ETH_T_SGMII_RXP: length 2.8
  TOP w0.089: U15.77 29.04,12.84 29.18,12.7 31.05,12.7 C630.1
ETH_T_SGMII_TXN: length 3.8
  TOP w0.089: U15.81 29.61,14.04 29.79,14.22 30.06,14.22 30.18,14.34 30.18,14.61 30.44,14.87 31.08,14.87 31.34,15.13 31.47,15.13 31.56,15.04 C629.1
ETH_T_SGMII_TXP: length 3.8
  TOP w0.089: U15.82 29.51,14.34 30.32,15.15 30.96,15.15 C628.1
ETH_XTAL_25MHZ: length 3
  TOP w0.163: X1.3 23.09,8.37 U15.55
EXT_JTAG_TCK: length 77.6
  TOP w0.109: J19.1 12.71,146.05 R356.1 ; U23.N14 v2(41.93,176.72)
  ART18 w0.114: v2(41.93,176.72) 41.7,176.72 41.27,177.14 40.94,177.14 40.74,177.34 40.74,180.34 39.98,181.1 38.9,181.1 38.23,181.77 38.23,182.07 37.99,182.31 37.97,182.31 37.71,182.57 30.15,182.57 28.14,180.57 27.93,180.57 27.5,180.14 21.23,180.14 20.97,179.88 19.85,179.88 19.74,179.98 18.77,179.98 17.35,178.56 17.35,175.44 17.33,175.43 17.33,175.42 17.16,175.25 17.16,167.38 16.23,166.45 16.23,163.98 13.28,161.04 13.28,153.98 13.59,153.67 13.59,151.71 11.07,149.2 11.07,147.42 J19.1
  BOTTOM w0.109: v2(41.93,176.72) 42.35,177.14 46.76,177.14 47.12,177.5 R353.2
EXT_JTAG_TDI: length 68.4
  TOP w0.109: U23.R16 v2(43.53,178.32)
  ART18 w0.114: J19.9 11.58,156.21 11.77,156.4 11.77,157.92 11.66,158.04 10.42,158.04 10.31,158.15 10.31,158.38 10.42,158.49 11.66,158.49 11.77,158.61 11.77,158.84 11.66,158.95 10.42,158.95 10.31,159.06 10.31,159.29 10.42,159.41 11.66,159.41 11.77,159.52 11.77,163.97 12.95,165.15 13.94,165.15 14.83,166.04 14.83,167.05 15.9,168.12 15.9,174.58 15.9,174.58 15.9,175.77 16.08,175.94 16.08,180.42 18.03,182.37 26.21,182.37 26.59,182.75 27.96,182.75 29.64,184.43 38.55,184.43 39.89,183.09 41.64,183.09 43.15,181.58 43.15,178.69 v2(43.53,178.32)
  BOTTOM w0.127: v2(43.53,178.32) 43.43,178.22 R349.1
EXT_JTAG_TDO: length 71.3
  TOP w0.109: U23.T16 v2(44.34,178.32)
  ART18 w0.114: v2(44.34,178.32) 43.92,177.9 42.64,177.9 42.36,178.18 42.36,180.16 41.09,181.43 40.79,181.43 40.41,181.81 40.41,181.81 38.35,183.87 30.02,183.87 28.01,181.86 26.61,181.86 26.24,181.48 25.98,181.48 25.97,181.48 21.73,181.48 21.25,181.95 19.24,181.95 18.67,181.38 18.18,181.38 16.51,179.7 16.51,175.79 16.49,175.78 16.49,175.77 16.32,175.59 16.32,174.4 16.32,174.4 16.32,167.85 15.29,166.83 15.29,164.97 14.88,164.57 13.23,164.57 12.37,163.7 12.37,153.9 10.84,152.37 8.99,152.37 8.46,151.84 8.46,150.49 9.7,149.25 J19.3
EXT_JTAG_TMS: length 70.7
  TOP w0.109: U23.P14 v2(42.74,176.72)
  ART18 w0.114: v2(42.74,176.72) 42.74,176.87 42.34,177.27 42.34,177.75 42.19,177.9 41.78,177.9 41.53,178.15 41.53,180.1 38.27,183.36 30.38,183.36 30.01,182.99 29.97,182.99 27.97,180.99 27.76,180.99 27.59,180.82 18.95,180.82 16.93,178.79 16.93,175.62 16.91,175.6 16.91,175.6 16.74,175.42 16.74,174.23 16.74,174.23 16.74,167.64 15.71,166.61 15.71,164.55 15.27,164.11 13.39,164.11 12.85,163.57 12.85,162.34 12.96,162.22 13.42,162.22 13.53,162.11 13.53,161.88 13.42,161.76 12.96,161.76 12.82,161.62 12.82,153.75 12.44,153.38 12.44,152.77 10.79,151.13 J19.5
  BOTTOM w0.109: R350.1 47.1,176.33 43.13,176.33 v2(42.74,176.72)
EXT_PROC_RSTN: length 76.4
  TOP w0.109: U23.M11 v2(41.14,174.32)
  ART18 w0.114: v2(41.14,174.32) 40.76,174.7 39.29,174.7 39.11,174.88 39.11,180.26 38.02,181.36 30.81,181.36 29.64,180.19 29.45,180.19 29.38,180.12 28.08,180.12 27.58,179.63 21.36,179.63 18.43,176.7 18.43,171.62 18.36,171.54 18.36,171.52 17.6,170.76 17.6,166.69 18.04,166.26 18.04,165 13.94,160.91 13.94,154.05 14.66,153.34 14.66,151.54 11.56,148.44 11.56,145.7 10.51,144.65 8.86,144.65 8.35,145.16 8.35,149.94 J19.6
EXT_RESERVED: length 79.8
  TOP w0.109: U23.M12 v2(41.14,175.12)
  ART18 w0.114: v2(41.14,175.12) 41.53,175.51 44.59,175.51 44.7,175.63 44.7,181.63 44.55,181.79 44.55,183.37 44.14,183.79 44.14,184.22 40.78,187.58 35.91,187.58 35.41,187.07 29.83,187.07 27.68,184.92 27.67,184.92 26.97,184.23 15.72,184.23 14.07,182.57 14.07,178.23 14.32,177.98 14.32,171.19 11.85,168.72 11.85,166.14 5.84,160.13 5.84,154.99 J19.8
EXT_RESERVED1: length 68.2
  TOP w0.109: U23.T18 v2(44.34,179.92)
  ART18 w0.114: v2(44.34,179.92) 44.34,181.31 42.87,182.78 42.87,184.1 40.38,186.59 38.22,186.59 37.95,186.31 37.18,186.31 36.9,186.59 30.83,186.59 27.96,183.72 18.59,183.72 16.56,181.68 14.92,181.68 14.5,181.26 14.5,178.94 14.68,178.76 14.68,168.22 13.51,167.05 12.88,167.05 12.42,166.6 12.42,165.35 8.56,161.49 8.56,154.82 J19.7
F2M_I2C_SCL: length 75.9
  ART16 w0.114: v2(166.67,97.58) 166.27,97.18 163.73,97.18 161.47,99.44 161.47,102.77 161.03,103.2 155.16,103.2 153.48,101.52 153.48,97.75 152.25,96.52 151.51,96.52 v2(150.26,97.76)
  ART18 w0.114: v2(117.39,118.1) 117.39,117.83 118.04,117.18 118.49,117.18 118.96,116.71 119.28,116.71 119.57,117.01 120.13,117.01 120.18,116.96 120.61,116.52 120.62,116.52 120.66,116.49 121.01,116.49 121.46,116.04 121.46,116.04 121.48,116.02 121.83,116.02 121.87,115.99 121.88,115.99 122.38,115.49 122.75,115.49 123.21,115.02 123.58,115.02 124.08,114.52 124.45,114.52 124.92,114.05 124.92,114.05 124.98,113.99 125.34,113.99 125.84,113.49 129.31,113.49 129.81,112.99 130.54,112.99 131.02,112.51 131.03,112.51 131.05,112.49 131.41,112.49 131.88,112.01 132.17,112.01 133.05,111.14 133.96,111.14 134.31,111.49 134.87,111.49 135.18,111.18 135.8,111.18 136.46,110.51 136.84,110.51 137.22,110.14 137.53,110.14 138.03,109.64 138.4,109.64 138.71,109.32 138.71,109.32 139.93,108.11 139.93,103.5 140.65,102.78 143,102.78 148.5,97.28 149.78,97.28 v2(150.26,97.76)
  BOTTOM w0.109: R380.1 163.45,96.58
  BOTTOM w0.127: 163.45,96.58 164.05,97.18 166.27,97.18 166.67,97.58 v2(166.67,97.58)
F2M_I2C_SDA: length 79.5
  ART16 w0.114: v2(167.47,97.58) 167.08,97.19 167.08,96.65 166.85,96.42 163.68,96.42 161.01,99.08 161.01,99.87 160.09,100.79 158.54,100.79 156.82,102.51 155.06,102.51 153.9,101.35 153.9,97.54 152.25,95.88 151.48,95.88 150.34,97.03 v2(150.24,97.03)
  ART18 w0.114: v2(115.66,118.1) 115.66,117.92 116.36,117.21 116.73,117.21 117.25,116.69 117.79,116.69 118.09,116.99 118.42,116.99 118.64,116.76 118.64,116.44 118.89,116.19 119.22,116.19 119.73,115.68 121.05,115.68 121.05,115.68 121.09,115.68 121.58,115.19 121.95,115.19 121.96,115.18 121.96,115.18 122.45,114.69 122.81,114.69 123.33,114.18 123.69,114.18 123.7,114.17 123.7,114.17 123.93,113.95 123.93,113.94 124.16,113.71 124.52,113.71 124.99,113.24 125.02,113.21 125.39,113.21 125.89,112.71 126.21,112.71 126.24,112.74 126.73,113.23 128.92,113.23 129.95,112.2 130.6,112.2 131.08,111.71 131.57,111.71 132.07,111.21 132.36,111.21 132.84,110.73 133.17,110.73 133.68,110.21 133.83,110.21 134.52,109.52 134.95,109.52 135.41,109.99 135.78,109.99 136.28,109.49 136.6,109.49 136.83,109.26 136.83,108.53 137.15,108.21 137.15,108.21 137.22,108.14 137.53,108.14 138.03,107.64 138.52,107.64 139.5,106.66 139.5,101.72 140.47,100.75 143.93,100.75 147.83,96.85 150.06,96.85 v2(150.24,97.03)
  BOTTOM w0.109: R381.1 163.45,97.85
  BOTTOM w0.127: v2(167.47,97.58) 167.08,97.97 163.56,97.97 163.45,97.85
FAN_RPM: length 97.1
  ART18 w0.114: v2(164.27,89.58) 163.43,88.74 163.43,81.97 163.98,81.43 172.37,81.43 173.35,80.45 182.36,80.45 182.43,80.38 183.18,80.38 183.19,80.38 183.53,80.38 185.6,82.44 185.6,82.93 187.47,84.81 187.53,84.81 187.54,84.8 187.88,84.8 187.88,84.81 188.87,84.81 189.38,84.3 190.04,84.3 191.72,85.98 193.51,85.98 194.07,86.53 194.07,88.97 195.46,90.37 195.46,95.8 198.09,98.43 198.09,109.12 199.09,110.11 199.09,112.24 196.52,114.81 196.52,115.97 197.01,116.46 197.01,118.87 195.53,120.35 195.53,122.38 195.18,122.73 195.18,123.44 194.75,123.87 194.75,127.16 194.74,127.17 194.74,135.08 v2(194.01,135.81)
  BOTTOM w0.109: R401.1 193.69,135.94 193.88,135.94 v2(194.01,135.81)
FAULT: length 71.5
  TOP w0.203: v2(81.28,214.72) 81.12,214.87 R6043.1 78.98,213.64 76.4,213.64 76.21,213.45 ; 76.21,213.45 76.41,213.25 U54.18 ; 76.21,213.45 76.01,213.25 U54.19
  ART05 w0.199: v2(81.28,214.72) 80.4,213.84 79.73,213.84 78.69,212.8 78.69,212.51 78.64,212.46 78.64,208.53 79.32,207.85 79.32,207.85 79.56,207.6 79.96,207.6 80.23,207.33 80.23,206.94 81.05,206.12
  ART05 w0.203: v3(84.46,203.49) 83.82,204.14 82.07,204.14 81.05,205.16 81.05,206.12
  ART18 w0.199: v2(123.34,202.53) 122.01,203.86 115.83,203.86 114.94,202.97 112.19,202.97 v2(111.29,202.07) 111.29,201.43 111.71,201.02 111.71,200.1 110.3,198.69 106.16,198.69 105.15,199.69 100.58,199.69 98.06,202.22 v2(97.51,202.22) 97.24,202.49 92.56,202.49 90.42,200.36 86.02,200.36 85.14,201.24 85.14,202.81 v3(84.46,203.49)
FAULT0_N: length 3.1
  BOTTOM w0.109: R5316.1 204.25,187.95 204.57,188.27 204.57,189.51 v1(204.09,189.99)
FAULT0_N_1: length 3
  BOTTOM w0.109: R5338.1 202.93,122.52 203.18,122.76 203.18,124 v1(202.69,124.49)
FAULT1_N: length 1.1
  BOTTOM w0.109: R5317.1 203.05,188.49 v1(202.82,188.72)
FAULT1_N_1: length 1.1
  BOTTOM w0.109: R5339.1 201.7,122.94 v1(201.42,123.22)
FLASH_DC0_IO0: length 52
  TOP w0.109: J10.5 183.29,80.11 v2(182.6,80.8)
  ART05 w0.089: 178.55,87.57 178.66,87.45
  ART05 w0.114: v2(182.6,80.8) 180.39,83.01 180.39,85.72 178.66,87.45 ; 178.55,87.57 178.31,87.8 178.31,88.07 178,88.38 176.67,88.38 v2(176.27,88.78)
  ART16 w0.114: v2(142.09,81.28) 148.06,81.53 160.37,81.53 163.89,81.72 167.23,82 168.53,82.14 169.38,82.37 173.68,84.13 175.79,86.24 175.79,88.05 v2(176.27,88.78)
  BOTTOM w0.109: R961.2 v2(142.09,81.28)
FLASH_DC0_IO1: length 54.9
  TOP w0.109: v2(188.57,80.72) 189.18,80.11 J10.6
  ART03 w0.114: v2(188.57,80.72) 188,80.15 182.54,80.15 181.76,80.92 175.89,80.92 173.05,83.76 173.05,86.48 172.67,86.87 172.67,87.58 v2(173.07,87.98)
  ART16 w0.114: v2(144.5,88.9) 144.73,88.67 153.34,88.67 154.12,89.46 157.27,89.46 158.93,87.81 163.04,87.81 163.6,88.37 172.68,88.37 v2(173.07,87.98)
  BOTTOM w0.109: v2(144.5,88.9) R953.1
FLASH_DC0_IO2: length 56.7
  TOP w0.109: v2(189.68,83.03) 190.11,82.61 J10.16
  ART05 w0.114: v2(189.68,83.03) 188.22,83.03 187.89,82.7 185.21,82.7 183.74,84.17 182.4,84.17 182.01,84.56 182.01,85.01 179.32,87.71 179.32,88.09 178.23,89.18 175.31,89.18 175.06,88.93 175.06,88.37 v2(174.67,87.98)
  ART16 w0.114: v2(174.67,87.98) 174.27,87.58 174.27,87.05 174,86.79 173.97,86.79 172.95,85.77 166.86,85.77 160.33,83.38 159.89,83.31 159.82,83.31 159.81,83.3 151.44,83.3 149.69,85.04 143.4,85.04 v2(142.09,86.36)
  BOTTOM w0.109: v2(142.09,86.36) R957.1
FLASH_DC0_IO3: length 48.5
  TOP w0.109: J10.17 183.08,83.11 v2(182.6,82.63)
  ART03 w0.114: v2(174.67,87.18) 174.97,86.88 174.97,85.2 176.17,84 181.23,84 v2(182.6,82.63)
  ART16 w0.114: v2(142.09,85.09) 142.59,84.59 149.45,84.59 151.23,82.81 159.42,82.81 160.44,82.97 165.66,84.89 170.3,84.89 173.12,85.35 174.67,86.9 v2(174.67,87.18)
  BOTTOM w0.109: v2(142.09,85.09) R965.2
FLASH_DC0_IO4: length 52.8
  TOP w0.109: J10.8 189.41,80.61 v2(189.28,80.73)
  ART05 w0.114: v2(189.28,80.73) 188.81,80.26 181.93,80.26 178.5,83.69 178.5,84.43 177.47,85.47 177.47,85.72 176.76,86.44 176.27,86.44 175.13,87.58 174.49,87.58 174.27,87.8 174.27,88.18 174.05,88.39 173.45,88.39 v2(173.07,88.78)
  ART16 w0.114: v2(173.07,88.78) 172.65,89.2 172.08,89.2 171.88,89.41 171.88,89.74 171.65,89.97 163.73,89.97 163.34,90.35 159.51,90.35 159,90.85 151.91,90.85 151.23,90.17 v2(144.63,90.17)
  BOTTOM w0.109: R954.1 v2(144.63,90.17)
FLASH_DC0_IO5: length 50.3
  TOP w0.109: J10.9 183.73,81.11 183.56,81.28 183.03,81.28 v2(182.57,81.74)
  ART03 w0.114: v2(182.57,81.74) 182.26,81.42 176.01,81.42 173.63,83.8 173.63,86.94 v2(173.87,87.18)
  ART16 w0.114: v2(142.09,88.9) 142.85,88.14 153.49,88.14 154.37,89.02 156.69,89.02 158.75,86.97 162.99,86.97 163.6,87.58 173.47,87.58 v2(173.87,87.18)
  BOTTOM w0.109: v2(142.09,88.9) R963.2
FLASH_DC0_IO6: length 51
  TOP w0.109: J10.25 183.05,85.11 v2(182.55,84.61)
  ART03 w0.114: v2(182.55,84.61) 182.01,85.14 175.84,85.14 175.46,85.53 175.46,87.6 175.08,87.98 175.08,88.37 v2(174.67,88.78)
  ART16 w0.114: v2(142.09,83.82) 142.51,83.39 149.88,83.39 150.88,82.39 159.45,82.39 160.55,82.57 165.7,84.45 170.34,84.45 173.29,84.93 175.08,86.72 175.08,88.37 v2(174.67,88.78)
  BOTTOM w0.109: v2(142.09,83.82) R966.2
FLASH_DC0_IO7: length 51.2
  TOP w0.109: v2(182.6,83.59) 183.12,84.11 J10.21
  ART03 w0.114: v2(182.6,83.59) 182.98,83.97 182.98,84.81 181.99,85.8 178.33,85.8 178.06,86.08 176.76,86.08 175.89,86.94 175.89,87.86 175.47,88.28 v2(175.47,88.78)
  ART16 w0.114: v2(175.47,88.78) 175.44,88.75 175.44,86.48 173.46,84.51 170.41,83.95 166.93,83.95 164.55,83.59 160.65,82.16 159.48,81.97 145.51,81.97 v2(142.09,82.55)
  BOTTOM w0.109: v2(142.09,82.55) R967.2
FLASH_DC0_IO8: length 57
  TOP w0.109: v2(191.86,83.11) J10.18
  ART07 w0.114: v2(173.07,87.18) 173.98,86.27 175.29,83.46 176.59,82.17 186.94,82.17 187.25,82.47 191.22,82.47 v2(191.86,83.11)
  ART16 w0.114: v2(173.07,87.18) 172.94,87.05 172.94,86.9 172.55,86.51 171.99,86.51 171.79,86.71 166.37,86.71 165.4,86.36 161.45,84.91 157.2,83.95 153.12,83.95 150.68,86.39 143.32,86.39 v2(142.09,87.63)
  BOTTOM w0.109: v2(142.09,87.63) R958.1
FLASH_DC0_IO9: length 57.6
  TOP w0.109: v2(189.73,83.89) 189.73,83.89 190.01,83.61 J10.20
  ART07 w0.114: v2(189.73,83.89) 187.48,83.89 186.68,83.08 179.37,83.08 178.51,83.95 176.08,83.95 175.71,84.31 174.48,86.36 174.27,86.71 174.27,88.38 v2(173.87,88.78)
  ART16 w0.114: v2(142.14,92.58) 142.69,92.02 146.1,92.02 147.47,93.4 153.29,93.4 154.74,91.95 159.26,91.95 159.94,92.63 161.19,92.63 162.02,91.79 163.62,91.79 163.84,91.58 171.66,91.58 171.86,91.39 171.86,91 172.12,90.74 172.42,90.74 172.63,90.53 172.63,90.53 172.69,90.46 172.69,90.22 172.97,89.94 173.22,89.94 173.43,89.73 173.43,89.73 173.46,89.7 173.46,89.19 v2(173.87,88.78)
  BOTTOM w0.109: R959.1 142.01,92.71 v2(142.14,92.58)
FLASH_DC0_IO10: length 55
  TOP w0.109: v2(191.84,81.11) J10.10
  ART05 w0.114: v2(191.84,81.11) 190.46,83.86 190.17,84.15 189.84,84.3 189.61,84.3 189.13,84.53 188.1,85.55 182.41,87.21 181.41,88.21 181.39,88.21 178,91.59 172.66,91.59 v2(172.27,91.98)
  ART16 w0.114: v2(172.27,91.98) 171.86,92.39 171.86,92.98 171.65,93.19 164.13,93.19 163.35,93.98 162.63,93.98 162.6,93.95 161.5,93.95 161.1,94.35 144.99,94.35 v2(144.63,93.98)
  BOTTOM w0.109: R955.1 v2(144.63,93.98)
FLASH_DC0_IO11: length 54.2
  TOP w0.109: v2(185.89,84.53) 185.89,82.01 185.49,81.61 J10.11
  ART05 w0.114: v2(185.89,84.53) 184.29,86.13 182.78,86.13 178.13,90.78 172.11,90.78 171.88,91.01 171.88,92.37 v2(171.47,92.78)
  ART16 w0.114: v2(142.14,94.08) 143.02,93.19 144.75,93.19 145.44,93.88 160.83,93.88 161.95,92.76 163.55,92.76 163.93,92.38 171.07,92.38 v2(171.47,92.78)
  BOTTOM w0.109: R964.2 142.03,93.98 v2(142.14,94.08)
FLASH_DC0_IO12: length 56.9
  TOP w0.109: J10.12 189.96,81.61 v2(189.68,81.33)
  ART05 w0.114: v2(173.07,89.58) 173.46,89.97 178.33,89.97 180.18,88.11 180.18,87.47 182.48,85.17 183.66,85.17 185.22,83.61 188,83.61 188.14,83.48 189.91,83.48 190.35,83.04 190.35,81.99 v2(189.68,81.33)
  ART16 w0.114: v2(142.06,91.44) 142.54,90.96 144.8,90.96 145.31,91.46 161.41,91.46 161.52,91.36 163.45,91.36 164.03,90.78 171.63,90.78 171.9,90.5 171.9,90.22 172.11,90.02 172.46,90.02 172.9,89.58 v2(173.07,89.58)
  BOTTOM w0.109: R956.1 v2(142.06,91.44)
FLASH_DC0_IO13: length 50.8
  TOP w0.109: v2(183.34,81.71) 183.73,82.11 J10.13
  ART03 w0.114: v2(183.34,81.71) 182.86,82.19 180.97,82.19 180.86,82.31 180.86,82.74 180.75,82.85 180.52,82.85 180.4,82.74 180.4,82.31 180.29,82.19 180.06,82.19 179.95,82.31 179.95,82.74 179.83,82.85 179.6,82.85 179.49,82.74 179.49,82.31 179.37,82.19 177.04,82.19 174.27,84.96 174.27,87.35 174.04,87.58 173.66,87.58 173.51,87.73 173.51,87.83 173.51,88.13 173.28,88.37 172.68,88.37 v2(172.27,88.78)
  ART16 w0.114: v2(172.27,88.78) 172.02,88.78 171.62,89.18 160.93,89.18 160.83,89.08 158.72,89.08 157.92,89.88 153.71,89.88 153.57,89.74 142.52,89.74 v2(142.09,90.17)
  BOTTOM w0.109: R962.2 v2(142.09,90.17)
FLASH_DC0_IO14: length 53.8
  TOP w0.109: J10.24 189.83,84.61 189.71,84.73 v2(189.71,84.73)
  ART05 w0.114: v2(189.71,84.73) 188.36,85.9 185.23,89.03 182.42,89.03 178.66,91.88 177.94,92.39 172.88,92.39 v2(172.27,92.78)
  ART16 w0.114: v2(172.27,92.78) 172.27,93.01 171.85,93.42 171.85,93.75 171.63,93.98 163.95,93.98 163.17,94.77 162.61,94.77 162.6,94.77 162.26,94.77 162.25,94.77 142.57,94.77 v2(142.09,95.25)
  BOTTOM w0.109: v2(142.09,95.25) R960.1
FLASH_DC0_IO15: length 23.7
  TOP w0.109: v2(188.69,89.69) 188.49,89.48 188.49,86.36 189.66,85.19 190.09,85.19 190.17,85.11 J10.26
  ART03 w0.114: v2(188.69,89.69) 188.57,89.81 186.03,89.81 185.89,89.95 182.46,89.95 182.02,89.51 180.93,89.51 180.69,89.27 178.58,89.27 177.9,89.18 176.15,89.18 175.96,89.36 175.89,89.55 175.81,89.74 175.63,89.96 175.53,89.99 175.3,89.99 175.17,90.09 175.01,90.59 174.85,90.75 174.44,90.85 174.4,90.89 174.34,90.99 174.21,91.41 174.08,91.53 173.89,91.59 173.59,91.59 v2(173.07,91.98)
FLASH_DC0_IO16: length 20
  TOP w0.109: J10.28 191.78,85.61 192.78,86.61 v2(192.78,87.02)
  ART03 w0.114: v2(192.78,87.02) 192,86.23 181.2,86.23 181.06,86.37 178.55,86.37 178.46,86.46 176.99,86.46 v2(176.27,87.18)
FLASH_DC0_IO17: length 10.8
  TOP w0.109: v2(183.4,85.69) 183.82,86.11 J10.29
  ART07 w0.114: v2(183.4,85.69) 182.98,86.11 176.5,86.11 175.77,86.84 175.77,87.48 v2(176.27,87.98)
FLASH_DC0_IO18: length 20.3
  TOP w0.109: v2(189.71,85.77) 190.05,86.11 J10.30
  ART07 w0.114: v2(189.71,85.77) 188.88,86.6 177.07,86.6 176.68,86.99 176.68,88.92 176.44,89.17 176.11,89.17 175.87,89.41 175.87,89.73 175.62,89.98 174.27,89.98 v2(173.87,89.58)
FLASH_DC0_IO19: length 15.6
  TOP w0.109: v2(179.75,83.58) 182.43,86.26 183.25,86.26 183.6,86.61 J10.31
  ART07 w0.114: v2(179.75,83.58) 178.35,84.98 175.87,84.98 175.06,86.36 175.06,87.91 175.06,89.19 v2(174.67,89.58)
FLASH_DC0_IO20: length 16.6
  TOP w0.109: v2(191.97,86.94) 191.64,86.61 J10.32
  ART03 w0.114: v2(191.97,86.94) 191.68,86.65 181.41,86.65 181.16,86.9 178.24,86.9 178.12,86.78 177.47,86.78 v2(177.07,87.18)
FLASH_DC0_IO21: length 8.1
  TOP w0.109: J10.33 182.99,87.11 182.65,87.45 v2(182.65,87.58)
  ART07 w0.114: v2(182.65,87.58) 182.45,87.38 178.51,87.38 178.31,87.58 177.47,87.58 v2(177.07,87.98)
FLASH_DC0_IO22: length 17.5
  TOP w0.109: v2(189.63,87.63) 189.63,87.4 189.92,87.11 J10.34
  ART03 w0.114: v2(189.63,87.63) 189.08,87.07 181.58,87.07 181.16,87.5 178.7,87.5 178.61,87.58 176.86,87.58 176.67,87.77 176.67,88.15 176.42,88.39 176.06,88.39 175.84,88.61 175.84,88.97 175.47,89.35 v2(175.47,89.58)
FLASH_DC0_IO23: length 8.9
  TOP w0.109: v2(181.56,88.62) 182.06,88.11 J10.37
  ART07 w0.114: v2(176.27,89.58) 176.46,89.58 176.86,89.18 181,89.18 v2(181.56,88.62)
FLASH_DC0_IO24: length 14.4
  TOP w0.109: J10.38 189.38,88.11 v2(188.9,87.63)
  ART03 w0.114: v2(188.9,87.63) 188.57,87.96 186.97,87.96 186.82,88.11 180.24,88.11 179.99,88.36 178.49,88.36 178.48,88.37 177.48,88.37 177.36,88.49 177.36,88.49 v2(177.07,88.78)
FLASH_DC0_IO25: length 8.2
  TOP w0.109: v2(182.34,88.52) 182.94,89.11 J10.41
  ART07 w0.114: v2(177.87,87.98) 177.87,88.11 178.36,88.59 180.11,88.59 180.87,87.83 182.06,87.83 182.34,88.11 v2(182.34,88.52)
FLASH_DC0_IO26: length 23.4
  TOP w0.109: J10.42 191.65,89.11 191.97,89.43 v2(191.97,89.66)
  ART03 w0.114: v2(174.67,91.18) 175.08,91.59 177.08,91.59 177.3,91.67 177.34,91.71 177.43,91.89 177.52,92.18 177.64,92.31 177.83,92.38 178.03,92.38 178.7,92.2 181.58,92.2 182.43,93.05 183.85,93.05 184.02,93.22 189.99,93.22 191.13,92.09 192.24,92.09 192.55,91.77 192.55,90.25 v2(191.97,89.66)
FLASH_DC0_IO27: length 11.8
  TOP w0.109: J10.43 183.56,89.61 v2(183.46,89.51)
  ART07 w0.114: v2(174.67,90.38) 175.08,90.79 175.62,90.79 175.88,90.53 175.88,90.18 176.1,89.97 177.27,89.97 177.27,89.97 177.27,89.97 177.46,90.16 177.46,90.56 177.65,90.75 181.18,90.75 181.73,90.19 182.78,90.19 v2(183.46,89.51)
FLASH_DC0_IO28: length 14.1
  TOP w0.109: J10.44 189.92,89.61 189.66,89.36 v2(189.66,88.59)
  ART03 w0.114: v2(177.87,88.78) 180.85,88.78 181.14,89.08 186.94,89.08 187.12,88.9 189.35,88.9 v2(189.66,88.59)
FLASH_DC0_IO29: length 8.1
  TOP w0.109: v2(182.67,89.51) 182.67,89.64 183.15,90.11 J10.45
  ART07 w0.114: v2(177.87,89.58) 177.87,89.81 178.25,90.19 180.85,90.19 181.99,89.05 182.22,89.05 v2(182.67,89.51)
FLASH_DC0_IO30: length 16.3
  TOP w0.109: J10.46 190.1,90.11 189.71,90.5 v2(189.71,90.7)
  ART03 w0.114: v2(189.71,90.7) 189.25,90.25 186.64,90.25 186.51,90.37 178.99,90.37 178.61,89.99 176.12,89.99 175.73,90.38 v2(175.47,90.38)
FLASH_DC0_IO31: length 10.6
  TOP w0.109: J10.47 183.32,90.61 v2(182.7,91.24)
  ART07 w0.114: v2(175.47,91.18) 175.87,91.58 176.42,91.58 176.64,91.81 176.64,92.19 176.83,92.38 181.56,92.38 v2(182.7,91.24)
FLASH_DC0_IO32: length 17.5
  TOP w0.109: J10.48 v2(191.97,90.61)
  ART03 w0.114: v2(177.07,90.38) 177.27,90.38 177.7,90.8 178.23,90.8 178.76,91.33 181.9,91.33 182.34,91.78 183.96,91.78 184.37,92.19 189.79,92.19 191.36,90.61 v2(191.97,90.61)
FLASH_DC0_IO33: length 14.2
  TOP w0.109: J10.50 190.09,91.11 189.71,91.49 v2(189.71,91.62)
  ART03 w0.114: v2(177.87,90.38) 178.41,90.38 178.92,90.89 182.28,90.89 182.38,90.79 184.74,90.79 185.6,91.64 186.05,91.64 186.56,91.13 189.23,91.13 v2(189.71,91.62)
FLASH_DC0_IO34: length 9.9
  TOP w0.109: v2(183.44,91.24) 183.81,91.61 J10.51
  ART07 w0.114: v2(183.44,91.24) 182.95,90.75 182.14,90.75 181.3,91.59 176.93,91.59 176.64,91.31 176.64,90.75 v2(176.27,90.38)
FLASH_DC0_IO35: length 18.5
  TOP w0.109: J10.52 v2(191.97,91.61)
  ART03 w0.114: v2(176.27,91.18) 176.67,90.78 177.19,90.78 177.47,91.06 177.47,91.39 177.65,91.57 178.43,91.57 178.63,91.77 181.74,91.77 182.17,92.19 183.73,92.19 184.26,92.72 189.87,92.72 190.98,91.61 v2(191.97,91.61)
FLASH_DC0_IO36: length 10.4
  TOP w0.109: J10.53 183.07,92.11 v2(182.57,92.61)
  ART07 w0.114: v2(176.27,91.98) 175.88,92.37 175.88,93 176.07,93.19 181.99,93.19 v2(182.57,92.61)
FLASH_DC0_IO37: length 22
  TOP w0.109: J10.54 192.35,92.11 v2(192.86,92.63)
  ART03 w0.114: v2(176.27,92.78) 176.68,93.19 177.26,93.19 177.59,93.52 178.13,93.52 178.59,93.06 181.12,93.06 181.62,93.56 182.93,94.87 183.23,94.87 183.51,95.15 183.87,95.15 184.68,94.33 186.36,94.33 187.23,95.21 189.42,95.21 191.46,93.17 192.32,93.17 v2(192.86,92.63)
FLASH_DC0_IO38: length 21.6
  TOP w0.109: J10.56 v2(191.97,92.61)
  ART03 w0.114: v2(191.97,92.61) 191.25,92.61 189.56,94.31 186.99,94.31 186.43,93.75 183.91,93.75 183.63,93.47 182.26,93.47 181.43,92.64 178.55,92.64 178.05,93.14 178.03,93.14 178.02,93.14 177.72,93.14 177.72,93.14 177.64,93.14 177.44,92.94 177.44,92.58 177.24,92.38 174.27,92.38 v2(173.87,91.98)
FLASH_DC0_IO39: length 12.1
  TOP w0.109: v2(182.62,93.9) 182.8,93.73 182.8,93.72 183.13,93.39 183.14,93.39 183.41,93.11 183.62,93.11 183.62,93.12 J10.57
  ART07 w0.114: v2(173.87,92.78) 174.31,93.22 174.93,93.22 175.06,93.34 175.06,93.75 175.28,93.97 180.43,93.97 180.72,94.26 182.27,94.26 v2(182.62,93.9)
FLASH_DC0_PRSNTN: length 294
  TOP w0.089: 44.55,182.04 44.55,180.93 v2(43.54,179.92)
  TOP w0.109: v2(162.56,87.39) 162.56,86.7 R178.2 ; v2(43.54,179.92) U23.R18 ; R354.1 R180.1 44.55,182.04
  ART07 w0.114: v2(200.43,109.9) 200.43,110.21 199.01,111.63 199.01,115.77 198.8,115.98 197.43,115.98 197.3,116.11 196.81,116.11 196.7,116 196.14,116 194.18,117.96 194.18,118.45 193.88,118.75 193.39,118.75 192.23,119.91 192.23,120.34 191.68,120.89 191.68,126.59 192,126.91 192,136.86 192.34,137.2 192.34,140.96 191.45,141.85 191.45,151.83 188.09,155.19 180.47,155.19 178.69,156.97 172.72,156.97 172.3,156.55 165.06,156.55 160.7,160.91 148.97,160.91 147.83,162.05 142.24,162.05 141.86,162.43 141.86,164.47 141.48,164.85 139.45,164.85 139.28,165.01 137.91,165.01 137.5,165.42 137.5,165.77 136.87,166.4 132.44,166.4 130.43,168.4 130.43,171.7 128.91,173.23 79.38,173.23 78.1,174.5 73.66,174.5 69.67,178.49 69.63,178.49 69.59,178.52 65.52,178.52 64.9,177.9 59.13,177.9 58.52,177.29 48.01,177.29 46.48,178.82 45.97,178.82 45.25,179.54 44.18,179.54 43.8,179.92 v2(43.54,179.92)
  ART18 w0.114: v2(162.56,87.39) 161.87,86.71 161.87,82.78 163.65,81 172.16,81 173.13,80.03 182.19,80.03 182.25,79.96 183.01,79.96 183.02,79.96 183.7,79.96 186.2,82.46 186.2,82.93 186.92,83.64 188.47,83.64 188.63,83.48 189.95,83.48 192.03,85.56 193.69,85.56 194.49,86.36 194.49,88.8 195.88,90.19 195.88,95.63 198.63,98.37 198.63,105.51 200.43,107.31 v2(200.43,109.9)
  BOTTOM w0.114: v2(162.56,87.39) 162.88,87.39 163.88,88.39 164.56,88.39 164.67,88.49 164.67,88.98 164.87,89.18 165.25,89.18 165.48,89.41 165.48,90.58 165.68,90.78 166.27,90.78 v2(166.67,91.18)
