# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SYSMAX_PB2: length 102.8
  ART18 w0.114: v2(183.23,153.42) 183.74,153.92 192.91,153.92 193.17,153.67 193.17,147.32 191.81,145.96 191.81,143.07 192.28,142.6 192.28,137.52 190.55,135.79 190.55,134.08 190.3,133.83 190.3,130.12 190.14,129.96 190.14,127.56 190.67,127.03 190.67,123.61 191.2,123.09 191.2,121.32 190.96,121.08 190.96,119.8 192.01,118.75 193.88,118.75 194.18,118.45 194.18,118.02 193.98,117.83 193.98,100.15 189.68,95.86 189.68,93.55 188.36,92.23 188.36,91.62 187.9,91.15 187.06,91.15 184.02,88.11 182.52,88.11 182.52,88.11 182.17,88.11 182.17,88.11 181.35,88.11 180.29,87.04 179.5,87.04 178.58,86.13 171.83,86.13 171.82,86.13 171.7,86.13 171.07,86.77 171.07,88.21 170.86,88.42 169.72,88.42 169.36,88.78 v2(169.07,88.78)
SYSMAX_PB3: length 108.5
  ART18 w0.114: v2(168.27,87.98) 168.7,87.55 169.21,87.55 169.47,87.3 169.47,87.02 169.82,86.66 170.15,86.66 171.5,85.32 175.18,85.32 175.66,84.84 178.28,84.84 179.41,85.98 180.9,85.98 181.61,86.69 183.72,86.69 186.94,89.92 188.08,89.92 189.08,90.91 189.08,91.87 190.35,93.14 190.35,95.2 194.61,99.47 194.61,117.56 194.81,117.76 194.81,118.71 194.14,119.39 193.43,119.39 191.83,120.99 191.83,123.35 191.31,123.87 191.31,127.3 190.87,127.73 190.87,129.02 191.95,130.1 191.95,136.07 193.27,137.39 193.27,146.99 193.47,147.19 193.47,153.8 193.27,154 193.27,154.08 193.04,154.31 179.68,154.31 v2(178.79,153.42)
SYSMAX_PB4: length 89.5
  ART18 w0.114: v2(187.81,153.42) 187.39,153.42 187.26,153.54 184.02,153.54 183.77,153.29 183.77,149.83 184.76,148.84 184.76,144.02 185.9,142.87 188.57,142.87 189.76,141.68 189.76,140.03 188.88,139.15 188.88,136.52 187.74,135.38 187.74,129.71 186.55,128.52 186.55,124.37 187.81,123.12 187.81,122.55 188.92,121.44 188.92,119.4 190.47,117.86 190.47,105.68 190.65,105.5 190.65,101.58 187.25,98.18 187.25,94.9 184.2,91.86 182.09,91.86 181.54,91.31 179.63,91.31 178.28,89.97 177.7,89.97 177.44,89.71 177.44,89.41 177.23,89.19 172.07,89.19 171.69,89.58 v2(171.47,89.58)
SYSMAX_PB5: length 96.7
  ART18 w0.114: v2(171.47,88.78) 171.57,88.68 171.57,88.52 171.85,88.24 171.85,87.81 172.07,87.59 177.25,87.59 177.47,87.81 177.47,88.19 177.65,88.37 178.53,88.37 180.54,90.37 183.84,90.37 186.87,93.39 187.91,93.39 188.57,94.06 188.57,97.1 192.42,100.95 192.42,105.75 191.21,106.96 191.21,118.11 189.66,119.66 189.66,121.97 188.56,123.07 188.56,123.47 187.19,124.85 187.19,128.26 188.38,129.45 188.38,134.92 191.36,137.9 191.36,142.21 185.06,148.51 185.06,149.04 184.28,149.83 184.28,152.91 184.53,153.16 186.18,153.16 186.56,152.78 191.74,152.78 v2(192.38,153.42)
SYSMAX_SW0: length 80.5
  TOP w0.109: v2(157.07,152.02) SW5.1
  ART20 w0.114: v2(157.07,152.02) 158.7,150.39 158.7,147.34 157.96,146.61 157.96,143.89 156.08,142.01 156.08,136.27 155.14,135.33 155.14,130.61 158.5,127.25 164.16,127.25 164.67,127.76 166.78,127.76 167.79,126.75 167.79,125.37 168.73,124.43 168.73,123.75 170.31,122.17 170.31,120.93 172.34,118.9 172.34,114.68 171.3,113.64 169.7,113.64 168.73,112.67 168.73,107.8 166.19,105.26 166.19,103.68 165.71,103.2 164.03,103.2 163.58,102.74 163.58,102.06 162.76,101.24 162.76,96.87 163.5,96.14 163.5,95.15 v2(164.27,94.38)
SYSMAX_SW1: length 80.3
  TOP w0.109: v2(158.34,152.02) SW5.2
  ART20 w0.114: v2(158.34,152.02) 159.36,151 159.36,145.8 158.47,144.91 158.47,134.82 157.86,134.21 156.72,134.21 155.85,133.35 155.85,131.57 156.87,130.56 157.58,130.56 157.96,130.94 158.39,130.94 160.73,128.6 163.63,128.6 164.13,128.09 167.03,128.09 168.2,126.92 168.2,125.81 170.88,123.13 170.88,122.14 171.3,121.72 171.65,121.72 172.11,121.26 172.11,119.91 174.24,117.78 174.24,115.52 172.72,114 172.72,110.57 171.02,108.86 170.23,108.86 169.11,107.75 169.11,104.52 166.34,101.75 163.98,101.75 163.28,101.05 163.28,96.91 163.9,96.29 163.9,95.55 v2(164.27,95.18)
SYSMAX_SW2: length 77.4
  TOP w0.109: v2(159.61,152.02) SW5.3
  ART20 w0.114: v2(159.61,152.02) 160.09,152.5 161.36,152.5 161.85,152.02 161.85,150.54 162.91,149.48 162.91,143.38 161.36,141.83 161.36,139.34 161.14,139.11 161.14,136.4 163.04,134.49 163.04,133.81 163.55,133.3 165.38,133.3 168.12,130.56 168.45,130.56 169.04,129.97 169.04,128.3 169.21,128.12 169.21,127.38 170.21,126.39 171.12,126.39 171.74,125.77 171.74,124.85 174.65,121.95 174.65,121.21 176.68,119.18 176.68,103.12 174.9,101.35 169.77,101.35 169.47,101.04 169.47,94.78 v2(169.07,94.38)
SYSMAX_SW3: length 75.2
  TOP w0.109: v2(160.88,152.02) SW5.4
  ART20 w0.114: v2(160.88,152.02) 161.52,151.38 161.52,150.37 162.53,149.35 162.53,143.64 160.98,142.09 160.98,139.5 160.75,139.27 160.75,134.8 161.57,133.99 162.28,133.99 163.6,132.66 165.38,132.66 168.02,130.02 168.02,129.44 168.54,128.92 168.54,128.05 168.87,127.71 168.87,127.23 169.04,127.06 169.04,125.98 169.42,125.6 171.04,125.6 171.4,125.25 171.4,124.61 174.32,121.69 174.32,121.06 176.25,119.13 176.25,104.47 175.11,103.33 170.84,103.33 168.66,101.15 168.66,94.77 v2(168.27,94.38)
SYSMAX_SW4: length 113.2
  TOP w0.109: SW10.1 164.18,152.3 164.21,152.27 v2(164.21,152.15)
  ART05 w0.114: v2(164.21,152.15) 166.37,154.31 183.87,154.31 185.03,153.14 v2(185.03,152.73)
  ART18 w0.114: v2(171.47,87.98) 171.47,87.73 171.85,87.35 171.85,86.97 172.06,86.77 178.33,86.77 179.32,87.75 179.32,88.59 180.72,89.99 183.94,89.99 187.04,93.09 188.03,93.09 188.87,93.93 188.87,96.72 193.32,101.17 193.32,110.79 191.52,112.59 191.52,118.24 189.97,119.79 189.97,122.1 188.86,123.2 188.86,123.6 187.55,124.91 187.55,128.17 188.69,129.3 188.69,134.79 191.67,137.78 191.67,142.34 190.88,143.13 190.88,145.39 185.03,151.23 v2(185.03,152.73)
SYSMAX_SW5: length 113.2
  TOP w0.109: v2(165.1,152.15) 165.45,152.5 SW10.2
  ART05 w0.114: v2(165.1,152.15) 166.88,153.92 181.48,153.92 183.26,152.15 185.54,152.15 v2(186.05,152.65)
  ART18 w0.114: v2(186.05,152.65) 186.05,150.85 191.39,145.51 191.39,143.05 191.98,142.47 191.98,137.65 189.53,135.2 189.53,132.92 189.99,132.46 189.99,130.24 189.66,129.91 189.66,129.34 188.93,128.6 188.93,127.59 188.67,127.33 188.67,125.7 190.37,124.01 190.37,123.09 190.27,123 190.27,119.97 192.55,117.7 192.74,117.7 193.67,116.77 193.67,100.56 189.23,96.11 189.23,93.72 188.29,92.78 188.08,92.78 184.35,89.05 180.72,89.05 180.24,88.57 180.24,87.63 180.08,87.48 179.48,87.48 178.43,86.44 171.95,86.44 171.47,86.92 v2(171.47,87.18)
TDIO_0: length 2.4
  TOP w0.254: U87.36 82.82,198.36 v2(82.09,199.09)
  BOTTOM w0.254: C2132.1 82,199.17 v2(82.09,199.09)
TDIO_2: length 1.7
  TOP w0.254: U89.36 v2(110.63,197.75)
  BOTTOM w0.254: v2(110.63,197.75) 110.49,197.89 C2136.1
TDIO_3: length 2.8
  TOP w0.254: U90.36 v2(123.41,198.22)
  BOTTOM w0.254: v2(123.41,198.22) 123.13,198.5 122.75,198.5 C2138.1
TDIO_4: length 1.6
  TOP w0.254: U88.36 v2(96.77,197.85)
  BOTTOM w0.254: v2(96.77,197.85) 96.72,197.9 C2134.1
TEMP_ALERTN: length 108.6
  TOP w0.109: v3(174.82,114.55) 173.4,113.14 U31.18
  ART05 w0.114: v3(174.82,114.55) 175.47,113.89 184.43,113.89 184.89,113.43 188.13,113.43 188.72,114.02 190.85,114.02 191.36,113.51 v2(201.25,113.51)
  ART18 w0.114: v2(201.25,113.51) 201.02,113.28 201.02,106.86 199.16,105 199.16,98.3 196.31,95.45 196.31,90.02 194.94,88.65 194.94,86.16 192.38,83.59 191.08,83.59 190.09,82.6 187.5,82.6 184.51,79.61 183.95,79.61 183.88,79.54 182.09,79.54 182.01,79.61 181.7,79.61 172.91,79.61 172,80.53 162.95,80.53 161.39,82.09 161.39,89.71 163.6,91.92 164.21,91.92 v2(164.27,91.98)
TSNS0: length 70.3
  TOP w0.109: v2(79.27,208.56) U54.8
  ART05 w0.199: v2(79.27,208.56) 80.19,208.56 80.82,207.92 83.13,207.92 83.69,207.37 86.82,207.37 88.58,205.6 v2(88.58,199.64)
  ART16 w0.199: v2(129.58,198.55) 128.19,198.55 127.11,199.63 125.54,199.63 124.65,198.74 122.35,198.74 121.63,198.02 119.89,198.02 118.19,199.72 117.16,199.72 v2(116.47,199.03) 115.52,199.03 113.69,200.86 111.43,200.86 109.8,202.49 105.97,202.49 104.8,201.32 104.8,201.04 103.45,199.69 103.24,199.69 v2(102.68,199.14) 101.14,199.14 98.86,201.42 96.95,201.42 95.68,202.69 92.13,202.69 89.89,200.46 89.4,200.46 v2(88.58,199.64)
  BOTTOM w0.109: C1719.1 80.82,207.92 80.19,208.56 v2(79.27,208.56)
TSNS0_R: length 2.6
  TOP w0.254: U89.22 118.26,198.14 v3(117.36,199.03)
  BOTTOM w0.254: v3(117.36,199.03) 117.67,199.34 C2135.1
TSNS0_R_0: length 2.6
  TOP w0.254: R1101.1 90.37,198.74 U87.22
  BOTTOM w0.254: C2131.1 89.98,200.09 v3(89.53,199.64)
TSNS0_R_3: length 2.5
  TOP w0.254: v3(130.47,198.55) 131.37,197.65 U90.22
  BOTTOM w0.254: C2137.1 131.23,198.62 130.53,198.62 v3(130.47,198.55)
TSNS0_R_4: length 2.5
  TOP w0.254: v3(103.57,199.14) 104.47,198.24 U88.22
  BOTTOM w0.254: C2133.1 104.37,199.14 v3(103.57,199.14)
USB_ADDR0: length 166.8
  TOP w0.109: U23.U13 v2(45.14,175.92)
  ART05 w0.114: v2(126.05,113.1) 126.76,113.81 126.76,114.21 126.53,114.44 126.53,114.76 126.84,115.07 127.21,115.07 127.58,114.71 129.67,114.71 130.14,115.18 130.5,115.18 131,115.68 131.64,115.68 131.76,115.8 133.7,115.8 134.48,116.57 134.95,116.57 135.32,116.2 135.88,116.2 136.3,116.62 136.93,116.62 140.39,120.08 140.39,136.65 139.17,137.87 139.17,141.5 139.13,141.54 139.13,141.58 137.16,143.55 137.16,157.05 132.79,161.42 131.57,161.42 130.94,162.05 130.94,165.74 130.05,166.62 107.44,166.62 105.54,168.53 99.95,168.53 99.06,167.64 83.69,167.64 80.39,164.34 64.14,164.34 63.12,165.35 63.12,169.16 60.58,171.7 56.54,171.7 50.9,177.34 46.35,177.34 46.15,177.14 45.77,177.14 45.54,176.91 45.54,176.55 45.14,176.15 v2(45.14,175.92)
USB_ADDR1: length 167.6
  TOP w0.109: U23.U12 v2(45.14,175.12)
  ART05 w0.114: v2(126.92,114.6) 127.2,114.6 127.3,114.5 129.73,114.5 130.22,114.99 130.58,114.99 131.06,115.47 131.08,115.49 131.87,115.49 131.95,115.57 134.91,115.57 135.36,115.13 135.92,115.13 136.31,115.52 136.55,115.52 140.83,119.8 140.83,136.92 139.75,138 139.75,141.58 138.25,143.08 138.25,156.58 132.91,161.93 131.95,161.93 131.44,162.43 131.44,166.24 130.56,167.13 112.39,167.13 111.12,168.4 111.12,170.59 110.52,171.2 79.5,171.2 78.23,172.47 72.39,172.47 71.17,173.69 71.17,177.67 68.88,179.96 65.91,179.96 65.66,180.21 50.29,180.21 48.03,177.95 45.77,177.95 45.54,177.72 45.54,177.37 45.26,177.09 44.96,177.09 44.7,176.83 44.7,175.56 v2(45.14,175.12)
USB_CFG0: length 252.7
  TOP w0.109: U23.T4 v2(44.34,167.92)
  ART07 w0.114: v2(176.5,149.22) 175.87,148.59 173.45,148.59 173.03,149.01 161.34,149.01 158.82,151.52 158.13,151.52 157.71,151.94 157.71,152.78 155.93,154.56 145.38,154.56 144.87,155.07 137.79,155.07 135.13,157.73 132.84,157.73 131.19,159.38 119.38,159.38 118.3,160.46 111.19,160.46 105.16,166.5 99.68,166.5 93.09,159.9 59.75,159.9 53.29,166.37 50.85,166.37 49.6,167.62 49.31,167.62 48.9,168.02 47.58,168.02 47.13,167.57 46.74,167.57 46.65,167.66 46.33,167.66 46.2,167.54 44.72,167.54 v2(44.34,167.92)
  ART20 w0.114: v2(167.47,89.58) 167.91,89.14 178.02,89.14 178.03,89.13 180.21,89.13 180.64,88.7 181.03,88.7 181.36,89.03 183.93,89.03 184.64,89.75 184.64,90.79 186.59,92.73 187.22,92.73 188.19,93.7 188.19,96.25 188.07,96.36 187.22,96.36 187.11,96.47 187.11,96.7 187.22,96.82 188.07,96.82 188.19,96.93 188.19,97.16 188.07,97.27 187.22,97.27 187.11,97.39 187.11,97.62 187.22,97.73 188.07,97.73 188.19,97.85 188.19,98.07 188.07,98.19 187.22,98.19 187.11,98.3 187.11,98.53 187.22,98.65 188.07,98.65 188.19,98.76 188.19,98.99 188.07,99.1 187.22,99.1 187.11,99.22 187.11,99.45 187.22,99.56 188.07,99.56 188.19,99.67 188.19,99.9 188.07,100.02 187.22,100.02 187.11,100.13 187.11,100.36 187.22,100.47 188.07,100.47 188.19,100.59 188.19,100.82 188.07,100.93 187.22,100.93 187.11,101.05 187.11,101.27 187.22,101.39 188.07,101.39 188.19,101.5 188.19,121.57 188.07,121.69 187.22,121.69 187.11,121.8 187.11,122.03 187.22,122.14 188.07,122.14 188.19,122.26 188.19,122.49 188.07,122.6 187.22,122.6 187.11,122.71 187.11,122.94 187.22,123.06 188.07,123.06 188.19,123.17 188.19,123.4 188.07,123.51 187.22,123.51 187.11,123.63 187.11,123.86 187.22,123.97 188.05,123.97 188.16,124.09 188.16,124.34 188.07,124.43 187.22,124.43 187.11,124.54 187.11,125.67 187.32,125.89 187.8,125.89 187.91,126 187.91,126.21 187.78,126.34 187.22,126.34 187.11,126.46 187.11,130.07 187.37,130.33 187.37,131.55 187.37,131.55 187.37,132.39 186.16,133.6 182.37,133.6 178.9,137.07 178.9,141.11 176.5,143.51 v2(176.5,149.22)
USB_CFG1: length 264
  TOP w0.109: U23.U3 v2(45.14,167.12)
  ART07 w0.114: v2(188.06,149.73) 183.49,149.73 180.06,146.3 173.33,146.3 172.95,145.92 163.97,145.92 161.89,148.01 160.87,148.01 158.86,150.02 157.67,150.02 157.4,150.29 157.4,150.75 157.2,150.95 156.74,150.95 155.55,152.14 155.55,152.43 155.46,152.52 155.46,152.53 154.26,153.72 145.02,153.72 144.69,154.05 136.78,154.05 134.75,156.08 133.22,156.08 130.76,158.55 118.7,158.55 117.86,159.38 110.74,159.38 104.65,165.48 100.33,165.48 93.74,158.89 59.3,158.89 53.48,164.72 49.12,164.72 47.41,166.43 46.44,166.43 46.15,166.72 45.54,166.72 45.15,167.12 v2(45.14,167.12)
  ART20 w0.114: v2(165.87,87.98) 165.45,87.56 165.45,84.12 167.53,82.04 173.89,82.04 175.67,80.26 183.64,80.26 185.01,81.63 187.88,81.63 188.29,82.04 189.99,82.04 191.65,83.7 192.03,83.7 192.27,83.94 192.27,84.01 194.69,86.43 194.69,102.33 195.63,103.27 195.63,119.11 194.82,119.92 194.82,129.8 192.47,132.14 192.47,134.17 192.01,134.64 192.01,141.96 188.06,145.91 v2(188.06,149.73)
USB_CFG2: length 258.6
  TOP w0.109: U23.V2 v2(45.94,166.32)
  ART07 w0.114: v2(45.94,166.32) 45.94,165.74 46.25,165.43 47.42,165.43 48.64,164.21 53.29,164.21 59.03,158.47 95.73,158.47 98.3,161.04 98.3,162.31 100.97,164.97 104.52,164.97 110.62,158.88 117.6,158.88 118.38,158.1 129.93,158.1 133.1,154.94 135.13,154.94 137.16,152.91 142.62,152.91 143.26,153.54 144.61,153.54 144.85,153.3 154.09,153.3 155.04,152.35 155.04,152.02 155.97,151.09 155.97,150.46 156.79,149.64 157.13,149.64 157.27,149.5 158.56,149.5 160.49,147.57 161.74,147.57 163.8,145.5 182.18,145.5 v2(185.77,149.1)
  ART20 w0.114: v2(166.67,87.98) 167.07,87.58 167.07,85 167.87,84.2 174.63,84.2 177.29,81.53 178.44,81.53 179.07,82.17 183.64,82.17 185.29,83.82 189.05,83.82 189.54,84.31 190.51,84.31 191.66,85.47 192.42,85.47 193.69,86.74 193.69,102.52 194.79,103.62 194.79,118.6 194.21,119.17 193.61,119.17 192.65,120.12 192.65,120.5 192.03,121.12 192.03,122.73 192.03,122.73 192.03,123.44 191.91,123.56 191.91,128.69 190.8,129.8 190.8,134.33 191.17,134.7 191.17,141.54 185.77,146.94 v2(185.77,149.1)
USB_CFG3: length 253.3
  TOP w0.109: U23.P6 v2(42.74,169.52)
  ART07 w0.114: v2(173.58,151.64) 172.21,150.27 162.05,150.27 160.47,151.85 160.47,152.19 160.48,152.21 160.48,152.37 157.03,155.83 147.06,155.83 146.3,156.59 138.18,156.59 135.51,159.26 133.35,159.26 130.56,162.05 112.65,162.05 112.01,162.69 112.01,166.24 111.51,166.75 107.19,166.75 105.92,168.02 79.88,168.02 74.55,162.69 67.12,162.69 67.01,162.57 67.01,161.9 66.9,161.78 66.67,161.78 66.55,161.9 66.55,163.17 66.44,163.28 66.21,163.28 66.1,163.17 66.1,161.9 65.98,161.78 65.75,161.78 65.64,161.9 65.64,163.17 65.52,163.28 65.3,163.28 65.18,163.17 65.18,161.9 65.07,161.78 64.84,161.78 64.72,161.9 64.72,163.17 64.61,163.28 64.38,163.28 64.27,163.17 64.27,161.9 64.15,161.78 63.92,161.78 63.81,161.9 63.81,163.17 63.7,163.28 63.47,163.28 63.35,163.17 63.35,161.9 63.24,161.78 63.01,161.78 62.9,161.9 62.9,163.17 62.78,163.28 62.55,163.28 62.44,163.17 62.44,161.9 62.32,161.78 62.09,161.78 61.98,161.9 61.98,163.17 61.87,163.28 61.64,163.28 61.52,163.17 61.52,161.9 61.41,161.78 61.18,161.78 61.07,161.9 61.07,163.17 60.95,163.28 60.72,163.28 60.61,163.17 60.61,161.9 60.49,161.78 60.27,161.78 60.15,161.9 60.15,163.17 60.04,163.28 58.99,163.28 51.61,170.66 44.61,170.66 43.92,169.96 43.68,169.96 43.68,169.96 43.18,169.96 v2(42.74,169.52)
  ART20 w0.114: v2(169.07,91.18) 169.44,90.81 169.44,90.25 169.71,89.98 183.07,89.98 185.95,92.86 185.95,93.02 185.6,93.37 185.6,93.53 185.77,93.69 185.93,93.69 186.27,93.35 186.44,93.35 186.69,93.6 186.69,124.6 182.5,128.79 182.5,131.44 178.48,135.46 178.48,140.92 176.08,143.32 176.08,149.14 v2(173.58,151.64)
USB_CFG4: length 253.1
  TOP w0.109: U23.P5 v2(42.74,168.72)
  ART07 w0.114: v2(173.45,150.88) 173.45,150.34 172.96,149.85 161.88,149.85 160.05,151.67 160.05,152.21 156.85,155.41 145.83,155.41 145.16,156.08 138.05,156.08 135.38,158.75 133.22,158.75 130.43,161.54 111.63,161.54 105.66,167.51 80.13,167.51 74.85,162.23 74.16,162.23 74.05,162.11 74.05,161.45 73.93,161.34 73.7,161.34 73.59,161.45 73.59,162.11 73.47,162.23 73.25,162.23 73.13,162.11 73.13,161.45 73.02,161.34 72.79,161.34 72.67,161.45 72.67,162.11 72.56,162.23 72.32,162.23 72.2,162.11 72.2,161.48 72.09,161.37 71.86,161.37 71.75,161.48 71.75,162.11 71.63,162.23 71.4,162.23 71.29,162.11 71.29,161.48 71.18,161.37 70.95,161.37 70.83,161.48 70.83,162.11 70.72,162.23 70.49,162.23 70.38,162.11 70.38,161.48 70.26,161.37 70.03,161.37 69.92,161.48 69.92,162.11 69.8,162.23 69.58,162.23 69.46,162.11 69.46,161.48 69.35,161.37 69.12,161.37 69,161.48 69,162.11 68.89,162.23 68.66,162.23 68.55,162.11 68.55,161.48 68.43,161.37 68.2,161.37 68.09,161.48 68.09,162.11 67.98,162.23 67.75,162.23 67.63,162.11 67.63,161.48 67.52,161.37 67.24,161.37 67.13,161.25 67.13,161.01 67.01,160.89 66.78,160.89 66.67,161.01 66.67,161.25 66.55,161.37 66.33,161.37 66.21,161.25 66.21,161.01 66.1,160.89 65.87,160.89 65.75,161.01 65.75,161.25 65.64,161.37 65.41,161.37 65.3,161.25 65.3,161.01 65.18,160.89 64.95,160.89 64.84,161.01 64.84,161.25 64.73,161.37 64.5,161.37 64.38,161.25 64.38,161.01 64.27,160.89 64.04,160.89 63.93,161.01 63.93,161.25 63.81,161.37 63.58,161.37 63.47,161.25 63.47,161.01 63.35,160.89 63.13,160.89 63.01,161.01 63.01,161.25 62.9,161.37 62.67,161.37 62.55,161.25 62.55,161.01 62.44,160.89 62.21,160.89 62.1,161.01 62.1,161.25 61.98,161.37 61.75,161.37 61.64,161.25 61.64,161.01 61.53,160.89 61.3,160.89 61.18,161.01 61.18,161.25 61.07,161.37 60.84,161.37 60.73,161.25 60.73,161.01 60.61,160.89 60.38,160.89 60.27,161.01 60.27,161.25 60.15,161.37 59.81,161.37 53.67,167.51 53.07,167.51 52.96,167.63 52.96,168.15 52.84,168.26 52.61,168.26 52.5,168.15 52.5,167.63 52.38,167.51 52.02,167.51 51.64,167.89 51.64,169.19 51.01,169.82 48.75,169.82 48.59,169.98 48.2,169.98 48.08,169.86 48.08,169.24 47.97,169.13 47.74,169.13 47.63,169.24 47.63,169.86 47.51,169.98 47.28,169.98 47.17,169.86 47.17,169.24 47.05,169.13 46.82,169.13 46.71,169.24 46.71,169.86 46.6,169.98 46.37,169.98 46.25,169.86 46.25,169.24 46.14,169.13 45.91,169.13 45.8,169.24 45.8,169.86 45.68,169.98 44.7,169.98 43.87,169.14 43.16,169.14 v2(42.74,168.72)
  ART20 w0.114: v2(169.87,91.18) 170.28,90.77 181.57,90.77 182.93,92.12 183.79,92.12 184.53,92.86 184.53,103.02 185.01,103.5 185.01,118.44 183.84,119.61 183.84,123.03 181.96,124.92 181.96,125.86 177.77,130.05 177.14,130.05 176.15,131.03 176.15,135.13 174.12,137.17 174.12,137.95 174.23,138.06 174.91,138.06 175.02,138.18 175.02,138.41 174.91,138.52 174.23,138.52 174.12,138.64 174.12,138.87 174.23,138.98 174.91,138.98 175.02,139.09 175.02,139.32 174.91,139.44 174.23,139.44 174.12,139.55 174.12,140.11 174.75,140.74 174.91,140.74 175.24,140.4 175.41,140.4 175.57,140.56 175.57,140.72 175.23,141.06 175.23,141.22 175.51,141.5 175.51,148.82 v2(173.45,150.88)
USB_CFG5: length 265.1
  TOP w0.109: U23.V3 v2(45.94,167.12)
  ART07 w0.114: v2(188.06,150.62) 187.93,150.62 187.55,150.24 183.23,150.24 180.19,147.19 174.22,147.19 172.82,148.59 161.08,148.59 158.62,151.05 157.99,151.05 157.6,151.43 157.02,151.43 156.06,152.4 156.06,152.68 154.6,154.14 145.2,154.14 144.78,154.56 136.91,154.56 134.87,156.59 133.35,156.59 130.98,158.96 119.04,158.96 118.17,159.83 111.06,159.83 104.9,165.99 100.06,165.99 93.47,159.4 59.47,159.4 53.6,165.26 49.72,165.26 47.86,167.12 v2(45.94,167.12)
  ART20 w0.114: v2(165.07,87.18) 165.07,86.57 165.03,86.53 165.03,83.94 167.95,81.03 173.75,81.03 175.26,79.51 182.36,79.51 182.36,79.52 188.91,79.52 193.02,83.62 193.02,84.17 196.05,87.19 196.05,115.36 196.95,116.26 196.95,118.38 195.24,120.09 195.24,130.34 193.5,132.07 193.5,133.54 193.5,133.54 193.5,133.74 192.43,134.82 192.43,142.14 188.85,145.72 188.85,149.83 v2(188.06,150.62)
USB_CFG6: length 259.6
  TOP w0.109: U23.V4 v2(45.94,167.92)
  ART07 w0.114: v2(45.94,167.92) 46.54,168.53 49.2,168.53 49.29,168.44 49.72,168.44 51.15,167 53.41,167 59.94,160.47 73.91,160.47 80.44,167 105.41,167 111.38,161.04 118.49,161.04 119.72,159.8 131.41,159.8 132.97,158.24 135.25,158.24 137.92,155.57 144.95,155.57 145.54,154.99 156.64,154.99 158.98,152.65 158.98,152.02 161.57,149.43 173.78,149.43 174.22,149.86 180.69,149.86 181.58,150.75 v2(187.17,150.75)
  ART20 w0.114: v2(187.17,150.75) 187.17,146.21 191.59,141.79 191.59,134.46 192.02,134.03 192.02,130.77 193.37,129.41 193.37,127.09 192.46,126.18 192.46,122.03 193.46,121.02 193.76,121.02 194.4,120.38 194.4,119.74 195.21,118.93 195.21,103.44 194.18,102.42 194.18,86.64 192.07,84.53 191.41,84.53 190.68,83.8 190.68,83.44 189.79,82.55 184.91,82.55 183.64,81.28 179.07,81.28 178.82,81.03 175.84,81.03 173.14,83.73 167.4,83.73 165.95,85.19 165.95,86.36 165.87,86.44 165.87,86.53 165.87,86.54 v2(165.87,87.18)
USB_DATA0: length 162.5
  TOP w0.109: U23.M10 v2(41.14,173.52)
  ART05 w0.114: v2(126.05,114.1) 125.65,114.5 125.65,115.77 125.53,115.9 125.53,116.19 125.7,116.37 125.7,116.75 125.55,116.9 125.55,117.31 125.82,117.58 126.17,117.58 126.71,118.11 127.19,118.11 128.7,119.62 129.67,119.62 130.11,120.07 130.43,120.07 130.75,120.39 130.75,120.43 130.77,120.44 130.77,120.9 133.93,124.07 133.93,127.37 132.33,128.97 132.33,155.93 130.53,157.73 116.51,157.73 115.75,158.5 110.87,158.5 104.39,164.97 100.97,164.97 93.98,157.99 63.33,157.99 59.73,161.59 59.57,161.59 58.99,161.01 58.83,161.01 58.67,161.17 58.67,161.33 59.24,161.91 59.24,162.07 59.07,162.24 58.91,162.24 58.4,161.73 58.23,161.73 58.07,161.89 58.07,162.05 58.59,162.57 58.59,162.73 58.43,162.89 58.27,162.89 57.75,162.38 57.59,162.38 53.72,166.24 53.72,169.04 52.9,169.86 52.84,169.86 52.73,169.98 52.73,170.81 52.57,170.97 52.31,170.97 52.19,170.85 52.19,169.98 52.08,169.86 51.85,169.86 51.74,169.98 51.74,170.85 51.62,170.97 51.39,170.97 51.28,170.85 51.28,169.98 51.17,169.86 50.94,169.86 50.82,169.98 50.82,170.7 50.71,170.81 49.32,170.81 49.31,170.81 48.93,170.81 48.92,170.81 46.84,170.81 46.1,171.55 44.14,171.55 43.96,171.73 43.96,172.26 43.13,173.1 41.56,173.1 v2(41.14,173.52)
USB_DATA1: length 162.3
  TOP w0.109: U23.L10 v2(40.34,173.52)
  ART05 w0.114: v2(40.34,173.52) 41.5,172.36 41.5,171.73 41.68,171.55 43.69,171.55 43.94,171.3 43.94,170.98 44.21,170.71 45.16,170.71 45.48,170.39 47.64,170.39 48.59,169.44 52.3,169.44 53.09,168.66 53.09,166.12 59.05,160.15 59.21,160.15 59.81,160.75 59.97,160.75 60.13,160.59 60.13,160.43 59.53,159.83 59.53,159.67 59.7,159.51 59.86,159.51 60.46,160.11 60.62,160.11 60.78,159.95 60.78,159.78 60.18,159.18 60.18,159.02 60.34,158.86 60.5,158.86 61.1,159.46 61.27,159.46 61.43,159.3 61.43,159.14 60.83,158.54 60.83,158.38 60.99,158.21 61.15,158.21 61.75,158.81 61.91,158.81 62.07,158.65 62.07,158.49 61.47,157.89 61.47,157.73 61.72,157.48 94.11,157.48 101.09,164.47 104.27,164.47 110.87,157.86 115.6,157.86 116.23,157.23 130.28,157.23 131.83,155.68 131.83,128.32 132.64,127.51 132.64,124.21 131.55,123.11 131.08,123.11 129.99,122.03 129.99,120.76 129.79,120.56 129.16,120.56 128.62,120.03 128.26,120.03 127.33,119.1 126.7,119.1 126.2,118.61 125.82,118.61 125.26,118.05 125.02,118.05 124.73,117.75 124.73,114.06 v2(125.18,113.6)
USB_DATA2: length 161.6
  TOP w0.109: U23.R10 v2(43.54,173.52)
  ART05 w0.114: v2(125.18,114.6) 125.18,114.23 125.7,113.71 126.26,113.71 126.44,113.89 126.44,114.26 126.29,114.41 126.29,114.79 126.37,114.87 126.37,114.88 126.48,114.99 126.48,116.98 126.7,117.2 127.08,117.2 128.54,118.66 129.77,118.66 130.18,119.06 130.45,119.06 130.95,119.56 131.27,119.56 131.74,120.03 131.74,120.35 131.47,120.61 131.47,120.77 131.88,121.19 132.34,121.19 132.73,121.58 133.16,121.58 133.59,122.01 134.02,122.01 134.43,122.42 134.43,122.8 135.37,123.74 135.37,127.29 132.84,129.82 132.84,156.12 130.72,158.24 116.84,158.24 116.08,159 111,159 104.52,165.48 100.84,165.48 93.85,158.5 63.42,158.5 58.35,163.57 58.18,163.57 57.69,163.07 57.53,163.07 57.37,163.23 57.37,163.39 57.86,163.89 57.86,164.05 57.7,164.21 57.54,164.21 57.04,163.72 56.88,163.72 56.72,163.88 56.72,164.04 57.21,164.54 57.21,164.7 57.05,164.86 56.89,164.86 56.4,164.36 56.24,164.36 56.07,164.53 56.07,164.69 56.57,165.18 56.57,165.34 56.41,165.5 56.24,165.5 55.75,165.01 55.59,165.01 54.21,166.38 54.21,169.91 52.72,171.41 50.05,171.41 49.63,171.83 46.71,171.83 46.05,172.49 44.25,172.49 43.54,173.2 v2(43.54,173.52)
USB_DATA3: length 155.1
  TOP w0.109: U23.R11 v2(43.54,174.32)
  ART05 w0.114: v2(43.54,174.32) 44.6,174.32 45.01,173.91 48.94,173.91 50.52,172.34 53.19,172.34 55.55,169.98 55.55,167.59 63.63,159.51 93.6,159.51 100.58,166.5 104.78,166.5 111.25,160.02 116.54,160.02 117.3,159.26 131.48,159.26 135.39,155.35 135.39,138.78 138.66,135.51 138.66,122.32 137.4,121.07 137.12,121.07 136.65,120.6 136.19,120.6 135.19,119.6 134.57,119.6 133.62,118.64 132.88,118.64 132.25,118.01 131.81,118.01 131.51,117.71 130.97,117.71 130.69,117.99 129.67,117.99 129.13,117.44 129.13,116.49 v2(129.51,116.1)
USB_DATA4: length 156.8
  TOP w0.109: U23.V13 v2(45.94,175.92)
  ART05 w0.114: v2(129.51,117.1) 130.06,117.1 130.14,117.18 130.65,117.18 130.96,117.49 131.51,117.49 131.78,117.21 132.73,117.21 134.72,119.2 135.39,119.2 135.83,119.63 136.6,119.63 137.11,120.14 137.46,120.14 137.87,120.55 138.25,120.55 139.08,121.37 139.08,135.84 135.9,139.01 135.9,155.49 131.5,159.89 117.47,159.89 116.84,160.53 111.38,160.53 104.9,167 100.46,167 93.73,160.27 64.01,160.27 60.45,163.83 60.45,164.97 59.05,166.37 57.78,166.37 56.13,168.02 56.13,170.07 53.36,172.85 50.72,172.85 48.89,174.67 47.53,174.67 47.42,174.79 47.42,175.76 47.3,175.88 47.06,175.88 46.94,175.77 46.94,174.48 46.83,174.37 46.6,174.37 46.48,174.48 46.48,175.77 46.37,175.88 45.98,175.88 v2(45.94,175.92)
USB_DATA5: length 158.4
  TOP w0.109: U23.V14 v2(45.94,176.72)
  ART05 w0.114: v2(128.65,115.6) 128.72,115.52 129.75,115.52 130.44,116.21 130.54,116.21 130.85,116.52 131.64,116.52 131.95,116.21 132.27,116.21 132.58,116.52 133.32,116.52 133.49,116.69 134.07,116.69 134.58,117.2 135.86,117.2 136.23,117.56 136.61,117.56 137.11,118.06 137.49,118.06 139.92,120.48 139.92,136.46 138.71,137.67 138.71,141.4 136.74,143.37 136.74,156.87 132.7,160.91 131.44,160.91 130.43,161.93 111.38,161.93 105.28,168.02 100.08,168.02 99.19,167.13 83.82,167.13 80.52,163.83 63.75,163.83 62.61,164.97 62.61,168.91 60.45,171.07 56.54,171.07 50.72,176.88 50.31,176.88 50.19,176.77 50.19,176.47 50.08,176.35 49.85,176.35 49.74,176.47 49.74,176.77 49.62,176.88 49.39,176.88 49.28,176.77 49.28,176.47 49.16,176.35 48.94,176.35 48.82,176.47 48.82,176.77 48.71,176.88 46.48,176.88 46.32,176.72 v2(45.94,176.72)
USB_DATA6: length 156.7
  TOP w0.109: U23.R12 v2(43.53,175.12)
  ART05 w0.114: v2(43.53,175.12) 43.15,174.74 43.15,174.12 43.33,173.94 43.74,173.94 43.94,173.74 43.94,173.3 44.45,172.8 49.3,172.8 50.26,171.83 53.06,171.83 54.85,170.04 54.85,167.65 55.17,167.33 55.17,167.17 54.8,166.79 54.8,166.63 54.96,166.47 55.12,166.47 55.5,166.85 55.66,166.85 55.82,166.68 55.82,166.52 55.44,166.14 55.44,165.98 55.6,165.82 55.77,165.82 56.14,166.2 56.31,166.2 63.5,159 93.73,159 100.71,165.99 104.65,165.99 111.12,159.51 116.26,159.51 117.02,158.75 131.14,158.75 133.86,156.03 133.86,136.78 134.67,135.97 134.67,129.11 137.03,126.75 137.03,123.71 134.94,121.62 134.63,121.62 134.18,121.16 133.72,121.16 133.25,120.69 132.99,120.69 132.51,120.21 132.51,119.28 132.31,119.08 131.98,119.08 131.42,118.52 131.07,118.52 130.77,118.21 128.64,118.21 128.19,117.77 128.19,117.05 v2(128.65,116.6)
USB_DATA7: length 161.2
  TOP w0.109: U23.R13 v2(43.53,175.92)
  ART05 w0.114: v2(127.78,116.1) 128.84,116.1 129.23,115.71 129.67,115.71 129.99,116.03 129.99,116.76 130.22,116.99 130.54,116.99 130.81,116.71 131.41,116.71 131.68,116.99 132.27,116.99 132.34,116.92 133.05,116.92 133.25,117.12 133.99,117.12 135.55,118.68 136.61,118.68 137.06,119.13 137.91,119.13 139.5,120.71 139.5,136.14 136.32,139.32 136.32,156.7 132.62,160.4 130.34,160.4 129.33,161.42 111.12,161.42 105.03,167.51 100.33,167.51 99.44,166.62 83.95,166.62 80.64,163.32 63.5,163.32 62.1,164.72 62.1,168.78 60.33,170.56 56.36,170.56 53.57,173.35 50.92,173.35 48.36,175.92 47.95,175.92 47.57,176.3 45.77,176.3 45.54,176.07 45.54,174.88 45.39,174.73 44.65,174.73 43.53,175.85 v2(43.53,175.92)
USB_EMPTY: length 160.2
  TOP w0.109: U23.V15 v2(45.94,177.52)
  ART20 w0.114: v2(45.94,177.52) 46.61,176.85 46.61,175.84 49.22,173.23 55.75,173.23 56.64,172.34 61.72,172.34 62.87,171.2 62.87,164.97 68.05,159.79 95.66,159.79 100.84,164.97 104.65,164.97 108.08,161.54 128.91,161.54 130.17,160.27 132.46,160.27 135.64,157.1 135.64,140.09 134.63,139.09 134.63,128.22 135.17,127.69 135.17,119.93 133.86,118.62 132.79,118.62 132.31,118.13 131.95,118.13 131.34,117.52 131.09,117.52 130.78,117.22 130.78,116.41 130.4,116.03 130.1,116.03 129.66,115.59 129.34,115.59 127.91,114.17 126.72,114.17 126.34,114.55 125.91,114.55 125.58,114.88 125.58,116.63 v2(126.05,117.1)
USB_FPGA_CLK: length 148.7
  ART20 w0.114: v2(131.25,117.1) 132.75,117.1 133.78,118.14 134.61,118.14 136.04,119.57 136.04,121.86 135.64,122.26 135.64,126.61 136.27,127.24 136.27,157.35 132.59,161.04 130.56,161.04 129.41,162.18 108.33,162.18 104.9,165.61 100.58,165.61 95.5,160.53 68.58,160.53 63.5,165.61 63.5,171.45 61.85,173.1 57.32,173.1 53.47,176.95 49.6,176.95 v2(48.04,175.39)
USB_FPGA_CLK_R: length 6.8
  TOP w0.127: U23.N11 v2(41.93,174.32)
  BOTTOM w0.109: R301.2 47,175.54 42.42,175.54 42.32,175.44 42.32,174.7 v2(41.93,174.32)
USB_FULL: length 159
  TOP w0.109: U23.T15 v2(44.34,177.52)
  ART20 w0.114: v2(126.05,116.1) 126.05,115.78 126.67,115.16 127.05,115.16 127.48,115.59 127.88,115.59 128.44,116.15 128.9,116.15 129.39,116.64 129.77,116.64 130.01,116.88 130.01,117.28 129.84,117.45 129.84,117.75 130.15,118.06 130.48,118.06 130.93,118.52 131.34,118.52 131.9,119.08 132.36,119.08 132.92,119.63 133.17,119.63 133.68,120.14 133.98,120.14 134.31,120.47 134.31,120.79 134.07,121.03 134.07,121.2 134.38,121.5 134.38,121.74 134.13,121.99 134.13,122.15 134.37,122.39 134.37,123.02 133.9,123.49 133.9,127.75 133.3,128.35 133.3,140.61 135.13,142.44 135.13,156.26 131.7,159.69 119.33,159.69 117.98,161.04 107.7,161.04 104.27,164.47 101.09,164.47 96,159.37 67.58,159.37 62.36,164.59 62.36,170.99 61.64,171.7 56.13,171.7 55.07,172.77 47.55,172.77 46.4,173.91 45.79,173.91 45.54,174.16 45.54,176.93 45.37,177.1 44.76,177.1 v2(44.34,177.52)
USB_MAX_CLK: length 258.9
  TOP w0.109: U23.U9 v2(45.14,171.92)
  ART07 w0.114: v2(175.8,152.34) 175.61,152.15 172.97,152.15 171.77,150.94 162.87,150.94 157.36,156.45 147.8,156.45 147.03,157.23 138.43,157.23 135.76,159.89 133.6,159.89 130.81,162.69 114.55,162.69 113.92,163.32 113.92,166.37 112.9,167.39 107.44,167.39 106.17,168.66 78.99,168.66 73.66,163.32 67.69,163.32 67.06,163.96 59.33,163.96 56.52,166.77 56.52,166.93 57.3,167.71 57.3,167.87 57.14,168.03 56.98,168.03 56.2,167.25 56.04,167.25 55.87,167.41 55.87,167.57 56.65,168.35 56.65,168.51 56.49,168.68 56.33,168.68 55.55,167.9 55.39,167.9 55.23,168.06 55.23,168.22 56.01,169 56.01,169.16 55.84,169.32 55.68,169.32 54.9,168.54 54.74,168.54 54.58,168.71 54.58,168.87 55.36,169.65 55.36,169.81 55.2,169.97 55.04,169.97 54.26,169.19 54.1,169.19 53.94,169.35 53.94,169.51 54.71,170.29 54.71,170.45 54.55,170.62 54.39,170.62 53.61,169.84 53.45,169.84 53.29,170 53.29,170.16 54.07,170.94 54.07,171.1 53.9,171.26 53.74,171.26 52.97,170.48 52.8,170.48 52.64,170.65 52.64,170.81 53.42,171.59 53.42,171.75 53.26,171.91 53.1,171.91 52.32,171.13 52.16,171.13 51.51,171.78 47.83,171.78 47.6,171.55 45.5,171.55 v2(45.14,171.92)
  ART20 w0.114: v2(166.67,89.58) 167.08,89.17 167.08,88.56 167.27,88.37 171.85,88.37 171.85,88.37 171.91,88.37 171.91,88.37 179.9,88.37 180.89,87.38 181.53,87.38 182.24,88.09 184.33,88.09 185.27,89.03 185.27,89.81 188.81,93.36 188.81,101.71 189.37,102.28 189.37,103.85 188.81,104.42 188.81,113.42 190.29,114.91 190.29,117.72 188.81,119.2 188.81,126.2 187.73,127.28 187.73,129.81 187.99,130.07 187.99,131.81 187.99,131.81 187.99,133.32 187.07,134.24 182.63,134.24 179.52,137.34 179.52,141.38 178.15,142.75 178.15,149.53 175.99,151.69 175.99,152.15 v2(175.8,152.34)
USB_OEN: length 154.5
  TOP w0.109: U23.R14 v2(43.53,176.72)
  ART20 w0.114: v2(43.53,176.72) 43.53,176.66 43.95,176.23 43.95,173.24 44.3,172.89 45.29,172.89 45.91,172.28 46.08,172.28 46.3,172.07 46.3,171.77 47.4,170.66 54.51,170.66 54.76,170.41 54.92,170.41 55.28,170.78 55.44,170.78 55.6,170.61 55.6,170.45 55.24,170.09 55.24,169.93 55.4,169.77 55.56,169.77 55.93,170.13 56.09,170.13 56.25,169.97 56.25,169.81 55.89,169.44 55.89,169.28 56.05,169.12 56.21,169.12 56.57,169.48 56.73,169.48 56.9,169.32 56.9,169.16 56.53,168.8 56.53,168.64 58.67,166.5 60.33,166.5 60.83,165.99 60.83,164.34 67.03,158.14 98.15,158.14 100.09,156.2 104.66,156.2 107.3,158.84 110.18,158.84 110.29,158.95 110.29,159.5 110.4,159.61 110.63,159.61 110.75,159.5 110.75,158.95 110.86,158.84 111.09,158.84 111.2,158.95 111.2,159.5 111.32,159.61 111.55,159.61 111.66,159.5 111.66,158.95 111.78,158.84 112,158.84 112.12,158.95 112.12,159.5 112.51,159.89 116.97,159.89 118.11,158.75 130.66,158.75 132.82,156.59 132.82,143.1 131.95,142.24 131.95,128.02 132.32,127.65 132.32,122.15 132.66,121.81 132.66,121.56 132.13,121.03 131.54,121.03 130.5,119.99 130.05,119.99 129.56,119.51 129.26,119.51 127.96,118.21 127.96,117.98 126.92,116.93 v2(126.92,116.6)
USB_RDN: length 154.7
  TOP w0.127: U23.T14 v2(44.34,176.72)
  ART20 w0.114: v2(44.34,176.72) 43.94,177.11 43.36,177.11 43.13,176.88 43.13,173.11 43.65,172.59 45.05,172.59 45.5,172.14 45.5,172.07 45.5,172.07 45.5,170.86 46.56,169.8 52.58,169.8 52.9,169.48 53.06,169.48 53.66,170.08 53.82,170.08 53.98,169.92 53.98,169.76 53.38,169.16 53.38,169 53.54,168.83 53.7,168.83 54.31,169.43 54.47,169.43 54.63,169.27 54.63,169.11 54.03,168.51 54.03,168.35 54.23,168.15 55.88,168.15 58.04,165.99 60.07,165.99 60.33,165.74 60.33,164.08 66.74,157.67 97.87,157.67 99.76,155.78 104.83,155.78 107.3,158.24 112.27,158.24 113.28,159.26 116.59,159.26 117.6,158.24 130.45,158.24 132.28,156.41 132.28,143.38 131.42,142.52 131.42,123.23 131.68,122.97 131.68,121.75 130.99,121.06 130.17,121.06 129.68,120.56 129.3,120.56 127.86,119.13 127.86,118.97 127.05,118.16 126.85,118.16 126.49,117.81 126.49,116.02 v2(126.92,115.6)
USB_RESETN: length 145.4
  TOP w0.127: U23.P10 v2(42.74,173.52)
  ART20 w0.114: v2(42.74,173.52) 42.74,173.07 43.53,172.28 44.48,172.28 44.7,172.07 44.7,171.03 46.35,169.37 52.37,169.37 54.1,167.64 55.75,167.64 66.14,157.25 97.69,157.25 99.59,155.36 105.08,155.36 107.46,157.73 108.22,157.73 108.33,157.62 108.33,156.45 108.44,156.34 108.67,156.34 108.79,156.45 108.79,157.62 108.9,157.73 109.13,157.73 109.24,157.62 109.24,156.45 109.36,156.34 109.59,156.34 109.7,156.45 109.7,157.62 109.82,157.73 110.04,157.73 110.16,157.62 110.16,156.45 110.27,156.34 110.5,156.34 110.62,156.45 110.62,157.62 110.73,157.73 110.96,157.73 111.07,157.62 111.07,156.45 111.19,156.34 111.42,156.34 111.53,156.45 111.53,157.62 111.64,157.73 112.78,157.73 113.54,158.5 116.33,158.5 117.09,157.73 130,157.73 131.78,155.96 131.78,143.73 130.19,142.14 130.19,123.16 v2(131.25,122.1)
USB_SCL: length 166.7
  TOP w0.109: U23.U15 v2(45.14,177.52)
  ART05 w0.114: v2(135.57,113.6) 135.73,113.45 136.24,113.45 136.28,113.49 137.26,113.49 138.76,114.99 138.76,116.03 140.72,117.98 142.29,117.98 143.18,118.87 143.18,125.53 148.05,130.4 148.05,132.57 140.84,139.78 140.84,141.81 139.29,143.36 139.29,156.87 132.97,163.19 132.97,166.62 131.44,168.15 113.28,168.15 112.39,169.04 112.39,170.94 111.25,172.09 80.14,172.09 77.34,174.88 74.68,174.88 72.31,177.24 72.31,179.27 69.6,181.99 50.55,181.99 47.45,178.89 44.98,178.89 44.75,178.66 44.75,177.9 v2(45.14,177.52)
USB_SDA: length 164.5
  TOP w0.109: U23.U16 v2(45.14,178.32)
  ART05 w0.114: v2(133.84,113.6) 134.83,113.6 135.22,113.99 136.01,113.99 136.28,113.71 136.6,113.71 136.66,113.77 136.89,113.77 137.06,113.93 137.06,115.04 141.17,119.15 141.78,119.15 142.39,119.76 142.39,125.5 147.55,130.65 147.55,132.47 142.35,137.67 141.35,137.67 140.17,138.85 140.17,141.82 138.71,143.28 138.71,156.82 132.46,163.07 132.46,166.12 130.94,167.64 112.78,167.64 111.76,168.66 111.76,170.62 110.74,171.64 79.95,171.64 77.22,174.37 74.42,174.37 71.78,177.01 71.78,177.93 68.3,181.41 50.6,181.41 47.62,178.43 45.25,178.43 v2(45.14,178.32)
USB_T_CLK: length 24.5
  TOP w0.109: U23.K12 v2(39.54,175.12) ; R977.1 v3(17.63,172.4)
  ART07 w0.114: v3(17.63,172.4) 19.67,174.45 27.28,174.45 28.12,175.29 31.95,175.29 32.15,175.49 39.17,175.49 v2(39.54,175.12)
USB_WRN: length 156.2
  TOP w0.109: U23.T13 v2(44.34,175.92)
  ART20 w0.114: v2(44.34,175.92) 44.34,174.27 44.67,173.94 45.26,173.94 45.57,173.63 45.57,173.13 45.87,172.82 46.61,172.82 47.6,171.83 48.64,171.83 48.93,172.12 49.58,172.12 49.7,172.01 49.7,171.39 49.81,171.27 50.04,171.27 50.16,171.39 50.16,172.01 50.27,172.12 50.5,172.12 50.61,172.01 50.61,171.39 50.73,171.27 50.96,171.27 51.07,171.39 51.07,172.01 51.18,172.12 51.41,172.12 51.53,172.01 51.53,171.39 51.64,171.27 51.87,171.27 51.98,171.39 51.98,172.01 52.1,172.12 52.33,172.12 52.44,172.01 52.44,171.39 52.56,171.27 52.78,171.27 52.9,171.39 52.9,172.01 53.01,172.12 54.74,172.12 55.79,171.07 60.83,171.07 61.85,170.05 61.85,164.41 67.33,158.93 98.12,158.93 100.43,156.62 104.42,156.62 108.33,160.53 117.36,160.53 118.62,159.27 131.25,159.27 133.83,156.69 133.83,155.03 133.44,154.64 133.44,142.71 132.74,142.01 132.74,123.05 133.5,122.29 133.5,122.01 133.24,121.74 133.24,121.54 133.46,121.31 133.46,120.82 133.2,120.55 132.79,120.55 132.33,120.09 131.93,120.09 131.39,119.56 131.01,119.56 130.54,119.09 130.19,119.09 129.41,118.31 129.41,117.78 128.73,117.1 v2(127.78,117.1)
USERMD: length 58.7
  TOP w0.109: U23.U2 v2(45.14,166.32)
  ART05 w0.114: v2(45.14,166.32) 45.31,166.32 46.13,165.51 46.13,165.31 46.24,165.2 46.24,163.98 48.51,161.7 48.51,158.06 47.97,157.52 47.97,155.84 49.32,154.48 49.32,153.16 50.39,152.09 50.39,151 50.67,150.72 50.67,147.29 50.2,146.82 50.2,146.42 47.88,144.09 47.62,144.09 41.15,137.62 41.15,136.33 v2(40.39,135.57) 39.81,135 30.07,135 29.44,134.37 29.44,133.64 v2(28.83,133.03)
  BOTTOM w0.109: v2(28.83,133.03) 29.51,133.72 29.51,135 30.08,135.57 R844.1 30.1,135.86 29.91,136.05 U24.23 ; v2(40.39,135.57) 40.07,135.89 U25.23
UV_12V_DCIN: length 85.6
  TOP w0.109: v2(33.25,192.4) 33.36,192.29 U48.11 ; v2(31.65,187.71) 31.86,187.92 U48.3
  ART05 w0.254: v2(31.65,187.71) 31.65,188.04 30.6,189.08 29.34,189.08 28.11,187.86 26.38,187.86 25.6,187.08 25.6,185.52 24.97,184.89 20.52,184.89 19.3,183.67 14.86,183.67 14.2,183.01 14.2,174.8 15.14,173.86 15.14,158.85 11.38,155.09 11.38,140.8 v2(12.14,140.04) v2(13.33,140.04) 14.9,138.48 SW8.5 SW8.2
  BOTTOM w0.109: v2(31.65,187.71) 31.65,187.73 31.15,188.23 C1408.1 30.64,188.98 30.18,188.98 30.07,189.08 30.07,190.88 30.52,191.32 32.17,191.32 v2(33.25,192.4)
VFB0: length 8.8
  TOP w0.109: U54.12 78.29,210.16 79.5,211.36 79.5,212.04 80.22,212.75 81.17,212.75 R5875.2 82.39,212.32 82.4,212.31 R5876.1 82.94,211.11 C2118.1
VID_I2C_ALERTN: length 122.2
  TOP w0.109: U54.17 77.61,212.16 78.16,212.7 v2(78.23,212.7) ; SW6.6 v2(143.76,163.51)
  ART20 w0.114: v2(78.23,212.7) 77.7,212.7 76.61,211.61 76.61,206.1 76,205.49 76,203.28 76.99,202.29 77.55,202.29 78.46,201.37 78.46,200.69 77.04,199.26 77.04,193.29 78.46,191.87 78.46,185.95 79.44,184.97 79.44,172.97 80.84,171.58 134.75,171.58 135.38,170.94 135.38,168.51 136.4,167.49 136.4,165.41 137,164.81 141.46,164.81 141.68,164.59 141.68,163.63 142.37,162.94 143.19,162.94 v2(143.76,163.51)
  BOTTOM w0.109: v2(78.23,212.7) 79.15,212.7 79.7,212.15 80.1,212.15 80.25,212.3 R574.1
VID_I2C_SCL: length 123.8
  TOP w0.109: U54.15 77.27,211.46 77.77,211.46 v2(78,211.23) ; SW6.8 v2(141.22,163.51)
  ART20 w0.114: v2(78,211.23) 78.33,210.9 78.33,205.95 78.34,205.94 78.34,205.81 78.34,205.81 78.34,204 78.8,203.55 78.8,201.95 79.07,201.67 79.07,199.98 77.82,198.72 77.82,193.38 79.07,192.13 79.07,186.86 80.52,185.42 80.52,173.48 81.66,172.34 135.25,172.34 136.27,171.32 136.27,169.8 137.86,168.21 143.88,168.21 144.86,167.23 144.86,163.27 144.02,162.43 142.3,162.43 v2(141.22,163.51)
  BOTTOM w0.109: v2(78,211.23) 78.92,211.23 80.54,209.6 R576.1
VID_I2C_SDA: length 117.1
  TOP w0.109: SW6.7 v2(142.49,163.51) ; v2(78,211.94) 77.76,211.69 77.24,211.69 U54.16
  ART20 w0.114: v2(142.49,163.51) 141.99,164.02 141.99,166.85 141.02,167.81 137.46,167.81 135.89,169.39 135.89,171.07 135,171.96 81.38,171.96 79.98,173.35 79.98,185.2 78.77,186.41 78.77,192 77.47,193.3 77.47,199.26 78.77,200.56 78.77,201.5 77.67,202.59 77.52,202.59 77.12,202.99 77.12,204.85 76.83,205.14 76.83,205.88 77.01,206.07 77.01,206.19 77.01,206.2 77.01,210.33 77.35,210.66 77.35,211.28 v2(78,211.94)
  BOTTOM w0.109: R575.1 79.82,211.04 78.92,211.94 v2(78,211.94)
VOSNS_N: length 152.2
  ART03 w0.254: v2(192.13,158.91) 192.37,158.67 192.99,158.67 193.88,159.56 197.1,159.56 198.25,158.42 202.06,158.42 202.49,158.85 202.49,163.55 v1(203.15,164.21) ; v2(195.87,157) 195.68,156.8 195.68,156.25 195.06,155.63 193.39,155.63 192.68,156.34 191.08,156.34 186.88,160.54 177.61,160.54 176.94,161.21 173.74,161.21 171.08,163.87 163.28,163.87 161.79,162.38 139.8,162.38 136.8,165.38 135.68,165.38 135.33,165.03 135.33,164.77 v2(135.51,164.59)
  ART16 w0.254: v2(109.95,131.32) 109.84,131.43 109.74,131.43 109.6,131.57 109.6,131.9 109.86,132.16 113.84,132.16 119.99,138.3 127.34,138.3 132.33,143.3 132.33,158.06 135.51,161.24 v2(135.51,164.59)
  BOTTOM w0.254: v2(192.13,158.91) 192.52,158.91 192.77,159.16 193.25,159.16 193.27,159.18 193.36,159.18 C1125.2 193.79,159.13 194.83,159.13 195.7,158.26 195.7,157.17 v2(195.87,157) ; v2(109.95,131.32) 109.95,122.55 110.64,121.86 110.64,120.91 R667.1
VOSNS_P: length 157.6
  ART03 w0.254: v2(192.13,158.19) 192.16,158.23 193.17,158.23 194.05,159.11 196.88,159.11 198.04,157.94 203.07,157.94 203.84,158.7 203.84,162.26 v1(203.15,162.94) ; v2(134.75,164.59) 134.88,164.73 134.88,165.21 135.5,165.83 136.98,165.83 139.98,162.83 161.61,162.83 163.09,164.31 171.27,164.31 173.89,161.7 177.09,161.7 177.8,160.99 187.07,160.99 191.27,156.78 192.87,156.78 193.57,156.08 194.88,156.08 195.23,156.44 195.23,156.87 v2(195.11,157)
  ART05 w0.254: v1(203.15,168.02) 203.84,167.34 203.84,163.63 v1(203.15,162.94)
  ART16 w0.254: v2(109.32,130.94) 109.32,131.22 109.15,131.39 109.15,132.08 109.68,132.6 113.66,132.6 119.8,138.75 127.15,138.75 131.88,143.48 131.88,158.25 135.06,161.42 135.06,164.28 v2(134.75,164.59)
  BOTTOM w0.254: R666.1 110.29,120.92 110.29,121.72 109.6,122.41 109.6,126.72 109.51,126.81 109.51,130.75 v2(109.32,130.94) ; v2(195.11,157) 195.25,157.13 195.25,158.08 194.64,158.68 193.75,158.68 C1125.1 193.31,158.72 192.96,158.72 192.71,158.47 192.4,158.47 v2(192.13,158.19)
VREF_DDR4_COMP_0.6V: length 88.2
  TOP w0.254: R5387.2 v2(137.57,141.86) ; U3.M1 v2(91.74,150.52) ; U4.M1 v2(103.17,150.52) ; U6.M1 v2(126.03,150.52) ; U7.M1 80.21,150.42 80.87,150.42 v2(80.87,150.42) ; U5.M1 v2(114.6,150.52)
  ART07 w0.508: v2(137.57,141.86) 136.17,143.26 136.17,148.97 135.46,149.68 133.91,149.68 133.12,148.89 129.64,148.89 129.36,149.17
  ART16 w0.254: 125.98,154.53 125.96,154.56
  ART16 w0.508: v2(80.87,150.42) 81.93,151.48 81.93,154.98 82.9,155.96 92.43,155.96 92.94,155.45 ; v2(114.6,150.52) 114.81,150.52 115.83,151.55 115.83,155.8 ; 115.83,155.8 111.15,155.8 110.74,156.21 106.43,156.21 105.41,155.19 104.27,155.19 ; 115.83,155.8 116.69,155.8 117.28,156.4 118.91,156.4 120.05,155.26 125.26,155.26 125.96,154.56 ; v2(91.74,150.52) 92.2,150.52 92.94,151.26 92.94,155.45 ; 92.94,155.45 93.44,155.96 96.9,155.96 97.66,155.19 104.27,155.19 ; 104.27,155.19 104.27,151.16 103.63,150.52 v2(103.17,150.52)
  BOTTOM w0.254: C498.1 80.86,150.43 v2(80.87,150.42)
VREF_FPGA_0.6V:
  vias: v2(93.95,77.22) v2(93.95,76.45) v2(94.71,77.22) v2(94.71,76.45) v2(105.26,112.1) v2(105.26,91.1) v2(107,112.1) v2(115.66,112.1) v2(115.66,91.1) v2(117.39,112.1) v2(117.39,91.1)
VREF_SODIMM_0.6V: length 45.5
  TOP w0.279: v2(114.27,51.69) 114.07,51.89 CON1.164
  ART18 w0.508: v3(75.27,54.23) 76.72,52.78 80.87,52.78 83.31,50.34 86.97,50.34 87.91,49.4 88.24,49.4 88.24,49.4 89.58,49.4 90.4,50.21 112.27,50.21 113.13,51.08 113.67,51.08 114.27,51.68 v2(114.27,51.69)
  BOTTOM w0.508: v2(114.27,51.69) 114.27,49.91 C399.2
VSENSE_3.3V_PRE: length 2.5
  BOTTOM w0.254: U32.9 45.06,54.99 45.09,55.01 45.09,55.69 R530.1 R528.2
VSENSE_5V: length 343.6
  TOP w0.254: v3(191.26,133.29) R548.1
  ART05 w0.254: v2(51.89,51.33) 55.91,51.33 56.72,52.15 67.28,52.15 70.56,48.87 70.56,48.13 73.25,45.44 85.37,45.44 88.52,42.29 88.52,35.05 90.68,32.89 93.47,32.89 96.27,30.1 109.98,30.1 111.91,32.03 119.25,32.03 122.02,29.26 122.02,15.04 122.89,14.17 139.68,14.17 139.73,14.12 140.13,14.12 140.18,14.17 150.04,14.17 151.31,12.9 160.96,12.9 162.36,11.51 165.13,11.51 167.54,13.92 177.44,13.92 178.99,15.47 178.99,19.86 180.85,21.72 187.83,21.72 188.59,22.48 192.91,22.48 196.22,19.18 201.04,19.18 204.22,22.35 208.79,22.35 209.42,21.72 214.5,21.72 215.14,22.35 215.14,102.57 199.26,118.44 196.98,118.44 195.43,119.99 195.43,121.54 197,123.12 197,132.27 196.58,132.69 195.99,132.69 194.63,134.05 192.02,134.05 v3(191.26,133.29)
  ART16 w0.254: v2(51.89,51.33) 51.77,51.46 51.17,51.46 50.61,50.9 48.03,50.9 47.37,51.56 47.37,53.35 45.83,54.89 45.83,54.92 v2(45.74,55.01)
  BOTTOM w0.254: v2(45.74,55.01) 45.57,54.83 U32.10
VSENSE_12VIN: length 191.4
  ART16 w0.254: v2(35.9,192.28) 35.19,191.57 30.4,191.57 29.12,190.28 29.12,186.98 27.18,185.04 19.56,185.04 19.18,184.66 12.83,184.66 10.59,182.42 10.59,178.36 7.95,175.72 7.95,171.25 10.85,168.35 10.85,160.83 16.05,155.63 29.41,155.63 32.83,152.21 32.83,148.79 34.48,147.14 35.22,147.14 37.74,144.61 37.74,128.6 41.64,124.71 41.64,114.48 35.02,107.87 35.02,93 39.24,88.78 39.24,84.49 41.91,81.82 41.91,73.53 41.04,72.67 41.04,59.79 44.02,56.82 44.02,55.53 v2(44.43,55.12)
  BOTTOM w0.254: v2(44.43,55.12) 44.57,54.99 U32.8 ; R509.1 v2(35.9,192.28)
VSENSEN_VCC: length 172.1
  TOP w0.109: 78.15,207.72 78.02,207.85 77.47,207.85 77.38,207.76 U54.6
  TOP w0.254: v2(79.77,207.15) 79.24,207.15 78.66,207.72 78.15,207.72 ; v2(75.55,200.22) 75.1,199.77 74.62,199.77 74.14,199.29 74.14,196.93 79.65,191.41 79.65,170.52 64.9,155.76 64.9,154.32 65.6,153.62 66.55,153.62 67.11,154.17 67.11,154.69 v3(67.48,155.07)
  ART03 w0.254: v2(67.75,96.01) 67.75,96.01 67.29,96.01 65.66,97.64 64.57,97.64 61.06,101.14 61.06,125.43 56.59,129.9 56.59,137.04 53.85,139.78 53.85,141.36 53.21,141.99 53.21,147.73 51.21,149.73 49.53,149.73 48.23,151.03 48.23,152.16 46.94,153.45 46.94,156.21 49,158.27 49,159.26 51.13,161.39 55.45,161.39 63.09,153.75 66.56,153.75 67.06,154.25 67.06,154.64 v3(67.48,155.07)
  BOTTOM w0.254: v2(75.55,200.22) 75.82,199.95 76.68,199.95 77.29,200.56 79.55,200.56 81.09,202.11 81.09,206.09 80.54,206.64 80.28,206.64 v2(79.77,207.15)
VSENSEN_VCCH: length 222.4
  ART03 w0.254: v4(163.35,174.9) 163.35,174.6 162.46,173.71 150.32,173.71 149.38,174.65 v4(149.38,174.9)
  BOTTOM w0.254: C2101.2 165.56,175.62 164.95,175.62 164.62,175.29 163.73,175.29 v4(163.35,174.9) ; v4(149.38,174.9) 149.38,174.93 148.97,175.34 148.46,175.34 147.42,176.38 147.42,177.22 147.05,177.58 146.14,177.58 C1960.2 144.97,177.61 143.22,177.61 141.99,176.38 136.91,176.38 135.56,175.03 135.56,167.79 133.38,165.61 133.38,162.89 128.83,158.34 107.9,158.34 104.9,155.35 97.74,155.35 97.08,156.01 65.43,156.01 62.28,152.86 62.28,142.27 63.22,141.33 63.22,124.72 64.12,123.83 66.67,123.83 70.33,127.48 79.61,127.48 82.76,124.33 93.83,124.33 95.06,123.1 arc(95.2,122.88) 95.24,122.63 arc(95.25,122.49) 95.3,122.35 95.31,122.35 arc(95.37,122.1) 95.31,121.85 arc(95.24,121.6) 95.31,121.35 arc(95.37,121.1) 95.31,120.85 arc(95.24,120.6) 95.31,120.35 arc(95.37,120.1) 95.31,119.85 arc(95.24,119.6) 95.31,119.35 arc(95.37,119.1) 95.31,118.85 arc(95.24,118.6) 95.31,118.35 arc(95.37,118.1) 95.31,117.85 arc(95.24,117.6) 95.31,117.35 arc(95.37,117.1) 95.31,116.85 arc(95.24,116.6) 95.31,116.35 arc(95.37,116.1) 95.31,115.85 arc(95.24,115.6) 95.31,115.35 arc(95.37,115.1) 95.31,114.85 arc(95.24,114.6) 95.31,114.35 arc(95.37,114.1) 95.31,113.85 arc(95.24,113.6) 95.31,113.35 arc(95.37,113.1) 95.31,112.85 arc(95.24,112.6) 95.31,112.35 arc(95.37,112.1) 95.31,111.85 95.31,111.85 arc(95.24,111.6) 95.3,111.35 95.31,111.35 arc(95.37,111.1) 95.31,110.85 arc(95.24,110.6) 95.31,110.35 arc(95.37,110.1) 95.31,109.85 arc(95.24,109.6) 95.31,109.35 arc(95.37,109.1) 95.31,108.85 arc(95.24,108.6) 95.31,108.35 95.31,108.35 arc(95.37,108.1) 95.31,107.85 arc(95.24,107.6) 95.3,107.35 95.31,107.35 arc(95.37,107.1) 95.31,106.85 arc(95.24,106.6) 95.31,106.35 arc(95.37,106.1) 95.31,105.85 arc(95.24,105.6) 95.31,105.35 arc(95.37,105.1) 95.31,104.85 arc(95.24,104.6) 95.31,104.35 arc(95.37,104.1) 95.31,103.85 arc(95.24,103.6) 95.31,103.35 arc(95.37,103.1) 95.31,102.85 arc(95.24,102.6) 95.31,102.35 arc(95.37,102.1) 95.31,101.85 arc(95.24,101.6) 95.31,101.35 arc(95.37,101.1) 95.31,100.85 arc(95.24,100.6) 95.31,100.35 arc(95.37,100.1) 95.31,99.85 arc(95.24,99.6) 95.31,99.35 arc(95.37,99.1) 95.31,98.85 arc(95.24,98.6) 95.31,98.35 arc(95.37,98.1) 95.31,97.85 arc(95.24,97.6) 95.31,97.35 arc(95.37,97.1) 95.31,96.85 arc(95.24,96.6) 95.31,96.35 arc(95.37,96.1) 95.31,95.85 95.3,95.85 arc(95.24,95.6) 95.31,95.35 arc(95.37,95.1) 95.31,94.85 95.31,94.85 arc(95.24,94.6) 95.31,94.35 arc(95.37,94.1) 95.31,93.85 arc(95.25,93.7) 95.24,93.54 95.24,93.43 95.61,93.07 95.99,93.07 96.64,92.41 R97.2
VSENSEP_VCC: length 156.1
  TOP w0.254: R1073.2 75.14,199.39 74.78,199.39 74.52,199.14 74.52,197.08 80.04,191.57 80.04,170.36 65.28,155.6 65.28,154.48 65.76,154 66.4,154 66.73,154.33 66.73,154.72 v3(66.37,155.07)
  ART03 w0.254: v3(66.37,155.07) 66.68,154.76 66.68,154.41 66.4,154.13 63.25,154.13 55.61,161.77 50.97,161.77 48.62,159.42 48.62,158.43 46.56,156.37 46.56,153.29 47.85,152 47.85,150.87 49.37,149.35 51.05,149.35 52.83,147.57 52.83,141.83 53.47,141.2 53.47,139.62 56.21,136.88 56.21,129.74 60.68,125.27 60.68,100.98 64.41,97.26 65.5,97.26 67.75,95 v2(67.75,94.74)
