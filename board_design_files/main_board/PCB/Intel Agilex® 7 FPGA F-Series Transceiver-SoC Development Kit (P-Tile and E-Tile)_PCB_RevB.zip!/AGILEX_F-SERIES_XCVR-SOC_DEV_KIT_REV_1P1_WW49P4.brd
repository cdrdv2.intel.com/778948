# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_RC_TXN11: length 106.2
  ART05 w0.114: 138.51,104.73 138.48,104.73 138.45,104.7 138.17,104.7 arc(137.97,104.75) 137.82,104.89 137.82,104.9 arc(137.61,105.11) 137.31,105.2 137.31,105.2 arc(137.01,105.12) 136.79,104.9 136.79,104.89 arc(136.64,104.75) 136.44,104.7 arc(136.24,104.75) 136.09,104.89 136.09,104.9 arc(135.87,105.11) 135.58,105.2 135.57,105.2 arc(135.28,105.12) 135.06,104.9 135.06,104.89 arc(134.91,104.75) 134.71,104.7 arc(134.51,104.75) 134.36,104.89 134.36,104.9 arc(134.14,105.11) 133.85,105.2 133.84,105.2 arc(133.64,105.25) 133.49,105.39 133.49,105.4 arc(133.27,105.62) 132.98,105.7 arc(132.78,105.75) 132.63,105.89 132.63,105.9 arc(132.41,106.11) 132.12,106.2 132.11,106.2 arc(131.81,106.12) 131.6,105.9 131.59,105.89 arc(131.45,105.75) 131.25,105.7 arc(131.04,105.75) 130.9,105.89 130.89,105.9 arc(130.68,106.11) 130.38,106.2 130.38,106.2 arc(130.21,106.23) 130.07,106.34 130.1,106.44 U1.AM53
  ART05 w0.135: 138.51,104.73 138.7,104.73 arc(138.94,104.68) 139.14,104.54 139.69,103.99 arc(139.78,103.93) 139.89,103.91 140.21,103.91 140.33,104.03 140.6,104.03 140.71,103.91 140.98,103.91 141.09,104.03 141.36,104.03 141.48,103.91 145.07,103.91 arc(145.41,103.97) 145.72,104.12 145.78,104.16 arc(146.15,104.35) 146.56,104.42 149.16,104.42 arc(149.59,104.33) 149.96,104.08 151,103.05 arc(151.24,102.68) 151.33,102.24 151.33,95.7 arc(151.4,95.36) 151.59,95.07 158.46,88.2 arc(158.71,87.83) 158.8,87.39 158.8,84.62 arc(158.84,84.36) 158.95,84.12 arc(158.99,84.07) 159.04,84.03 159.8,83.5 arc(159.95,83.43) 160.12,83.4 160.24,83.4 arc(160.87,83.28) 161.4,82.92 arc(162.66,82.08) 164.14,81.79 175.55,81.79 arc(175.98,81.7) 176.35,81.45 182.79,75.01 arc(183.08,74.82) 183.42,74.75 196.44,74.75 arc(196.72,74.81) 196.96,74.97 197.04,75.04 arc(197.36,75.26) 197.74,75.34 204.43,75.34 arc(204.77,75.4) 205.06,75.6 206.34,76.88 arc(206.71,77.13) 207.15,77.22 211.03,77.22 arc(211.28,77.26) 211.49,77.41 211.52,77.43 arc(211.66,77.64) 211.71,77.89 211.71,78.54 arc(211.77,78.84) 211.94,79.1 arc(212.13,79.23) 212.37,79.28 212.76,79.28 C615.1
PCIE_RC_TXN12: length 110.5
  ART05 w0.114: 138.46,105.73 138.43,105.73 138.4,105.7 138.17,105.7 arc(137.97,105.75) 137.82,105.89 137.82,105.9 arc(137.61,106.11) 137.31,106.2 137.29,106.2 137.28,106.19 arc(137.08,106.15) 136.91,106.04 136.91,106.04 136.62,105.75 arc(136.61,105.75) 136.6,105.74 arc(136.58,105.72) 136.55,105.71 arc(136.5,105.7) 136.44,105.7 arc(136.24,105.75) 136.09,105.89 136.09,105.9 arc(136.09,105.9) 136.09,105.9 arc(135.87,106.12) 135.58,106.2 135.57,106.2 arc(135.28,106.12) 135.06,105.9 arc(135.06,105.9) 135.06,105.9 135.06,105.9 arc(134.91,105.75) 134.71,105.7 134.71,105.7 arc(134.51,105.75) 134.36,105.89 arc(134.36,105.9) 134.36,105.9 134.35,105.92 arc(134.15,106.12) 133.89,106.19 arc(133.67,106.25) 133.49,106.4 arc(133.24,106.59) 132.94,106.67 132.93,106.67 arc(132.83,106.69) 132.74,106.75 132.65,106.84 arc(132.63,106.87) 132.63,106.9 arc(132.58,107.05) 132.59,107.2 arc(132.59,107.22) 132.6,107.23 132.7,107.26 U1.AL56
  ART05 w0.135: C617.1 212.76,83.28 212.46,83.28 arc(212.2,83.23) 211.99,83.08 arc(211.89,82.94) 211.86,82.78 211.86,81.74 arc(211.83,81.57) 211.73,81.43 211.63,81.32 arc(211.41,81.18) 211.15,81.13 207.01,81.13 arc(206.49,81.02) 206.05,80.73 204.84,79.52 arc(204.48,79.28) 204.07,79.2 198.93,79.2 arc(198.27,79.07) 197.72,78.7 195.04,76.02 arc(194.73,75.81) 194.36,75.74 184.17,75.74 arc(183.75,75.82) 183.4,76.06 176.77,82.69 arc(175.32,83.66) 173.61,84 162.06,84 arc(161.89,84.03) 161.75,84.12 arc(161.44,84.58) 161.34,85.11 161.34,96.96 arc(161.42,97.37) 161.66,97.73 162.39,98.46 arc(162.68,98.9) 162.79,99.41 162.79,101.04 arc(162.68,101.56) 162.39,102 161.15,103.24 arc(160.72,103.53) 160.2,103.63 151.92,103.63 arc(151.8,103.66) 151.69,103.73 150.37,105.05 arc(150,105.3) 149.56,105.38 145.77,105.38 arc(145.37,105.31) 145.04,105.08 145.01,105.06 arc(144.93,105) 144.82,104.98 144.25,104.98 144.14,105.09 143.87,105.09 143.76,104.98 143.49,104.98 143.37,105.09 143.1,105.09 142.99,104.98 142.72,104.98 142.6,105.09 142.34,105.09 142.22,104.98 141.95,104.98 141.84,105.09 141.57,105.09 141.45,104.98 141.18,104.98 arc(140.59,105.1) 140.08,105.44 arc(139.76,105.65) 139.38,105.73 138.46,105.73
PCIE_RC_TXN13: length 95.8
  ART05 w0.114: U1.AH53 130.1,108.44 130.07,108.34 arc(130.21,108.23) 130.38,108.2 130.38,108.2 arc(130.68,108.11) 130.89,107.9 arc(131.25,107.7) 131.6,107.9 131.6,107.9 arc(131.82,108.12) 132.11,108.2 132.11,108.2 arc(132.41,108.11) 132.63,107.9 132.63,107.89 arc(132.78,107.75) 132.98,107.7 arc(133.27,107.62) 133.49,107.4 133.49,107.39 arc(133.64,107.25) 133.84,107.2 133.85,107.2 arc(134.14,107.11) 134.36,106.9 134.36,106.89 arc(134.51,106.75) 134.71,106.7 arc(134.91,106.75) 135.06,106.89 135.06,106.9 arc(135.28,107.12) 135.57,107.2 135.58,107.2 arc(135.87,107.11) 136.09,106.9 136.09,106.89 arc(136.24,106.75) 136.44,106.7 arc(136.64,106.75) 136.79,106.89 136.79,106.9 arc(137.01,107.12) 137.31,107.2 137.31,107.2 arc(137.61,107.11) 137.82,106.9 137.82,106.89 arc(137.97,106.75) 138.17,106.7 138.37,106.7 138.4,106.73 138.43,106.73
  ART05 w0.135: C619.1 212.79,87.3 arc(212.73,87.26) 212.66,87.25 arc(212.65,87.25) 212.64,87.25 212.32,87.25 arc(212.2,87.24) 212.09,87.2 arc(211.95,87.12) 211.84,87.02 arc(211.66,86.77) 211.6,86.46 211.6,85.86 arc(211.44,85.46) 211.04,85.29 206.56,85.29 arc(205.92,85.42) 205.37,85.78 204.27,86.88 arc(203.84,87.17) 203.32,87.28 200.88,87.28 arc(200.46,87.36) 200.11,87.6 198.28,89.42 arc(198.05,89.77) 197.97,90.19 197.97,90.3 arc(197.86,90.81) 197.57,91.25 190.43,98.39 arc(190,98.68) 189.48,98.78 184.02,98.78 arc(183.6,98.86) 183.24,99.1 179.7,102.64 arc(179.39,102.85) 179.03,102.92 178.92,102.92 arc(178.66,102.97) 178.43,103.12 178.04,103.52 arc(177.6,103.81) 177.09,103.91 164.74,103.91 arc(164.32,103.99) 163.96,104.23 161.88,106.31 arc(161.45,106.6) 160.93,106.7 151.61,106.7 arc(151.25,106.65) 150.91,106.5 arc(150.71,106.41) 150.49,106.38 144.81,106.38 arc(144.65,106.4) 144.52,106.49 arc(144.51,106.49) 144.5,106.5 144.42,106.58 arc(144.26,106.69) 144.07,106.73 140.31,106.73 140.2,106.84 139.93,106.84 139.81,106.73 139.54,106.73 139.43,106.84 139.16,106.84 139.04,106.73 138.43,106.73
PCIE_RC_TXN14: length 91.9
  ART05 w0.114: 138.48,107.75 138.45,107.72 138.2,107.72 arc(137.98,107.77) 137.81,107.92 137.79,107.94 arc(137.58,108.13) 137.31,108.2 137.3,108.2 arc(137.01,108.12) 136.79,107.9 136.79,107.89 arc(136.64,107.75) 136.44,107.7 136.44,107.7 arc(136.44,107.7) 136.44,107.7 136.41,107.7 arc(136.32,107.71) 136.23,107.74 arc(136.19,107.77) 136.14,107.81 136.09,107.9 arc(135.87,108.12) 135.57,108.2 arc(135.28,108.12) 135.06,107.9 arc(134.91,107.75) 134.71,107.7 134.71,107.7 arc(134.51,107.75) 134.36,107.9 134.36,107.9 arc(134.36,107.9) 134.35,107.9 arc(134.16,108.1) 133.9,108.19 arc(133.84,108.2) 133.79,108.22 arc(133.66,108.27) 133.54,108.36 arc(133.5,108.39) 133.47,108.44 arc(133.26,108.61) 132.99,108.68 arc(132.79,108.73) 132.64,108.87 132.63,108.9 arc(132.57,109.06) 132.6,109.23 132.7,109.26 U1.AG56
  ART05 w0.135: C621.1 212.76,91.28 212.6,91.28 arc(212.31,91.22) 212.06,91.05 211.98,90.98 arc(211.78,90.67) 211.71,90.31 211.71,89.92 arc(211.56,89.56) 211.2,89.41 206.67,89.41 arc(206.25,89.49) 205.9,89.73 204.79,90.84 arc(204.35,91.13) 203.83,91.24 200.12,91.24 arc(199.7,91.32) 199.35,91.56 191.05,99.85 arc(190.61,100.14) 190.1,100.25 184.61,100.25 arc(184.2,100.33) 183.84,100.57 180.37,104.04 arc(180.16,104.35) 180.08,104.72 180.08,104.83 arc(179.99,105.29) 179.73,105.69 179.21,106.21 arc(178.77,106.5) 178.26,106.6 163.95,106.6 arc(163.53,106.69) 163.18,106.92 162.8,107.3 arc(162.36,107.59) 161.85,107.7 151.14,107.7 arc(150.81,107.65) 150.5,107.53 150.35,107.45 arc(150.19,107.39) 150.02,107.37 145.52,107.37 arc(145.36,107.4) 145.22,107.49 145.22,107.49 arc(145.21,107.49) 145.21,107.49 145.13,107.58 arc(144.93,107.71) 144.7,107.75 142.58,107.75 142.47,107.87 142.2,107.87 142.08,107.75 141.81,107.75 141.7,107.87 141.43,107.87 141.32,107.75 141.05,107.75 140.93,107.87 140.66,107.87 140.55,107.75 140.28,107.75 140.16,107.87 139.9,107.87 139.78,107.75 138.48,107.75
PCIE_RC_TXN15: length 95.3
  ART05 w0.114: U1.AD53 130.1,110.44 130.07,110.34 arc(130.21,110.23) 130.38,110.2 130.38,110.2 arc(130.68,110.11) 130.89,109.9 130.9,109.89 arc(131.04,109.75) 131.25,109.7 arc(131.45,109.75) 131.59,109.89 131.6,109.9 arc(131.81,110.12) 132.11,110.2 132.12,110.2 arc(132.41,110.11) 132.63,109.9 132.63,109.89 arc(132.78,109.75) 132.98,109.7 arc(133.27,109.62) 133.49,109.4 133.49,109.39 arc(133.64,109.25) 133.84,109.2 133.85,109.2 arc(134.14,109.11) 134.36,108.9 134.36,108.89 arc(134.71,108.7) 135.06,108.89 arc(135.06,108.9) 135.06,108.9 135.06,108.9 arc(135.06,108.9) 135.06,108.9 arc(135.28,109.12) 135.57,109.2 135.58,109.2 arc(135.87,109.11) 136.09,108.9 136.09,108.89 136.18,108.8 arc(136.3,108.72) 136.44,108.7 arc(136.5,108.7) 136.56,108.73 arc(136.64,108.78) 136.71,108.83 136.78,108.9 arc(136.79,108.91) 136.79,108.92 136.8,108.92 arc(137.01,109.12) 137.3,109.2 137.31,109.2 arc(137.6,109.12) 137.81,108.91 arc(137.82,108.91) 137.82,108.9 arc(137.97,108.75) 138.17,108.7 arc(138.18,108.7) 138.18,108.7 139.16,108.7 139.19,108.73 139.22,108.73
  ART05 w0.135: C623.1 212.76,95.28 212.55,95.28 arc(212.24,95.22) 211.99,95.04 211.91,94.96 arc(211.51,94.38) 211.38,93.69 211.38,93.68 arc(211.26,93.41) 210.99,93.29 207.06,93.29 arc(206.64,93.38) 206.28,93.61 205.02,94.88 arc(204.58,95.17) 204.06,95.28 198.16,95.28 arc(197.75,95.36) 197.39,95.6 192.24,100.75 arc(191.8,101.04) 191.29,101.14 185.51,101.14 arc(185.1,101.22) 184.74,101.46 183.17,103.03 arc(182.94,103.39) 182.85,103.8 182.85,105.49 arc(182.75,106) 182.46,106.44 180.78,108.11 arc(180.35,108.41) 179.83,108.51 169.66,108.51 arc(169.15,108.41) 168.71,108.11 168.46,107.86 arc(168.11,107.63) 167.69,107.54 164.28,107.54 arc(163.86,107.63) 163.51,107.86 163.08,108.29 arc(162.64,108.58) 162.13,108.69 148.84,108.69 arc(148.42,108.77) 148.07,109.01 147.82,109.26 arc(147.38,109.55) 146.86,109.65 142.75,109.65 142.63,109.77 142.36,109.77 142.25,109.65 141.98,109.65 141.87,109.77 141.6,109.77 141.48,109.65 140.97,109.65 arc(140.48,109.55) 140.06,109.27 139.61,108.83 arc(139.5,108.75) 139.37,108.73 139.22,108.73
PCIE_RC_TXP0: length 130.8
  ART05 w0.114: U1.BP55 132.39,95.44 132.42,95.32 arc(132.42,95.31) 132.42,95.3 arc(132.38,95.04) 132.46,94.8 arc(132.52,94.6) 132.46,94.4 arc(132.38,94.12) 132.44,93.84 arc(132.47,93.79) 132.51,93.75 132.59,93.66 arc(132.75,93.55) 132.94,93.51 arc(132.96,93.5) 132.98,93.5 132.98,93.5 arc(133.07,93.5) 133.16,93.47 arc(133.21,93.44) 133.25,93.4 133.39,93.21 arc(133.56,93.01) 133.76,92.86 134,92.71 arc(134.34,92.55) 134.71,92.5 arc(134.9,92.46) 135.04,92.33 135.05,92.32 135.06,92.29 arc(135.06,92.29) 135.06,92.29 135.07,92.28 arc(135.28,92.08) 135.56,92 135.57,92 arc(135.78,91.95) 135.92,91.81 135.93,91.8 arc(135.93,91.8) 135.93,91.8 arc(136.15,91.58) 136.44,91.5 136.49,91.5 arc(136.66,91.46) 136.79,91.33 arc(136.79,91.33) 136.79,91.33 136.81,91.29 arc(137.02,91.08) 137.31,91 arc(137.51,90.95) 137.66,90.81 137.66,90.8 arc(137.66,90.8) 137.66,90.8 arc(137.88,90.58) 138.17,90.5 138.4,90.5 138.44,90.47
  ART05 w0.135: C581.1 212.76,31.02 212.54,31.02 arc(212.39,30.99) 212.27,30.91 212.25,30.89 arc(212.03,30.56) 211.94,30.16 arc(211.93,30.1) 211.92,30.03 arc(211.76,29.59) 211.48,29.21 arc(211.47,29.2) 211.46,29.18 211.24,29 arc(211.15,28.94) 211.04,28.91 210.76,28.87 arc(210.67,28.86) 210.59,28.85 205.96,28.85 arc(204.87,28.64) 203.94,28.01 arc(203.35,27.62) 202.65,27.48 202.12,27.48 arc(201.02,27.7) 200.1,28.32 199.75,28.66 arc(198.81,29.29) 197.7,29.51 167.47,29.51 arc(165.81,29.84) 164.41,30.78 arc(163.55,32.07) 163.24,33.6 163.24,34.29 arc(162.71,36.75) 161.42,38.92 arc(161.18,39.22) 160.98,39.55 arc(160.89,39.7) 160.81,39.86 160.49,40.45 arc(160.47,40.5) 160.46,40.56 arc(159.73,42.81) 159.48,45.16 159.48,62.8 arc(159.42,63.14) 159.22,63.43 144.93,77.71 arc(144.69,78.09) 144.6,78.52 144.6,79.5 arc(144.53,79.84) 144.34,80.13 142.92,81.55 arc(142.64,81.74) 142.3,81.81 141.45,81.81 arc(140.97,82.01) 140.76,82.5 140.76,84.52 arc(140.7,84.86) 140.5,85.15 139.63,86.02 arc(139.27,86.56) 139.14,87.2 139.14,89.84 arc(139.09,90.1) 138.95,90.33 arc(138.81,90.44) 138.63,90.47 138.44,90.47
PCIE_RC_TXP1: length 132.3
  ART05 w0.114: U1.BN52 129.79,96.26 129.91,96.23 arc(130.12,96.06) 130.37,96 130.38,96 arc(130.58,95.95) 130.73,95.81 130.73,95.8 arc(130.95,95.58) 131.25,95.5 arc(131.54,95.58) 131.76,95.8 131.76,95.81 arc(131.91,95.95) 132.11,96 arc(132.31,95.95) 132.46,95.81 132.46,95.8 arc(132.68,95.59) 132.97,95.5 132.98,95.5 arc(133.18,95.45) 133.33,95.31 133.33,95.3 arc(133.38,95.1) 133.33,94.9 arc(133.25,94.6) 133.33,94.31 133.33,94.3 arc(133.55,94.08) 133.84,94 arc(134.04,93.95) 134.19,93.81 134.19,93.8 arc(134.41,93.58) 134.71,93.5 arc(134.91,93.45) 135.06,93.31 135.06,93.3 arc(135.28,93.08) 135.57,93 arc(135.78,92.95) 135.92,92.81 135.93,92.8 arc(136.14,92.59) 136.44,92.5 136.44,92.5 arc(136.64,92.45) 136.79,92.31 136.79,92.3 arc(137.01,92.08) 137.31,92 arc(137.51,91.95) 137.65,91.81 137.66,91.8 arc(137.87,91.59) 138.17,91.5 138.39,91.5 138.42,91.47
  ART05 w0.135: C587.1 212.76,36.02 212.3,36.02 arc(212.16,36) 212.04,35.92 arc(211.91,35.72) 211.86,35.49 211.86,34.05 arc(211.78,33.63) 211.54,33.28 arc(211.08,32.97) 210.54,32.87 207.91,32.87 arc(207.05,33.04) 206.32,33.53 arc(204.85,34.5) 203.13,34.85 200.78,34.85 arc(198.93,34.48) 197.36,33.43 196.52,32.59 arc(194.91,31.52) 193.02,31.14 171.96,31.14 arc(171.04,31.32) 170.25,31.85 165.11,36.99 arc(161.77,41.98) 160.6,47.88 160.6,64.5 arc(160.53,64.84) 160.34,65.13 156.83,68.64 arc(156.59,68.8) 156.31,68.86 156.19,68.86 arc(155.81,68.93) 155.49,69.15 148.57,76.07 arc(148.32,76.44) 148.23,76.88 148.23,77.5 arc(148.16,77.84) 147.97,78.13 147.52,78.58 arc(147.23,78.77) 146.89,78.84 146.58,78.84 arc(146.06,79.06) 145.84,79.58 145.84,79.99 arc(145.79,80.27) 145.64,80.5 143.84,82.29 arc(143.59,82.66) 143.51,83.1 143.51,84.06 arc(143.44,84.4) 143.25,84.69 142.58,85.35 arc(142.33,85.52) 142.05,85.6 arc(141.58,85.71) 141.19,85.98 140.51,86.67 arc(140.44,86.75) 140.38,86.84 140.27,87.07 arc(140.22,87.19) 140.21,87.31 140.21,90.07 arc(140.15,90.37) 139.98,90.63 139.32,91.28 arc(139.11,91.42) 138.86,91.47 138.42,91.47
PCIE_RC_TXP2: length 124.8
  ART05 w0.114: 138.43,92.47 138.4,92.47 138.37,92.5 138.17,92.5 arc(137.9,92.57) 137.69,92.76 137.65,92.81 arc(137.51,92.94) 137.32,93 arc(137.04,93.08) 136.82,93.26 136.73,93.37 arc(136.64,93.44) 136.54,93.48 136.4,93.51 arc(136.12,93.62) 135.91,93.83 arc(135.78,93.95) 135.61,94 arc(135.31,94.09) 135.07,94.29 135.02,94.35 arc(134.91,94.44) 134.78,94.49 arc(134.78,94.49) 134.77,94.49 134.66,94.5 arc(134.41,94.57) 134.22,94.76 134.19,94.81 arc(134.11,95.1) 134.19,95.4 arc(134.23,95.5) 134.25,95.6 arc(134.25,95.62) 134.25,95.63 arc(134.21,95.73) 134.15,95.83 arc(134.12,95.88) 134.07,95.91 arc(133.93,95.98) 133.78,96 arc(133.54,96.07) 133.36,96.24 arc(133.36,96.25) 133.35,96.25 133.32,96.31 arc(133.19,96.44) 133.01,96.49 132.92,96.49 arc(132.68,96.55) 132.5,96.72 132.47,96.77 arc(132.46,96.77) 132.46,96.78 132.44,96.82 arc(132.36,97.04) 132.37,97.27 arc(132.38,97.29) 132.38,97.3 132.38,97.31 arc(132.39,97.31) 132.39,97.32 132.39,97.33 arc(132.39,97.33) 132.4,97.34 132.4,97.34 132.37,97.45 U1.BK55
  ART05 w0.135: 138.43,92.47 139,92.47 arc(139.37,92.4) 139.69,92.19 140.91,90.97 arc(141.14,90.62) 141.22,90.2 141.22,87.58 arc(141.43,87.08) 141.94,86.87 142.22,86.87 arc(142.47,86.82) 142.69,86.67 144.97,84.39 arc(145.17,84.1) 145.23,83.76 145.23,82.94 arc(145.32,82.51) 145.57,82.13 149.01,78.69 arc(149.21,78.4) 149.27,78.06 149.27,77.16 arc(149.36,76.72) 149.61,76.35 155.72,70.23 arc(156.09,69.99) 156.53,69.9 157.06,69.9 arc(157.4,69.83) 157.69,69.64 161.51,65.82 arc(161.7,65.53) 161.77,65.19 161.77,59.65 arc(161.86,59.21) 162.1,58.84 164.41,56.54 arc(164.6,56.25) 164.67,55.91 164.67,44.95 arc(165.13,42.61) 166.46,40.63 169.9,37.18 170.67,36.41 arc(172.54,35.16) 174.75,34.72 194.42,34.72 arc(195.12,34.86) 195.71,35.25 arc(196.58,35.84) 197.61,36.04 203.8,36.04 arc(205.12,36.31) 206.25,37.06 206.5,37.31 arc(207.18,37.76) 207.97,37.92 211.14,37.92 arc(211.41,37.97) 211.64,38.13 arc(211.78,38.35) 211.83,38.6 211.83,39.01 arc(211.9,39.35) 212.1,39.64 212.35,39.9 arc(212.49,39.99) 212.66,40.02 212.76,40.02 C589.1
PCIE_RC_TXP3: length 126.2
  ART05 w0.114: 138.64,94.47 138.61,94.47 138.58,94.5 138.07,94.5 arc(137.83,94.61) 137.66,94.81 137.65,94.81 arc(137.51,94.95) 137.31,95 arc(137.01,95.08) 136.79,95.3 136.79,95.31 arc(136.64,95.45) 136.44,95.5 arc(136.14,95.58) 135.93,95.8 135.93,95.8 arc(135.85,96.1) 135.93,96.4 arc(135.98,96.6) 135.93,96.8 135.92,96.81 arc(135.78,96.95) 135.58,97.01 arc(135.38,96.96) 135.23,96.82 135.22,96.8 arc(134.87,96.53) 134.43,96.59 134.4,96.6 arc(134.29,96.69) 134.21,96.79 arc(134.06,96.94) 133.87,96.99 133.86,96.99 arc(133.7,97.03) 133.55,97.12 133.41,97.25 arc(133.35,97.3) 133.3,97.36 arc(133.18,97.46) 133.03,97.5 arc(132.7,97.6) 132.44,97.83 arc(132.3,97.96) 132.12,98 132.09,98 arc(131.81,98.08) 131.6,98.28 131.57,98.33 arc(131.57,98.33) 131.57,98.33 arc(131.57,98.33) 131.57,98.33 arc(131.28,98.5) 130.98,98.35 130.95,98.3 arc(130.94,98.3) 130.94,98.3 arc(130.72,98.08) 130.42,98 130.39,98 arc(130.14,98.05) 129.93,98.21 arc(129.92,98.22) 129.91,98.23 129.79,98.26 U1.BJ52
  ART05 w0.135: C591.1 212.76,44.02 212.6,44.02 arc(212.39,43.98) 212.22,43.87 212.04,43.69 arc(211.81,43.35) 211.73,42.94 arc(211.66,42.59) 211.47,42.3 211.43,42.26 arc(211.21,42.11) 210.94,42.06 206.6,42.06 arc(206.18,41.98) 205.83,41.74 204.48,40.4 arc(204.05,40.11) 203.53,40 199.34,40 arc(197.42,39.62) 195.78,38.53 arc(193.11,36.74) 189.96,36.12 177.85,36.12 arc(176.39,36.41) 175.15,37.23 173.59,38.8 170.39,41.99 arc(169.5,43.33) 169.19,44.91 169.19,51.36 arc(169.1,51.78) 168.87,52.13 168.11,52.89 arc(167.82,53.33) 167.71,53.84 167.71,55.66 arc(167.63,56.07) 167.39,56.43 163.06,60.76 arc(162.77,61.2) 162.67,61.71 162.67,65.88 arc(162.58,66.3) 162.35,66.65 158.43,70.57 arc(158.07,70.81) 157.66,70.89 157.07,70.89 arc(156.55,70.99) 156.12,71.28 150.62,76.78 arc(150.33,77.22) 150.23,77.73 150.23,78.73 arc(150.14,79.14) 149.91,79.5 146.54,82.86 arc(146.25,83.3) 146.15,83.81 146.15,84.33 arc(146.07,84.75) 145.83,85.1 143.17,87.76 arc(142.87,88.2) 142.77,88.72 142.77,91.21 arc(142.55,91.68) 142.08,91.9 arc(141.47,92.02) 140.96,92.37 138.9,94.42 arc(138.84,94.46) 138.77,94.47 138.64,94.47
PCIE_RC_TXP4: length 126.7
  ART05 w0.114: U1.BF55 132.27,99.51 arc(132.38,99.38) 132.39,99.22 arc(132.37,99.02) 132.44,98.83 132.44,98.83 arc(132.46,98.79) 132.48,98.76 132.5,98.72 arc(132.68,98.54) 132.92,98.47 133,98.47 arc(133.17,98.43) 133.3,98.3 133.3,98.3 arc(133.47,98.11) 133.71,98.05 133.84,98.05 arc(134.02,98) 134.16,97.87 134.19,97.8 arc(134.2,97.8) 134.2,97.8 arc(134.41,97.58) 134.71,97.5 134.71,97.5 arc(135.01,97.59) 135.22,97.8 135.23,97.81 arc(135.57,98) 135.92,97.81 135.93,97.8 arc(135.93,97.8) 135.93,97.8 arc(136.13,97.59) 136.4,97.51 arc(136.45,97.5) 136.51,97.48 arc(136.56,97.46) 136.62,97.44 arc(136.67,97.41) 136.71,97.37 136.92,97.17 arc(137.05,97.06) 137.21,97 137.28,96.99 arc(137.32,96.98) 137.36,96.98 arc(137.41,96.96) 137.47,96.94 arc(137.52,96.91) 137.56,96.88 137.77,96.67 arc(137.78,96.66) 137.78,96.66 arc(137.98,96.53) 138.21,96.49 138.27,96.49 arc(138.34,96.47) 138.4,96.43 138.51,96.32 arc(138.53,96.29) 138.54,96.25
  ART05 w0.135: 138.54,96.25 141.28,93.5 arc(141.71,93.21) 142.23,93.11 142.35,93.11 arc(142.69,93.04) 142.98,92.85 143.49,92.34 arc(143.73,91.99) 143.81,91.57 143.81,88.61 arc(143.85,88.41) 143.97,88.24 143.99,88.21 arc(144.16,88.1) 144.36,88.06 144.81,88.06 arc(145.23,87.98) 145.57,87.75 146.84,86.48 arc(147.07,86.13) 147.16,85.71 147.16,84.12 arc(147.26,83.6) 147.55,83.17 151.29,79.43 arc(151.53,79.07) 151.61,78.66 151.61,77.82 arc(151.71,77.31) 152,76.87 156.45,72.43 arc(156.88,72.14) 157.4,72.03 157.96,72.03 arc(158.38,71.95) 158.74,71.71 163.48,66.97 arc(163.72,66.61) 163.8,66.2 163.8,62.25 arc(163.9,61.74) 164.2,61.3 166.86,58.64 arc(167.3,58.34) 167.81,58.24 169.17,58.24 arc(169.58,58.16) 169.94,57.92 170.47,57.39 arc(170.7,57.04) 170.79,56.62 170.79,45.52 arc(171.18,43.56) 172.28,41.91 173.77,40.42 arc(174.96,39.62) 176.38,39.34 193.22,39.34 arc(193.74,39.45) 194.17,39.74 197.98,43.54 arc(198.33,43.78) 198.75,43.86 203.99,43.86 arc(204.5,43.97) 204.94,44.26 206.41,45.73 arc(206.77,45.97) 207.18,46.05 210.77,46.05 arc(211.47,46.34) 211.76,47.04 211.76,48.86 arc(211.87,49.43) 212.19,49.91 arc(212.32,49.99) 212.47,50.02 212.76,50.02 C593.1
PCIE_RC_TXP5: length 127.9
  ART05 w0.114: U1.BE52 129.79,100.26 129.91,100.23 arc(129.92,100.22) 129.93,100.21 arc(130.13,100.06) 130.37,100 130.38,100 arc(130.58,99.95) 130.73,99.81 130.73,99.8 arc(131.24,99.5) 131.76,99.8 131.76,99.81 arc(132.11,100) 132.46,99.81 132.46,99.8 arc(132.68,99.59) 132.97,99.5 132.98,99.5 arc(133.18,99.45) 133.33,99.31 133.33,99.3 arc(133.33,99.3) 133.33,99.3 arc(133.55,99.08) 133.84,99 arc(134.04,98.95) 134.19,98.81 134.19,98.8 arc(134.41,98.59) 134.7,98.5 134.71,98.5 arc(135,98.58) 135.22,98.8 arc(135.22,98.8) 135.22,98.8 135.23,98.81 arc(135.57,99) 135.92,98.81 135.93,98.8 arc(136.14,98.59) 136.44,98.5 136.44,98.5 arc(136.64,98.45) 136.79,98.31 136.79,98.3 arc(136.79,98.3) 136.8,98.3 arc(137.01,98.08) 137.31,98 arc(137.51,97.95) 137.65,97.81 137.66,97.8 arc(137.87,97.59) 138.17,97.5 138.52,97.5 138.84,97.18
  ART05 w0.135: C595.1 212.76,54.02 212.6,54.02 arc(212.41,53.99) 212.25,53.88 212.04,53.67 arc(211.85,53.38) 211.78,53.05 211.78,52.68 arc(211.56,52.14) 211.02,51.92 206.57,51.92 arc(206.15,51.83) 205.8,51.6 204.13,49.92 arc(203.69,49.63) 203.17,49.53 202.36,49.53 arc(201.94,49.45) 201.59,49.21 193.08,40.7 arc(192.64,40.41) 192.13,40.31 178.87,40.31 arc(177.08,40.66) 175.56,41.68 174.8,42.44 arc(173.52,44.35) 173.07,46.61 173.07,55.78 arc(172.99,56.2) 172.75,56.55 170.12,59.18 arc(169.77,59.42) 169.35,59.5 168.2,59.5 arc(167.69,59.6) 167.25,59.89 165.34,61.81 arc(165.05,62.24) 164.95,62.76 164.95,66.6 arc(164.86,67.02) 164.63,67.37 148.45,83.55 arc(148.16,83.98) 148.05,84.5 148.05,86.59 arc(147.97,87.01) 147.73,87.36 145.71,89.39 arc(145.41,89.83) 145.31,90.34 145.31,92.62 arc(145.27,92.84) 145.14,93.03 145.12,93.05 arc(144.93,93.17) 144.71,93.22 144.45,93.22 arc(143.73,93.51) 143.43,94.23 143.43,94.33 arc(143.37,94.62) 143.21,94.86 141.74,96.33 arc(141.56,96.45) 141.35,96.49 139.9,96.49 arc(139.56,96.56) 139.26,96.76 138.84,97.18
PCIE_RC_TXP6: length 107.2
  ART05 w0.114: 138.48,98.48 138.51,98.5 138.17,98.5 arc(137.88,98.58) 137.66,98.8 arc(137.66,98.8) 137.66,98.8 137.65,98.81 arc(137.51,98.95) 137.31,99 arc(137.31,99) 137.31,99 137.26,99 arc(137.22,99.01) 137.18,99.01 137.09,99.02 arc(136.95,99.08) 136.84,99.18 136.7,99.36 arc(136.66,99.41) 136.62,99.44 arc(136.53,99.48) 136.43,99.5 arc(136.14,99.61) 135.91,99.83 arc(135.57,100) 135.24,99.8 arc(135.21,99.77) 135.19,99.74 135.09,99.64 arc(134.94,99.54) 134.75,99.5 134.7,99.5 arc(134.41,99.58) 134.2,99.79 134.2,99.8 arc(134.2,99.8) 134.2,99.8 arc(134.19,99.8) 134.19,99.8 134.19,99.8 arc(134.19,99.81) 134.19,99.81 arc(134.05,99.95) 133.85,100 133.85,100 arc(133.55,100.08) 133.33,100.3 133.33,100.3 arc(133.33,100.3) 133.33,100.3 133.33,100.3 arc(133.33,100.31) 133.33,100.31 133.32,100.31 arc(133.19,100.44) 133,100.49 132.97,100.49 arc(132.68,100.57) 132.48,100.78 132.46,100.8 arc(132.38,101.04) 132.42,101.3 arc(132.42,101.31) 132.42,101.32 132.39,101.44 U1.BB55
  ART05 w0.135: 138.48,98.48 138.72,98.48 139,98.19 139.01,98.19 arc(139.01,98.19) 139.01,98.19 139.07,98.12 arc(139.12,98.07) 139.18,98.02 arc(139.31,97.94) 139.47,97.92 142.67,97.92 arc(142.81,97.89) 142.92,97.81 143.38,97.36 arc(143.74,96.82) 143.87,96.18 143.87,96.04 arc(143.94,95.66) 144.16,95.34 145.93,93.56 arc(146.17,93.21) 146.25,92.79 146.25,91.15 arc(146.35,90.64) 146.64,90.2 148.98,87.87 arc(149.22,87.51) 149.3,87.1 149.3,84.55 arc(149.4,84.04) 149.69,83.6 154.66,78.63 arc(158.12,76.32) 162.19,75.51 168.02,75.51 arc(168.44,75.43) 168.79,75.19 169.37,74.61 arc(169.81,74.32) 170.33,74.22 173.71,74.22 arc(174.01,74.16) 174.27,73.99 174.29,73.96 arc(174.46,73.71) 174.52,73.4 174.52,70.39 arc(174.62,69.88) 174.92,69.44 177.85,66.51 arc(178.28,66.22) 178.8,66.12 187.83,66.12 arc(188.25,66.03) 188.6,65.8 196.07,58.33 arc(196.5,58.04) 197.02,57.94 204.04,57.94 arc(204.56,58.04) 204.99,58.33 206.36,59.7 arc(206.72,59.94) 207.13,60.02 210.72,60.02 arc(211.13,59.94) 211.49,59.7 211.55,59.64 arc(211.74,59.35) 211.81,59 211.81,58.63 arc(211.85,58.43) 211.96,58.27 arc(212.23,58.09) 212.55,58.02 212.76,58.02 C597.1
PCIE_RC_TXP7: length 107.1
  ART05 w0.114: 138.59,99.47 138.56,99.47 138.53,99.5 138.17,99.5 arc(137.87,99.59) 137.66,99.8 137.65,99.81 arc(137.51,99.95) 137.31,100 arc(137.01,100.08) 136.79,100.3 136.79,100.31 arc(136.64,100.45) 136.44,100.5 136.44,100.5 arc(136.14,100.59) 135.93,100.8 135.92,100.81 arc(135.78,100.95) 135.57,101 arc(135.37,100.95) 135.23,100.81 135.22,100.8 arc(135.01,100.58) 134.71,100.5 134.7,100.5 arc(134.41,100.59) 134.19,100.8 134.19,100.81 arc(134.04,100.95) 133.84,101 arc(133.55,101.08) 133.33,101.3 133.33,101.31 arc(133.18,101.45) 132.98,101.5 132.97,101.5 arc(132.68,101.59) 132.46,101.8 132.46,101.81 arc(132.31,101.95) 132.11,102 arc(131.91,101.95) 131.76,101.81 131.76,101.8 arc(131.54,101.58) 131.25,101.5 131.24,101.5 arc(130.95,101.59) 130.73,101.8 130.73,101.81 arc(130.58,101.95) 130.38,102 130.37,102 arc(130.12,102.06) 129.91,102.23 129.79,102.26 U1.BA52
  ART05 w0.135: C599.1 212.76,62.02 212.6,62.02 arc(212.38,62.07) 212.2,62.19 212.04,62.35 arc(211.81,62.69) 211.73,63.08 211.73,63.44 arc(211.6,63.75) 211.3,63.88 207.59,63.88 arc(207.17,63.8) 206.82,63.56 205.58,62.32 arc(205.14,62.03) 204.62,61.92 194.68,61.92 arc(194.17,62.03) 193.73,62.32 189.34,66.71 arc(188.99,66.95) 188.57,67.03 181.42,67.03 arc(180.91,67.13) 180.47,67.42 177.07,70.82 arc(176.78,71.26) 176.68,71.77 176.68,72.69 arc(176.6,73.11) 176.36,73.47 174.94,74.89 arc(174.58,75.13) 174.17,75.21 172.46,75.21 arc(171.94,75.31) 171.51,75.6 170.65,76.46 arc(170.29,76.7) 169.87,76.78 161.93,76.78 arc(158.12,77.54) 154.89,79.7 154.47,80.11 150.63,83.95 arc(150.34,84.39) 150.24,84.91 150.24,88.52 arc(150.16,88.94) 149.92,89.29 147.61,91.6 arc(147.32,92.04) 147.22,92.55 147.22,93.14 arc(147.13,93.56) 146.9,93.91 146.01,94.8 arc(145.72,95.24) 145.62,95.75 145.62,95.94 arc(145.53,96.36) 145.3,96.71 143.22,98.79 arc(143.03,98.91) 142.81,98.96 140.06,98.96 arc(139.59,99.04) 139.17,99.27 138.96,99.44 arc(138.92,99.47) 138.88,99.47 138.59,99.47
PCIE_RC_TXP8: length 104.5
  ART05 w0.114: 138.51,100.47 138.48,100.47 138.45,100.5 138.21,100.5 arc(137.95,100.55) 137.72,100.71 137.49,100.94 arc(137.4,101) 137.29,101.02 137.2,101.02 arc(137.04,101.05) 136.91,101.15 136.83,101.24 arc(136.83,101.24) 136.82,101.25 arc(136.64,101.41) 136.43,101.51 136.42,101.51 arc(136.38,101.52) 136.34,101.53 136.33,101.53 arc(136.1,101.62) 135.93,101.8 arc(135.93,101.8) 135.93,101.8 135.92,101.81 arc(135.57,102) 135.23,101.81 135.22,101.8 arc(135.01,101.59) 134.71,101.5 134.64,101.5 arc(134.41,101.56) 134.23,101.74 134.19,101.8 134.16,101.85 arc(134.07,101.94) 133.96,101.98 133.86,101.98 arc(133.56,102.07) 133.33,102.27 arc(133.18,102.43) 132.97,102.48 132.94,102.48 arc(132.69,102.55) 132.5,102.74 132.46,102.8 arc(132.38,103.04) 132.42,103.3 132.42,103.32 132.39,103.44 U1.AV55
  ART05 w0.135: 138.51,100.47 138.85,100.47 arc(139.03,100.45) 139.21,100.41 arc(139.3,100.38) 139.39,100.36 139.64,100.29 arc(139.69,100.28) 139.73,100.28 142.9,100.28 arc(143.09,100.24) 143.26,100.13 143.56,99.82 145.99,97.39 arc(146.04,97.34) 146.08,97.29 arc(146.37,96.79) 146.52,96.23 arc(146.53,96.16) 146.53,96.09 arc(146.64,95.6) 146.92,95.18 147.96,94.15 arc(148.2,93.79) 148.28,93.37 148.28,93.27 arc(148.39,92.75) 148.68,92.31 151.06,89.93 arc(151.3,89.58) 151.38,89.16 151.38,85.03 arc(151.48,84.52) 151.78,84.08 153.62,82.24 155.14,80.72 arc(157.87,78.9) 161.08,78.26 173.91,78.26 arc(174.33,78.17) 174.69,77.94 178.54,74.08 arc(178.78,73.72) 178.86,73.31 178.86,72.46 arc(178.9,72.3) 178.99,72.16 arc(179.27,71.73) 179.37,71.23 179.37,70.48 arc(179.47,69.96) 179.77,69.53 179.89,69.41 arc(180.33,69.11) 180.84,69.01 188.39,69.01 arc(188.81,68.93) 189.16,68.69 192.23,65.62 arc(192.67,65.33) 193.19,65.23 199.16,65.23 arc(199.68,65.33) 200.12,65.62 200.37,65.87 arc(200.72,66.11) 201.14,66.19 205.59,66.19 arc(206.01,66.11) 206.36,65.87 206.64,65.6 arc(207.08,65.3) 207.59,65.2 211.3,65.2 arc(211.63,65.27) 211.91,65.45 211.91,65.46 arc(212.18,65.85) 212.27,66.31 212.27,66.67 arc(212.37,66.92) 212.62,67.02 212.76,67.02 C601.1
PCIE_RC_TXP9: length 106.7
  ART05 w0.114: U1.AU52 129.79,104.26 129.91,104.23 arc(129.92,104.22) 129.93,104.21 arc(130.13,104.06) 130.37,104 130.38,104 arc(130.58,103.95) 130.73,103.81 130.73,103.8 arc(131.24,103.5) 131.76,103.8 131.76,103.81 arc(132.11,104) 132.46,103.81 132.46,103.8 arc(132.68,103.59) 132.97,103.5 132.98,103.5 arc(133.18,103.45) 133.33,103.31 133.33,103.3 arc(133.33,103.3) 133.33,103.3 arc(133.55,103.08) 133.84,103 arc(134.04,102.95) 134.19,102.81 134.19,102.8 arc(134.41,102.59) 134.7,102.5 134.71,102.5 arc(135,102.58) 135.22,102.8 arc(135.22,102.8) 135.22,102.8 135.23,102.81 arc(135.57,103) 135.92,102.81 135.93,102.8 arc(136.14,102.59) 136.44,102.5 136.44,102.5 arc(136.64,102.45) 136.79,102.31 136.79,102.3 arc(136.79,102.3) 136.8,102.3 arc(137.01,102.08) 137.31,102 arc(137.51,101.95) 137.65,101.81 137.66,101.8 arc(137.87,101.59) 138.17,101.5 138.52,101.5 138.53,101.49
  ART05 w0.135: 138.53,101.49 139.15,101.49 arc(139.31,101.47) 139.46,101.42 arc(139.72,101.33) 140,101.3 143.17,101.3 arc(143.34,101.26) 143.49,101.16 147.33,97.32 arc(147.58,96.94) 147.67,96.5 147.67,96.5 147.67,96.39 arc(147.78,95.87) 148.07,95.44 151.98,91.53 arc(152.21,91.17) 152.3,90.75 152.3,85.41 arc(152.4,84.9) 152.69,84.46 154.23,82.92 arc(154.67,82.63) 155.19,82.52 155.21,82.52 arc(157.99,81.97) 160.34,80.4 160.44,80.3 arc(161.58,79.54) 162.92,79.27 174.53,79.27 arc(174.94,79.19) 175.3,78.95 179.89,74.36 arc(180.13,74.01) 180.21,73.59 180.21,72.37 arc(180.31,71.9) 180.58,71.49 180.63,71.44 arc(181.07,71.15) 181.58,71.04 185.71,71.04 arc(185.98,70.99) 186.2,70.84 186.28,70.76 arc(186.59,70.56) 186.95,70.48 191.46,70.48 arc(191.88,70.4) 192.24,70.16 195.81,66.59 arc(196.25,66.29) 196.77,66.19 198.63,66.19 arc(199.14,66.29) 199.58,66.59 199.8,66.81 arc(200.16,67.05) 200.58,67.13 204.93,67.13 arc(205.44,67.23) 205.88,67.53 207.2,68.84 arc(207.55,69.08) 207.97,69.16 211.15,69.16 arc(211.6,69.35) 211.78,69.8 211.78,70.03 arc(211.86,70.4) 212.07,70.71 212.38,71.02 212.76,71.02 C603.1
PCIE_RC_TXP10: length 102
  ART05 w0.114: U1.AP55 132.39,105.44 132.42,105.32 arc(132.42,105.31) 132.42,105.3 132.41,105.29 arc(132.41,105.28) 132.41,105.27 132.39,105.22 arc(132.37,105) 132.44,104.8 arc(132.44,104.8) 132.44,104.8 132.46,104.76 arc(132.67,104.55) 132.95,104.48 133,104.48 arc(133.14,104.45) 133.25,104.37 133.33,104.3 133.33,104.3 arc(133.55,104.08) 133.84,104 arc(134.02,103.96) 134.15,103.83 134.17,103.8 arc(134.17,103.8) 134.17,103.8 arc(134.39,103.58) 134.69,103.5 134.76,103.51 arc(135.01,103.57) 135.2,103.76 135.22,103.8 arc(135.37,103.95) 135.57,104 135.65,104 arc(135.79,103.98) 135.91,103.89 arc(135.93,103.87) 135.95,103.85 135.95,103.84 arc(136.46,103.54) 136.98,103.83 136.98,103.84 arc(137.26,104.02) 137.57,103.91 137.59,103.89 arc(137.67,103.81) 137.73,103.73 arc(137.8,103.65) 137.88,103.59 arc(137.98,103.54) 138.09,103.52 arc(138.23,103.51) 138.37,103.48 arc(138.55,103.41) 138.71,103.29 138.79,103.21 arc(138.81,103.18) 138.81,103.16 138.81,103.14 138.83,103.12
  ART05 w0.135: C605.1 212.76,75.02 212.41,75.02 arc(212.32,75) 212.24,74.95 arc(212.15,74.81) 212.12,74.64 212.12,73.98 arc(212.04,73.6) 211.82,73.27 arc(211.55,73.09) 211.22,73.02 206.85,73.02 arc(206.51,72.96) 206.22,72.76 204.65,71.2 arc(204.28,70.95) 203.85,70.87 195.79,70.87 arc(195.36,70.95) 194.98,71.2 192.96,73.22 arc(192.68,73.41) 192.34,73.48 182.79,73.48 arc(182.35,73.57) 181.98,73.82 175.59,80.21 arc(175.3,80.4) 174.96,80.47 163.95,80.47 arc(162.49,80.7) 161.17,81.38 arc(160.89,81.57) 160.59,81.75 159.82,82.16 arc(159.82,82.16) 159.82,82.16 arc(159.43,82.36) 159.06,82.58 arc(158.24,83) 157.38,83.34 arc(157.12,83.43) 156.86,83.51 arc(156.77,83.53) 156.67,83.54 155.41,83.54 arc(154.97,83.63) 154.6,83.87 153.54,84.93 arc(153.3,85.3) 153.21,85.74 153.21,91.19 arc(153.14,91.53) 152.95,91.82 148.95,95.82 arc(148.7,96.2) 148.61,96.63 148.61,96.96 arc(148.55,97.3) 148.35,97.59 143.37,102.57 arc(143.32,102.6) 143.27,102.62 139.75,102.62 arc(139.41,102.68) 139.11,102.85 arc(139.06,102.9) 139,102.96 138.83,103.12
PCIE_RC_TXP11: length 106.2
  ART05 w0.114: 138.51,104.47 138.48,104.5 138.17,104.5 arc(137.87,104.59) 137.66,104.8 137.65,104.81 arc(137.31,105) 136.96,104.81 136.96,104.8 arc(136.95,104.8) 136.95,104.8 arc(136.74,104.58) 136.44,104.5 136.44,104.5 arc(136.14,104.59) 135.93,104.8 135.92,104.81 arc(135.57,105) 135.23,104.81 135.22,104.8 arc(135.22,104.8) 135.22,104.8 arc(135,104.58) 134.71,104.5 134.7,104.5 arc(134.41,104.59) 134.19,104.8 134.19,104.81 arc(134.04,104.95) 133.84,105 arc(133.55,105.08) 133.33,105.3 arc(133.33,105.3) 133.33,105.3 133.33,105.31 arc(133.18,105.45) 132.98,105.5 132.97,105.5 arc(132.68,105.59) 132.46,105.8 132.46,105.81 arc(132.11,106) 131.76,105.81 131.76,105.8 arc(131.76,105.8) 131.76,105.8 arc(131.54,105.58) 131.25,105.5 131.24,105.5 arc(130.95,105.59) 130.73,105.8 130.73,105.81 arc(130.58,105.95) 130.38,106 130.37,106 arc(130.13,106.06) 129.93,106.21 arc(129.92,106.22) 129.91,106.23 129.79,106.26 U1.AN52
  ART05 w0.135: 138.51,104.47 138.7,104.47 arc(138.84,104.44) 138.96,104.36 139.52,103.8 arc(139.68,103.69) 139.87,103.66 145.07,103.66 arc(145.49,103.72) 145.87,103.92 145.93,103.96 arc(146.23,104.11) 146.56,104.16 149.16,104.16 arc(149.5,104.1) 149.78,103.9 150.82,102.87 arc(151.01,102.58) 151.08,102.24 151.08,95.7 arc(151.16,95.26) 151.41,94.89 158.28,88.02 arc(158.48,87.73) 158.54,87.39 158.54,84.62 arc(158.59,84.29) 158.74,83.98 arc(158.81,83.89) 158.9,83.82 159.66,83.29 arc(159.88,83.18) 160.12,83.15 160.24,83.15 arc(160.77,83.04) 161.22,82.74 arc(162.56,81.85) 164.14,81.53 175.55,81.53 arc(175.89,81.47) 176.17,81.27 182.62,74.83 arc(182.99,74.58) 183.42,74.5 196.44,74.5 arc(196.82,74.57) 197.14,74.79 197.22,74.86 arc(197.46,75.02) 197.74,75.08 204.43,75.08 arc(204.87,75.17) 205.24,75.42 206.52,76.7 arc(206.81,76.89) 207.15,76.96 211.03,76.96 arc(211.38,77.03) 211.67,77.23 211.69,77.25 arc(211.89,77.54) 211.96,77.89 211.96,78.54 arc(212,78.75) 212.12,78.92 arc(212.23,79) 212.37,79.02 212.76,79.02 C607.1
PCIE_RC_TXP12: length 110.5
  ART05 w0.114: 138.46,105.47 138.43,105.47 138.4,105.5 138.17,105.5 arc(137.88,105.58) 137.66,105.8 arc(137.66,105.8) 137.66,105.8 137.58,105.88 arc(137.47,105.96) 137.35,106 arc(137.29,106) 137.24,105.99 137.22,105.98 arc(137.16,105.96) 137.12,105.94 137.1,105.93 arc(137.05,105.9) 137.01,105.86 137,105.86 136.76,105.62 arc(136.73,105.59) 136.7,105.57 arc(136.66,105.55) 136.61,105.53 arc(136.53,105.51) 136.44,105.5 arc(136.14,105.58) 135.93,105.8 arc(135.93,105.8) 135.93,105.8 135.92,105.81 arc(135.57,106) 135.23,105.81 135.22,105.8 arc(135.01,105.58) 134.71,105.5 134.71,105.5 arc(134.41,105.58) 134.2,105.8 arc(134.19,105.8) 134.19,105.81 134.18,105.82 arc(134.06,105.95) 133.88,106 arc(133.88,106) 133.87,106 133.84,106 arc(133.57,106.07) 133.36,106.26 arc(133.35,106.27) 133.34,106.28 arc(133.16,106.42) 132.94,106.48 132.93,106.48 arc(132.75,106.52) 132.59,106.62 132.52,106.69 arc(132.42,106.85) 132.38,107.03 132.38,107.09 arc(132.39,107.17) 132.4,107.25 132.4,107.29 arc(132.41,107.33) 132.41,107.37 arc(132.38,107.43) 132.34,107.47 U1.AK55
  ART05 w0.135: 138.46,105.47 139.38,105.47 arc(139.66,105.42) 139.9,105.26 arc(140.49,104.86) 141.18,104.72 144.82,104.72 arc(145.02,104.76) 145.19,104.88 145.22,104.9 arc(145.47,105.07) 145.77,105.13 149.56,105.13 arc(149.9,105.06) 150.19,104.87 151.51,103.55 arc(151.7,103.42) 151.92,103.38 160.2,103.38 arc(160.62,103.29) 160.97,103.06 162.21,101.82 arc(162.45,101.46) 162.53,101.04 162.53,99.41 arc(162.45,99) 162.21,98.64 161.48,97.91 arc(161.19,97.47) 161.08,96.96 161.08,85.11 arc(161.21,84.48) 161.57,83.95 arc(161.79,83.8) 162.06,83.74 173.61,83.74 arc(175.22,83.42) 176.59,82.51 183.22,75.88 arc(183.65,75.59) 184.17,75.49 194.36,75.49 arc(194.83,75.58) 195.22,75.84 197.9,78.52 arc(198.37,78.83) 198.93,78.94 204.07,78.94 arc(204.58,79.04) 205.02,79.34 206.23,80.55 arc(206.59,80.79) 207.01,80.87 211.15,80.87 arc(211.5,80.94) 211.81,81.14 211.91,81.25 arc(212.06,81.48) 212.12,81.74 212.12,82.78 arc(212.13,82.85) 212.17,82.9 arc(212.3,82.99) 212.46,83.02 212.76,83.02 C616.1
PCIE_RC_TXP13: length 95.8
  ART05 w0.114: U1.AJ52 129.79,108.26 129.91,108.23 arc(130.12,108.06) 130.38,108 arc(130.58,107.95) 130.73,107.81 130.73,107.8 arc(131.24,107.5) 131.76,107.8 131.76,107.81 arc(131.91,107.95) 132.11,108 arc(132.31,107.95) 132.46,107.81 132.46,107.8 arc(132.68,107.59) 132.97,107.5 132.98,107.5 arc(133.18,107.45) 133.33,107.31 133.33,107.3 arc(133.55,107.08) 133.84,107 arc(134.04,106.95) 134.19,106.81 134.19,106.8 arc(134.41,106.59) 134.7,106.5 134.71,106.5 arc(135.01,106.58) 135.22,106.8 135.23,106.81 arc(135.37,106.95) 135.57,107 arc(135.78,106.95) 135.92,106.81 135.93,106.8 arc(136.14,106.59) 136.44,106.5 136.44,106.5 arc(136.74,106.58) 136.96,106.8 136.96,106.81 arc(137.11,106.95) 137.31,107 arc(137.51,106.95) 137.65,106.81 137.66,106.8 arc(137.87,106.59) 138.17,106.5 138.37,106.5 138.4,106.47 138.43,106.47
  ART05 w0.135: 138.43,106.47 144.07,106.47 arc(144.16,106.45) 144.24,106.4 144.32,106.32 144.32,106.32 arc(144.33,106.31) 144.35,106.3 arc(144.56,106.17) 144.81,106.12 150.49,106.12 arc(150.78,106.16) 151.05,106.29 arc(151.32,106.41) 151.61,106.45 160.93,106.45 arc(161.35,106.37) 161.71,106.13 163.79,104.05 arc(164.22,103.76) 164.74,103.66 177.09,103.66 arc(177.51,103.57) 177.86,103.34 178.25,102.94 arc(178.56,102.74) 178.92,102.67 179.03,102.67 arc(179.3,102.61) 179.52,102.46 183.06,98.92 arc(183.5,98.63) 184.02,98.53 189.48,98.53 arc(189.9,98.44) 190.25,98.21 197.39,91.07 arc(197.63,90.72) 197.71,90.3 197.71,90.19 arc(197.81,89.67) 198.11,89.24 199.93,87.42 arc(200.36,87.13) 200.88,87.02 203.32,87.02 arc(203.74,86.94) 204.09,86.7 205.19,85.61 arc(205.82,85.19) 206.56,85.04 211.04,85.04 arc(211.62,85.28) 211.86,85.86 211.86,86.46 arc(211.9,86.67) 212.02,86.84 arc(212.1,86.91) 212.19,86.97 arc(212.26,86.99) 212.32,87 212.64,87 arc(212.78,86.97) 212.89,86.89 C618.1
PCIE_RC_TXP14: length 92
  ART05 w0.114: U1.AF55 132.39,109.44 132.42,109.32 132.42,109.3 arc(132.38,109.04) 132.46,108.8 arc(132.46,108.8) 132.47,108.8 132.48,108.78 arc(132.69,108.56) 132.99,108.49 arc(133.17,108.44) 133.31,108.32 arc(133.36,108.27) 133.41,108.22 arc(133.42,108.21) 133.42,108.21 arc(133.57,108.11) 133.73,108.04 arc(133.8,108.02) 133.88,108 arc(134.06,107.94) 134.19,107.81 134.2,107.8 arc(134.41,107.58) 134.71,107.5 134.71,107.5 arc(135.01,107.59) 135.22,107.8 arc(135.37,107.95) 135.57,108 arc(135.77,107.95) 135.92,107.81 135.99,107.69 136.01,107.67 arc(136.07,107.62) 136.14,107.57 arc(136.28,107.5) 136.44,107.48 arc(136.73,107.56) 136.95,107.77 136.98,107.82 arc(137.12,107.96) 137.3,108 137.31,108 arc(137.49,107.96) 137.64,107.83 137.65,107.81 arc(137.89,107.6) 138.2,107.53 138.45,107.53 138.48,107.5
  ART05 w0.135: C620.1 212.76,91.02 212.6,91.02 arc(212.4,90.98) 212.24,90.87 212.16,90.8 arc(212.01,90.58) 211.96,90.31 211.96,89.92 arc(211.74,89.38) 211.2,89.15 206.67,89.15 arc(206.16,89.26) 205.72,89.55 204.61,90.66 arc(204.25,90.9) 203.83,90.98 200.12,90.98 arc(199.6,91.08) 199.17,91.38 190.87,99.67 arc(190.52,99.91) 190.1,99.99 184.61,99.99 arc(184.1,100.09) 183.66,100.39 180.19,103.86 arc(179.92,104.26) 179.83,104.72 179.83,104.83 arc(179.76,105.2) 179.55,105.51 179.03,106.03 arc(178.67,106.27) 178.26,106.35 163.95,106.35 arc(163.43,106.45) 163,106.74 162.62,107.12 arc(162.27,107.36) 161.85,107.44 151.14,107.44 arc(150.87,107.41) 150.62,107.31 150.47,107.23 arc(150.26,107.14) 150.02,107.11 145.52,107.11 arc(145.26,107.16) 145.04,107.3 arc(145.04,107.31) 145.03,107.31 144.95,107.4 arc(144.84,107.47) 144.7,107.5 138.48,107.5
PCIE_RC_TXP15: length 95.3
  ART05 w0.114: U1.AE52 129.79,110.26 129.91,110.23 arc(130.12,110.06) 130.37,110 130.38,110 arc(130.58,109.95) 130.73,109.81 130.73,109.8 arc(130.95,109.59) 131.24,109.5 131.25,109.5 arc(131.54,109.58) 131.76,109.8 131.76,109.81 arc(131.91,109.95) 132.11,110 arc(132.31,109.95) 132.46,109.81 132.46,109.8 arc(132.68,109.59) 132.97,109.5 132.98,109.5 arc(133.18,109.45) 133.33,109.31 133.33,109.3 arc(133.55,109.08) 133.84,109 arc(134.04,108.95) 134.19,108.81 134.19,108.8 arc(134.2,108.8) 134.2,108.8 arc(134.71,108.5) 135.22,108.8 arc(135.22,108.8) 135.22,108.8 135.23,108.81 arc(135.37,108.95) 135.57,109 135.58,109 arc(135.78,108.95) 135.92,108.81 135.94,108.77 136.05,108.67 arc(136.23,108.55) 136.44,108.5 arc(136.55,108.52) 136.65,108.56 arc(136.75,108.62) 136.84,108.69 136.91,108.76 arc(136.93,108.79) 136.95,108.82 136.96,108.82 arc(137.1,108.96) 137.3,109 137.31,109 arc(137.5,108.95) 137.65,108.81 137.66,108.81 arc(137.87,108.59) 138.17,108.5 138.17,108.5 arc(138.18,108.5) 138.18,108.5 139.16,108.5 139.19,108.47 139.22,108.47
  ART05 w0.135: 139.22,108.47 139.37,108.47 arc(139.6,108.52) 139.79,108.65 140.24,109.09 arc(140.57,109.32) 140.97,109.4 146.86,109.4 arc(147.28,109.31) 147.64,109.08 147.89,108.83 arc(148.33,108.53) 148.84,108.43 162.13,108.43 arc(162.54,108.35) 162.9,108.11 163.33,107.68 arc(163.76,107.39) 164.28,107.29 167.69,107.29 arc(168.2,107.39) 168.64,107.68 168.89,107.93 arc(169.25,108.17) 169.66,108.25 179.83,108.25 arc(180.25,108.17) 180.6,107.93 182.28,106.26 arc(182.51,105.9) 182.6,105.49 182.6,103.8 arc(182.7,103.29) 182.99,102.85 184.56,101.28 arc(185,100.99) 185.51,100.89 191.29,100.89 arc(191.71,100.8) 192.06,100.57 197.21,95.42 arc(197.65,95.13) 198.16,95.02 204.06,95.02 arc(204.48,94.94) 204.84,94.7 206.11,93.43 arc(206.54,93.14) 207.06,93.04 210.99,93.04 arc(211.44,93.23) 211.63,93.68 211.63,93.69 arc(211.75,94.28) 212.08,94.78 212.17,94.87 arc(212.34,94.98) 212.55,95.02 212.76,95.02 C622.1
PCIE_RC_WAKEN: length 299.9
  TOP w0.109: J14.B11 211.64,25.65 R239.2 212.66,26.67 214.09,26.67 v2(214.6,26.16) ; U23.U1 v2(45.13,165.52)
  ART03 w0.114: v2(45.13,165.52) 46.7,163.96 55.24,163.96 62.99,156.21 98.68,156.21 99.82,155.07 105.41,155.07 106.24,155.89 117.29,155.89 118.62,157.23 132,157.23 132.64,156.59 132.64,155.09 132.89,154.84 135.18,154.84 135.68,154.33 169.01,154.33 169.19,154.15 176.81,154.15 178.84,152.12 v2(180.16,152.12)
  ART20 w0.114: v2(214.6,26.16) 213.87,26.9 210.11,26.9 206.58,30.43 206.58,73.23 204.44,75.36 200.3,75.36 199.44,76.22 199.44,116.48 195.66,120.27 195.66,130.94 195.05,131.55 195.05,133.33 194.4,133.98 193.86,133.98 192.86,134.98 192.86,142.47 190.25,145.08 190.25,150.55 189.28,151.51 180.77,151.51 v2(180.16,152.12)
PCIE_TXN0: length 3.1
  TOP w0.097: J14.B15 209.97,31.65 210.37,31.25 211.85,31.25 C586.2
PCIE_TXN1: length 3.1
  TOP w0.097: J14.B20 209.97,36.65 210.37,36.25 211.85,36.25 C588.2
PCIE_TXN2: length 3.1
  TOP w0.097: J14.B24 209.97,40.65 210.37,40.25 211.85,40.25 C590.2
PCIE_TXN3: length 3.1
  TOP w0.097: J14.B28 209.97,44.65 210.37,44.25 211.85,44.25 C592.2
PCIE_TXN4: length 3.1
  TOP w0.097: J14.B34 209.97,50.65 210.37,50.25 211.85,50.25 C594.2
PCIE_TXN5: length 3.1
  TOP w0.097: J14.B38 209.97,54.65 210.37,54.25 211.85,54.25 C596.2
PCIE_TXN6: length 3.1
  TOP w0.097: J14.B42 209.97,58.65 210.37,58.25 211.85,58.25 C598.2
PCIE_TXN7: length 3.1
  TOP w0.097: C600.2 211.85,62.25 210.37,62.25 209.97,62.65 J14.B46
PCIE_TXN8: length 3.1
  TOP w0.097: C602.2 211.85,67.25 210.37,67.25 209.97,67.65 J14.B51
PCIE_TXN9: length 3.1
  TOP w0.097: J14.B55 209.97,71.65 210.37,71.25 211.85,71.25 C604.2
PCIE_TXN10: length 3.1
  TOP w0.097: C606.2 211.85,75.25 210.37,75.25 209.97,75.65 J14.B59
PCIE_TXN11: length 3.1
  TOP w0.097: J14.B63 209.97,79.65 210.37,79.25 211.85,79.25 C615.2
PCIE_TXN12: length 3.1
  TOP w0.097: C617.2 211.85,83.25 210.37,83.25 209.97,83.65 J14.B67
PCIE_TXN13: length 3.1
  TOP w0.097: J14.B71 209.97,87.65 210.37,87.25 211.85,87.25 C619.2
PCIE_TXN14: length 3.1
  TOP w0.097: C621.2 211.85,91.25 210.37,91.25 209.97,91.65 J14.B75
PCIE_TXN15: length 3.1
  TOP w0.097: C623.2 211.85,95.25 210.37,95.25 209.97,95.65 J14.B79
PCIE_TXP0: length 3.1
  TOP w0.097: J14.B14 209.96,30.65 210.36,31.05 211.85,31.05 C581.2
PCIE_TXP1: length 3.1
  TOP w0.097: C587.2 211.85,36.05 210.36,36.05 209.96,35.65 J14.B19
PCIE_TXP2: length 3.1
  TOP w0.097: J14.B23 209.96,39.65 210.36,40.05 211.85,40.05 C589.2
PCIE_TXP3: length 3.1
  TOP w0.097: J14.B27 209.96,43.65 210.36,44.05 211.85,44.05 C591.2
PCIE_TXP4: length 3.1
  TOP w0.097: C593.2 211.85,50.05 210.36,50.05 209.96,49.65 J14.B33
PCIE_TXP5: length 3.1
  TOP w0.097: J14.B37 209.96,53.65 210.36,54.05 211.85,54.05 C595.2
PCIE_TXP6: length 3.1
  TOP w0.097: C597.2 211.85,58.05 210.36,58.05 209.96,57.65 J14.B41
PCIE_TXP7: length 3.1
  TOP w0.097: J14.B45 209.96,61.65 210.36,62.05 211.85,62.05 C599.2
PCIE_TXP8: length 3.1
  TOP w0.097: C601.2 211.85,67.05 210.36,67.05 209.96,66.65 J14.B50
PCIE_TXP9: length 3.1
  TOP w0.097: C603.2 211.85,71.05 210.36,71.05 209.96,70.65 J14.B54
PCIE_TXP10: length 3.1
  TOP w0.097: J14.B58 209.96,74.65 210.36,75.05 211.85,75.05 C605.2
PCIE_TXP11: length 3.1
  TOP w0.097: J14.B62 209.96,78.65 210.36,79.05 211.85,79.05 C607.2
PCIE_TXP12: length 3.1
  TOP w0.097: J14.B66 209.96,82.65 210.36,83.05 211.85,83.05 C616.2
PCIE_TXP13: length 3.1
  TOP w0.097: C618.2 211.85,87.05 210.36,87.05 209.96,86.65 J14.B70
PCIE_TXP14: length 3.1
  TOP w0.097: C620.2 211.85,91.05 210.36,91.05 209.96,90.65 J14.B74
PCIE_TXP15: length 3.1
  TOP w0.097: J14.B78 209.96,94.65 210.36,95.05 211.85,95.05 C622.2
PG_1.2V: length 212.3
  TOP w0.109: U23.T2 v2(44.34,166.32)
  ART07 w0.114: v2(42.8,14.83) 43.64,15.67 47.55,15.67 49.6,17.72 49.6,18.23 49.61,18.23 49.61,23.29 52.55,26.24 54.43,26.24 60.78,32.59 60.78,38.48 67.91,45.61 67.91,51.09 60.94,58.06 48.11,58.06 45.97,60.2 45.59,60.2 44.07,61.72 38.73,61.72 27.41,73.05 27.41,119.91 27.69,120.19 27.69,126.42 30.68,129.41 30.68,140.07 30.68,140.07 30.68,142.16 32.36,143.84 32.64,143.84 32.91,144.11 32.91,145.29 32.92,145.3 32.92,145.8 33.44,146.32 36.05,146.32 36.7,146.96 38.43,146.96 39.07,146.32 39.41,146.32 40.82,147.72 40.82,148.36 42.58,150.13 42.58,152.48 43.53,153.43 43.53,155.65 42.58,156.6 42.58,160.55 44.21,162.18 44.21,163.32 43.94,163.59 43.94,165.93 v2(44.34,166.32)
  BOTTOM w0.254: v2(42.8,14.83) 43.38,15.42 46.53,15.42 47.78,16.66 47.78,17.51 R792.2
PG_1.8V: length 289.3
  TOP w0.109: U23.P3 v2(42.74,167.12)
  ART03 w0.114: v1(157.58,19.94) 157,20.52 148.87,20.52 139.73,29.67 138.02,29.67 136.07,31.62 116.1,31.62 113.67,29.18 113.67,19.46 112.27,18.06 102.11,18.06 101.24,18.92 101.24,19.71 100.48,20.47 99.31,20.47 97.61,22.17 97.61,28.3 92.61,33.3 90.14,33.3 88.9,34.54 88.9,37.01 88.21,37.69 88.21,42.13 87.04,43.31 85.47,43.31 83.51,45.27 83.51,59.38 83.08,59.81 83.08,64.74 81.94,65.89 74.42,65.89 73.3,67 73.3,74.57 71.17,76.71 62.56,76.71 58.6,80.67 50.31,80.67 47.9,83.08 47.9,86.56 49.04,87.71 49.04,96.39 48.13,97.31 48.13,101.04 47.5,101.68 43.93,101.68 32.74,112.87 32.74,126.45 32.18,127.01 32.18,135.09 33.57,136.48 37.72,136.48 44.17,142.93 45.13,142.93 46.36,144.16 46.36,148.48 45.59,149.25 44.65,149.25 44.22,149.68 44.22,151.59 43.76,152.04 43.76,152.63 44.07,152.93 44.07,154.28 42.42,155.93 42.42,158.52 42.64,158.75 42.64,160.43 42.19,160.88 42.19,162.18 43.15,163.14 43.15,164.42 42.31,165.25 42.31,166.7 v2(42.74,167.12)
  BOTTOM w0.109: R776.1 46.22,164.99 46.22,165.46 45.57,166.12 45.57,166.55 45.39,166.73 43.13,166.73 v2(42.74,167.12)
PG_2.5V: length 230.5
  TOP w0.109: v2(41.14,171.14) 41.14,171.12 U23.M7
  ART03 w0.114: v3(49.48,168.91) 47.37,168.91 46.76,169.52 45.74,169.52 45.36,169.14 40.92,169.14 40.74,169.32 40.74,170.18 41.14,170.58 v2(41.14,171.14) 40.75,171.53 40.11,171.53 39.93,171.35 39.93,165.12 40.66,164.39 40.66,163.45 40.41,163.19 40.41,162.66 41.63,161.44 41.63,158.11 42.01,157.73 42.01,155.83 43.71,154.13 43.71,153.44 43.13,152.86 43.13,149.73 43.94,148.92 45.36,148.92 45.79,148.49 45.79,147.67 45.31,147.19 45.31,144.24 44.84,143.77 44.58,143.77 37.59,136.79 33.44,136.79 31.87,135.21 31.87,126.88 32.43,126.32 32.43,112.75 32.89,112.28 32.89,105.34 30.18,102.62 30.18,85.09 32.76,82.5 46.58,82.5 48.92,80.16 58.62,80.16 62.89,75.89 62.89,74.42 65.28,72.03 68.22,72.03 71.68,68.58 71.68,64.19 74.63,61.24 74.63,50.68 74.95,50.36 74.95,49.03 79.06,44.92 79.39,44.92 79.86,44.45 81.76,44.45 82.73,43.48 82.73,30.43 84.2,28.96 91.61,28.96 93.31,27.26 93.31,20.51 92.05,19.25 90.14,19.25 v1(89.46,19.94)
  BOTTOM w0.109: R785.1 v3(49.48,168.91)
PG_3.3V: length 233.6
  TOP w0.109: U23.H6 v2(37.13,169.52)
  ART03 w0.114: v1(201.55,195.07) 202.23,194.39 207.97,194.39 208.38,193.97 208.38,193.01 v1(207.9,192.53)
  ART20 w0.114: v2(37.13,169.52) 37.53,169.91 37.53,172.05 38.09,172.61 40.4,172.61 40.77,172.97 40.77,180.47 41.15,180.85 59.79,180.85 60.1,180.54 64.08,180.54 64.9,181.36 70.1,181.36 71.86,179.6 71.86,178.78 71.65,178.58 71.65,169.39 76.2,164.85 97.92,164.85 99.82,166.75 105.54,166.75 107.7,164.59 130.05,164.59 130.43,164.21 130.43,163.58 131.83,162.18 133.22,162.18 135.38,160.02 162.69,160.02 163.32,160.66 166.24,160.66 168.78,163.19 171.25,163.19 174.14,166.09 175.44,166.09 179.27,169.93 182.37,169.93 183.39,170.94 183.39,178.05 187.38,182.04 194.44,182.04 197.41,185.01 198.83,185.01 200.67,186.85 202.63,186.85 203.4,186.08 v2(204.27,186.08)
  BOTTOM w0.109: v1(201.55,195.07) 201.55,194.45 202.01,193.99 202.01,191.11 202.51,190.6 204.44,190.6 204.75,190.3 204.75,189.87 204.88,189.74 204.88,188.39 205.59,187.68 205.59,187.58 205.6,187.56 205.6,186.88 205.59,186.87 205.59,186.32 R5311.1 204.46,185.64 204.27,185.83 v2(204.27,186.08)
