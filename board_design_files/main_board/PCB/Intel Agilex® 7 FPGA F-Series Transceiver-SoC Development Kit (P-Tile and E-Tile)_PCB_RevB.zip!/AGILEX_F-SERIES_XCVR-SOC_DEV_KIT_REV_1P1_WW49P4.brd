# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N30732069: length 1.6
  TOP w0.137: U7.C7 v2(75.51,142.52)
  BOTTOM w0.127: R127.2 75.61,142.52 v2(75.51,142.52)
N30732072: length 0.6
  TOP w0.137: U7.C2 v2(79.51,142.52)
N30732075: length 0.6
  TOP w0.137: U7.C8 v2(73.9,142.52)
N30732078: length 1.7
  TOP w0.137: U7.D3 v2(77.9,143.32)
  BOTTOM w0.127: R130.2 77.73,143.32 v2(77.9,143.32)
N30732081: length 0.6
  TOP w0.137: U7.D7 v2(75.51,143.32)
N30732436: length 0.6
  TOP w0.137: U7.E2 v2(79.51,144.12)
N30732839: length 1.7
  TOP w0.137: U7.B7 v2(75.51,141.72)
  BOTTOM w0.127: R133.2 76.24,140.99 v2(75.51,141.72)
N30732842: length 1.8
  TOP w0.137: U7.A7 v2(75.51,140.92)
  BOTTOM w0.127: v2(75.51,140.92) 75.25,140.65 R134.2
N31213276: length 3.8
  BOTTOM w0.109: U36.2 152.22,30.57 C837.1 151.84,30.95 Y4.1
N31213293: length 5.7
  BOTTOM w0.109: U36.1 152.41,30.07 C830.1 151.42,30.23 149.45,30.23 149.13,29.9 Y4.3
N31214782: length 5.7
  BOTTOM w0.109: U37.2 47.65,108.6 C847.1 47.28,108.77 46.33,109.73 45.15,109.73 Y5.1
N31214799: length 3.6
  BOTTOM w0.109: Y5.3 45.79,107.76 C843.1 47.81,108.1 U37.1
N31558092: length 0.6
  TOP w0.254: U3.E9 v2(84.53,144.12)
N31558448: length 0.6
  TOP w0.254: U4.E9 v2(95.96,144.12)
N31558945: length 0.6
  TOP w0.254: U5.E9 v2(107.39,144.12)
N31559300: length 0.6
  TOP w0.254: U6.E9 v2(118.82,144.12)
N31559457: length 0.6
  TOP w0.254: U7.E9 v2(73.1,144.12)
N31873956: length 1.7
  BOTTOM w0.109: U32.26 43.57,48.88 43.46,48.77 43.17,48.77 43.06,48.88 U32.27
N31873974: length 1.5
  BOTTOM w0.109: U32.25 44.06,48.95 44.17,48.84 44.46,48.84 44.57,48.95 U32.24
N32494365: length 3.1
  BOTTOM w0.109: U34.22 86.23,32.22 R417.2 R415.2
N32494380: length 5.7
  BOTTOM w0.109: U34.3 86.23,37.82 84.96,39.09 R424.2 84.95,39.81 84.4,40.36 84.4,41.41 R422.2
N32575920: length 2.4
  BOTTOM w0.109: R419.2 84.7,31.75 85.21,31.75 85.73,32.27 U34.23
N32575923: length 3.4
  BOTTOM w0.109: U34.2 85.73,37.65 R425.2
N34015045: length 1.9
  TOP w0.109: C956.2 32.86,187.26 U48.5
N34015049: length 2.8
  TOP w0.254: U48.9 34.36,191.9 34.83,192.37 R518.1 34.9,193.23 R513.2
N2499545414: length 4.7
  BOTTOM w0.109: U24.22 30.54,136.1 30.66,135.99 30.66,133.59 R313.1
N2499545415: length 2
  BOTTOM w0.109: U24.21 31.18,135.76 R315.1
N2499545416: length 4.7
  BOTTOM w0.109: R317.1 31.95,133.61 31.95,136.24 31.81,136.38 U24.20
N2499545417: length 2
  BOTTOM w0.109: U24.19 32.45,135.76 R319.1
N2499545418: length 4.8
  BOTTOM w0.109: U24.18 33.08,136.18 33.27,135.99 33.27,133.67 R321.1
N2499545419: length 2
  BOTTOM w0.109: U24.17 33.72,135.76 R323.1
N2499545420: length 4.8
  BOTTOM w0.109: R325.1 34.52,133.7 34.52,135.97 34.35,136.13 U24.16
N2499545421: length 2
  BOTTOM w0.109: R327.1 34.99,135.76 U24.15
N2499545422: length 4.8
  BOTTOM w0.109: U24.14 35.62,136.43 35.76,136.3 35.76,133.72 R329.1
N2499545423: length 2
  BOTTOM w0.109: R331.1 36.26,135.76 U24.13
N2499548814: length 4.8
  BOTTOM w0.109: U25.22 40.7,136.43 40.99,136.14 40.99,133.66 R314.1
N2499548815: length 2
  BOTTOM w0.109: R316.1 41.34,135.89 U25.21
N2499548816: length 4.8
  BOTTOM w0.109: R318.1 42.26,133.66 42.26,135.97 41.97,136.25 U25.20
N2499548817: length 2
  BOTTOM w0.109: U25.19 42.61,136.36 42.93,136.04 R320.1
N2499548818: length 4.8
  BOTTOM w0.109: U25.18 43.24,136.25 43.56,135.94 43.56,133.69 R322.1
N2499548819: length 2
  BOTTOM w0.109: R324.1 44.2,136.19 43.88,136.51 U25.17
N2499548820: length 4.8
  BOTTOM w0.109: U25.16 44.51,136.61 44.78,136.35 44.78,133.64 R326.1
N2499548821: length 2
  BOTTOM w0.109: U25.15 45.15,136.56 45.47,136.24 R328.1
N2499548822: length 4.8
  BOTTOM w0.109: R330.1 46.05,133.64 46.05,136.24 45.78,136.51 U25.14
N2499548823: length 2
  BOTTOM w0.109: R332.1 46.42,135.89 U25.13

## Copper pours and planes (outline as drawn)
1.2V on ART07 (solid shape): outline of 3688 points within 22.48,9.14 43.15,21.97
1.2V on TOP: 34.42,11.86 34.42,14.25 34.77,14.61 40.56,14.61 41.14,15.18 43.17,15.18 43.37,14.97 43.37,12.24 42.99,11.86 41.1,11.86 40.92,12.04 36.75,12.04 36.4,11.68 34.59,11.68
1.8V on TOP: 174.85,135.13 174.85,138.05 175.23,138.43 177.39,138.43 177.65,138.68 177.65,139.95 177.39,140.21 173.71,140.21 173.71,135.76 172.69,134.75 172.69,133.98 172.82,133.86 173.58,133.86
1.8V on TOP: 161.26,130.56 157.96,130.56 157.83,130.43 157.83,128.27 157.96,128.14 161.26,128.14 161.39,128.27 161.39,130.43
1.8V on TOP: 159.99,141.86 161.52,141.86 162.15,142.49 162.15,145.67 161.77,146.05 157.07,146.05 156.44,145.41 156.44,141.99 156.56,141.86 157.96,141.86 158.09,141.99 158.09,144.27 158.47,144.65 159.61,144.65 159.87,144.4 159.87,141.99
1.8V on TOP: 155.65,23.27 157.84,23.27 158.04,23.47 158.04,27.08 157.48,27.64 143.97,27.64 143.28,26.95 143.28,23.52 143.66,23.14 149.76,23.14 150.81,22.09 155.33,22.09 155.52,22.28 155.52,23.14
1.8V on BOTTOM: 152.93,37.39 152.93,36.22 152.78,36.07 150.8,36.07 150.57,36.3 150.57,37.26 150.85,37.54 152.78,37.54
1.8V on BOTTOM: 146.1,23.93 146.1,27.1 146.53,27.53 151,27.53 152.37,26.16 158.9,26.16 159.56,25.5 159.56,22.78 159.18,22.4 156.06,22.4 155.6,21.95 151.66,21.95 150.19,23.42 146.61,23.42
1.8V on BOTTOM: 47.67,104.7 48.56,104.7 48.71,104.55 48.71,103.45 48.41,103.15 46.91,103.15 46.45,103.61 46.45,104.77 46.71,105.03 47.34,105.03
1.8V on BOTTOM: 42.55,169.93 42.93,169.93 43.18,170.18 43.18,171.96 43.56,172.34 46.35,172.34 46.48,172.21 46.48,171.07 45.85,170.43 45.85,169.54 46.86,169.54 46.99,169.67 46.99,173.35 46.86,173.48 46.48,173.48 45.97,172.97 41.15,172.97 41.02,172.85 41.02,172.34 41.27,172.34 41.4,172.21 41.4,171.96 41.66,171.7 42.42,171.7 42.55,171.58
1.8V on BOTTOM: 170.69,84.51 175.72,84.51 176.02,84.2 178.18,84.2 178.31,84.33 178.31,86.21 178.18,86.33 170.69,86.33 170.61,86.26 170.61,84.58
1.8V on POWER09: 3.68,189.48 57,189.48 57,103.38 22.96,103.38 22.96,60.96 9.99,47.99 9.99,42.96 9.73,42.7 9.73,38.38 10.26,37.85 79.71,37.85 86.95,45.08 125.45,45.08 125.45,27.05 126.13,26.37 140.94,26.37 142.21,27.63 142.21,66.17 150.06,66.17 159.48,75.59 159.48,91.06 160.25,91.82 171.42,91.82 171.68,91.57 171.68,89.68 175.13,86.23 180.21,86.23 181.2,85.24 181.2,75.59 182.37,74.42 193.75,74.42 195.04,75.71 195.04,127.99 193.5,129.54 177.29,129.54 176.38,128.63 176.38,121.64 165.09,110.36 157.2,110.36 157.2,148.18 177.29,168.28 177.29,190.63 177.67,191.01 189.84,191.01 201.27,179.58 214.63,179.58 214.76,179.45 215.26,178.94 215.26,4.45 213.87,3.05 13.59,3.05 13.59,5.08 3.05,15.62 3.05,188.85 ; 14 cut-outs
1.8V_SI5338_0 on BOTTOM: 152.12,35.69 154.15,35.69 154.28,35.56 154.28,34.42 154.15,34.29 152.25,34.29 152.12,34.42
1.8V_SI5338_0 on ART05: 156.37,37.27 158.52,35.13 158.52,33.02 159.74,31.8 159.74,26.67 158.98,25.91 148.82,25.91 147.04,27.69 147.04,33.91 148.94,35.81 152.05,35.81 153.52,37.27
1.8V_SI5338_1 on BOTTOM: 50.04,106.68 49.93,106.58 49.93,105.08 49.81,104.95 47.93,104.95 47.77,105.1 47.77,106.5 48.92,107.65 49.94,107.65 50.04,107.54
1.8V_SI5338_1 on ART07: 47.88,114.91 55.04,114.91 56.18,113.77 56.18,105.31 55.01,104.14 50.39,104.14 49.88,104.65 47.24,104.65 45.97,105.92 45.97,113 ; 1 cut-out
2.5V on ART03 (solid shape): outline of 122 points within 15.88,4.72 40.18,9.19
2.5V on TOP: 88.77,29.51 78.44,29.51 77.77,28.85 77.77,23.67 78.31,23.14 82.09,23.14 83.15,22.09 84.61,22.09 84.61,22.09 87.12,22.09 87.33,22.3 87.33,22.89 87.73,23.29 89.76,23.29 89.92,23.44 89.92,28.37
2.5V on TOP: 87.63,59.94 87.62,59.96 86.95,59.96 86.46,60.45 86.46,62.86 87.09,63.5 91.23,63.5 91.46,63.27 91.46,60.1 91.31,59.94
2.5V on BOTTOM: 77.98,23.77 77.98,27.41 78.33,27.76 91.77,27.76 92.53,27 92.53,24.54 92.18,24.18 90.3,24.18 89.97,23.85 89.97,23.16 89.79,22.99 88.19,22.99 87.77,22.57 87.77,22.53 87.13,21.89 83.97,21.89 83.62,22.25 83.62,22.89 83.08,23.42 78.33,23.42
2.5V on BOTTOM: 89.66,59.94 90.17,60.45 90.17,64.39 90.07,64.49 84.94,64.49 84.5,64.06 84.5,60.3 84.86,59.94
2.5V on POWER11: 97.54,3.05 14.61,3.05 14.61,3.56 9.27,3.56 9.27,3.05 3.05,3.05 3.05,149.86 28.96,149.86 34.16,144.65 56.87,144.65 56.87,104.77 84.81,76.83 97.92,76.83 97.92,3.43 ; 14 cut-outs
2.5V on ART18: 49.07,132.08 51.18,132.08 52.57,133.48 79.75,133.48 81.15,132.08 127.15,132.08 128.88,133.81 128.88,137.82 130.55,139.5 130.56,139.5 130.56,155.96 129.54,156.97 58.8,156.97 54.35,152.53 54.35,148.61 48.03,142.29 48.03,133.12 ; 1 cut-out
3.3V on TOP (solid shape): outline of 206 points within 188.82,184.05 200.89,196.85
3.3V on TOP (solid shape): outline of 263 points within 207.19,184.53 216.6,195.55
3.3V on BOTTOM (solid shape): outline of 197 points within 188.26,186.13 200.89,196.9
3.3V on BOTTOM (solid shape): outline of 221 points within 207.62,184.71 216.81,195.63
3.3V on TOP: 57.1,100.46 62.43,100.46 63.02,99.87 63.02,95.68 62.56,95.22 60.3,95.22 57.18,95.22 57.05,95.35 57.05,96.57 57.23,96.75 59.28,96.75 59.56,97.03 59.56,98.35 59.16,98.75 57,98.75 56.77,98.98 56.77,100.13
3.3V on TOP: 110.49,20.65 110.49,22.2 110.08,22.61 110.08,22.78 109.96,22.91 107.98,22.91 107.77,22.71 107.77,22.07 107.52,21.82 106.55,21.82 106.22,21.49 106.22,18.52 105.97,18.26 103.84,18.26 102.51,16.94 97.82,16.94 97.54,16.66 97.54,14.88 97.93,14.49 102.55,14.49 103.05,14 106.2,14 106.68,13.51 106.68,12.9 106.93,12.65 107.49,12.65 107.72,12.42 107.72,11.73 107.87,11.58 110.13,11.58 110.36,11.81 110.36,12.78 111.73,14.15 111.73,19.41
3.3V on TOP: 135.48,20.24 135,20.73 135,21.29 134.82,21.46 134.82,22.68 134.7,22.81 132.79,22.81 132.66,22.68 132.66,22 132.36,21.69 131.39,21.69 131.04,21.34 131.04,18.59 130.86,18.41 128.88,18.41 127.28,16.81 122.61,16.81 122.4,16.61 122.4,14.66 122.69,14.36 125.67,14.36 125.78,14.25 126.75,14.25 127.05,13.94 127.56,13.94 128.65,12.85 132.26,12.85 132.49,12.62 132.49,12.12 132.69,11.91 134.62,11.91 135.08,12.37 135.13,12.37 135.13,12.65 136.47,14 136.47,19.81 136.04,20.24
3.3V on TOP: 91.43,18.05 91.21,18.26 91.21,20.04 90.3,20.95 90.3,22.5 89.87,22.94 87.96,22.94 87.71,22.68 87.71,22.05 87.38,21.72 86.77,21.72 86.23,21.18 86.23,18.36 85.99,18.12 83.2,18.12 82.32,17.25 77.85,17.25 77.67,17.07 77.67,15.47 78.35,14.8 80.71,14.8 81.13,14.38 82.78,14.38 83.11,14.05 86.26,14.05 86.49,13.82 86.49,13.21 86.74,12.95 87.3,12.95 87.53,12.73 87.53,12.04 87.68,11.89 89.94,11.89 90.17,12.12 90.17,13.08 91.41,14.33 91.41,16.33 91.43,16.34
3.3V on TOP: 24.66,36.93 22.94,36.93 22.81,36.8 22.81,34.82 23.01,34.62 23.65,34.62 23.9,34.37 23.9,33.4 24.23,33.07 27.2,33.07 27.46,32.82 27.46,30.68 28.52,29.62 28.52,25.32 28.85,24.99 30.84,24.99 31.23,25.39 31.23,29.4 31.72,29.9 31.72,33.05 32.21,33.53 32.61,33.53 33.07,33.99 33.07,34.34 33.3,34.57 33.6,34.57 33.78,34.75 33.78,36.75 33.32,37.21 32.94,37.21 31.57,38.58 26.31,38.58
3.3V on TOP: 42.1,39.26 40.55,39.26 40.39,39.09 40.21,39.09 40.08,38.96 40.08,36.98 40.28,36.78 40.92,36.78 41.17,36.53 41.17,35.56 41.5,35.23 44.48,35.23 44.73,34.98 44.73,32.84 45.82,31.75 45.82,27.64 46.18,27.28 48.23,27.28 48.5,27.55 48.5,31.56 49,32.05 49,35.2 49.48,35.69 49.83,35.69 50.34,36.2 50.34,36.5 50.57,36.73 50.88,36.73 51.05,36.91 51.05,39.07 50.75,39.37 50.22,39.37 48.84,40.74 43.59,40.74
3.3V on TOP: 185.27,93.47 183.61,93.47 183.23,93.85 183.23,94.74 183.49,95 184.63,95 185.27,94.36
3.3V on TOP: 16.46,153.52 16.46,150.57 16.84,150.19 16.84,149.02 16.31,148.49 16.31,144.48 16.21,144.37 15.75,144.37 15.54,144.17 15.54,141.94 15.7,141.78 16.46,141.78 17.81,140.44 23.72,140.44 24.08,140.79 24.08,141.55 24.49,141.96 24.99,141.96 25.32,142.29 26.21,142.29 26.42,142.49 26.42,144.17 26.11,144.48 25.55,144.48 24.28,145.75 24.28,148.77 23.36,149.69 19.14,149.69 18.69,150.14 18.69,153.44 18.38,153.76 16.7,153.76
3.3V on TOP: 75.77,49.96 75.77,48.34 75.9,48.21 76.48,48.21 76.63,48.36 76.63,49.96 76.56,50.04 75.84,50.04
3.3V on TOP: 190.09,93.47 192.63,93.47 193.01,93.85 193.01,95.25 192.63,95.63 190.47,95.63 190.09,95.25
3.3V on TOP: 142.32,141.68 143.89,141.68 144.07,141.86 144.07,142.34 143.92,142.49 142.34,142.49 142.32,142.47
3.3V on TOP: 184.12,120.27 186.03,120.27 186.41,119.89 186.41,118.87 186.14,118.6 185.66,118.6 185.39,118.87 183.87,118.87 183.87,120.01
3.3V on TOP: 158.6,20.68 158.27,21.01 158.27,22.61 157.81,23.06 156.11,23.06 155.73,22.68 155.73,22.05 155.45,21.77 154.66,21.77 154.18,21.29 154.18,18.52 153.9,18.24 151.89,18.24 150.52,16.87 146.05,16.87 145.87,16.69 145.85,16.69 145.52,16.36 145.52,14.55 146.08,14 150.98,14 151.31,13.67 154.23,13.67 154.97,12.93 155.42,12.93 155.6,12.75 155.6,12.24 155.88,11.96 157.94,11.96 158.37,12.4 158.37,12.7 159.61,13.94 159.61,15.95 159.63,15.96 159.63,18.83 159.64,18.85 159.64,20.42 159.38,20.68
3.3V on TOP: 73.63,65.84 68.63,65.84 68.33,66.14 68.33,67.89 68.66,68.22 69.24,68.22 69.28,68.18 70.32,68.18 70.33,68.17 70.69,68.17 71.2,68.68 71.2,72.05 70.54,72.7 67.49,72.7 67.49,72.72 67.28,72.92 67.28,73.3 67.54,73.56 68,73.56 68.4,73.96 68.4,75.36 68.76,75.72 73.61,75.72 74.35,74.98 74.35,66.55
3.3V on TOP: 7.75,40.46 7.26,39.98 5.54,39.98 5.41,39.85 5.41,37.87 5.61,37.67 6.25,37.67 6.5,37.41 6.5,36.45 6.83,36.12 9.8,36.12 10.06,35.86 10.06,33.73 11.05,32.74 11.05,28.47 11.35,28.17 13.32,28.17 13.83,28.68 13.83,32.45 14.33,32.94 14.33,36.09 14.81,36.58 15.27,36.58 15.67,36.98 15.67,37.39 15.9,37.62 16.18,37.62 16.36,37.8 16.36,39.88 15.98,40.26 15.54,40.26 14.17,41.63 8.15,41.63 7.75,41.22
3.3V on TOP: 203.02,24.99 195.5,24.99 195.15,24.64 195.15,23.29 195.55,22.88 200.15,22.88 200.45,23.19 203.05,23.19 203.22,23.37 203.22,24.79
3.3V on TOP: 190.09,118.87 192.25,118.87 192.63,119.25 192.63,120.22 192.33,120.52 190.24,120.52 190.09,120.37
3.3V on BOTTOM: 162.59,103.05 162.59,101.96 162.69,101.85 166.24,101.85 166.47,102.08 166.47,103.68 166.37,103.78 165.35,103.78 164.64,103.07 162.61,103.07
3.3V on BOTTOM: 190.73,95.63 192.38,95.63 192.89,95.12 192.89,93.73 192.5,93.34 190.96,93.34 190.73,93.58
3.3V on BOTTOM: 35.48,92.79 33.73,92.79 33.58,92.63 33.58,89.99 33.91,89.66 36.47,89.66 36.6,89.79 36.6,90.83 35.68,91.74 35.68,92.58
3.3V on BOTTOM: 173.1,103.07 173.79,103.07 174.5,103.78 175.39,103.78 176.05,103.12 176.94,103.12 177.01,103.05 177.01,102.01 176.83,101.83 173.13,101.83 173.05,101.9 173.05,103.02
3.3V on BOTTOM: 67.79,65.38 71.75,65.38 72.72,66.34 72.72,74.14 71.96,74.9 67.72,74.9 67.41,74.6 67.41,68.43 67.74,68.1 67.74,65.43
3.3V on BOTTOM: 17.73,148.16 16.43,149.45 16.43,153.59 16.65,153.81 18.33,153.81 18.59,153.54 18.59,150.44 20.37,148.67 24.46,148.67 25.2,147.93 25.2,147.47 25.17,147.45 25.17,144.53 25.45,144.25 26.11,144.25 26.52,143.84 26.52,141.05 26.11,140.64 22.48,140.64 21.44,141.68 20.24,141.68 19.96,141.4 19.96,141 19.63,140.67 18.08,140.67 17.73,141.02
3.3V on BOTTOM: 57.71,99.85 57.71,95.02 58.32,94.41 60.83,94.41 61.32,94.89 61.32,99.72 60.68,100.36 58.22,100.36
3.3V on BOTTOM: 190.65,119.66 190.65,118.77 190.7,118.72 191.62,118.72 191.77,118.87 191.77,119 192,119.23 192.25,119.23 192.38,119.35 192.38,120.12 191.92,120.57 191.92,121.26 191.77,121.41 190.32,121.41 190.14,121.23 190.14,120.17
3.3V on ART03: 37.85,67.64 46.51,58.98 68.38,58.98 70.41,61.01 70.41,67.89 70.08,68.22 70.05,68.22 67.78,70.5 62.99,70.5 61.68,71.81 38.43,71.81 37.85,71.22
3.3V on ART05: 183.36,118.49 188.44,118.49 189,119.05 191.19,119.05 191.75,118.49 193.14,118.49 193.9,119.25 193.9,120.29 192.73,121.46 189.1,121.46 187.64,122.93 187.64,129.07 186.66,130.05 179.8,130.05 175.87,126.11 175.23,126.11 174.85,126.49 174.85,129.67 174.34,130.17 171.17,130.17 168.76,127.76 168.76,121.54 171.93,118.36 183.23,118.36
3.3V on POWER11: 156.08,77.34 181.48,77.34 181.99,77.85 181.99,129.41 181.36,130.05 170.43,130.05 169.16,128.78 169.16,108.33 164.97,104.14 157.35,104.14 155.57,102.36 155.57,77.85
3.3V on POWER12: 181.96,129.92 181.96,3.05 3.05,3.05 3.05,154.58 4.14,155.68 23.14,155.68 33.91,144.91 33.91,144.91 34.16,144.65 56.87,144.65 56.87,127.63 27.66,127.63 27.53,127.51 27.53,114.93 56.87,114.93 56.87,104.8 81.53,80.14 81.53,80.14 84.84,76.83 153.67,76.83 155.55,78.71 155.55,102.38 157.3,104.14 164.92,104.14 169.14,108.35 169.14,128.8 170.38,130.05 181.84,130.05 ; 3 cut-outs
3.3V on ART16: 185.27,113.92 185.27,119.89 185.65,120.27 192.25,120.27 193.65,118.87 193.65,91.95 192.89,91.19 183.87,91.19 182.85,92.2 182.85,111.51
3.3V on ART16: 214.93,215.44 191.87,215.44 191.26,214.83 191.26,173 193.55,170.71 193.55,169.44 186.58,162.47 186.58,158.41 179.93,151.76 163.55,151.76 160.53,148.74 160.53,127.05 161.57,126.01 169.29,126.01 172.01,128.73 173.45,128.73 174.11,129.39 174.11,142.34 174.52,142.75 200.43,142.75 206.59,136.59 206.59,135.68 207.54,134.72 207.54,123.7 199.97,116.13 199.97,108.36 202.11,106.23 202.11,49.61 198.27,45.77 197.99,45.77 196.34,44.12 196.34,36.4 187.51,27.57 167.25,27.57 163.18,23.51 63.72,23.51 51.33,11.13 50.29,11.13 49.83,11.58 46.53,11.58 45.06,13.06 40.08,13.06 37.13,10.11 31.57,10.11 30.89,10.79 30.89,16.41 30.86,16.43 30.86,17.91 38.07,25.12 45.42,25.12 47.78,27.48 47.78,40.28 46.23,41.83 46.23,45.62 44.75,47.09 38.35,47.09 36.73,48.72 36.73,57.02 39.7,59.99 39.7,87 33.48,93.22 33.48,144.25 31.5,146.23 31.5,150.32 27.97,153.85 6.2,153.85 2.79,150.44 2.79,7.37 8.18,1.98 208.94,1.98 216.79,9.83 216.79,213.59
3.3V on ART18: outline of 107 points within 6.53,4.11 215.87,216.66 ; 4 cut-outs
3.3V_PRE on TOP: 53.68,163.19 53.68,159.63 53.95,159.36 54.96,159.36 55.22,159.61 55.22,163.19
3.3V_PRE on TOP: 57.53,172.03 57.53,167.49 58.62,166.4 66.83,166.4 67.18,166.75 67.18,175.13 66.88,175.44 64.47,175.44 61.8,172.77 58.27,172.77
3.3V_PRE on BOTTOM: 37.97,177.04 36.2,177.04 35.31,176.15 35.31,175.51 35.43,175.39 37.72,175.39 38.61,176.28 39.5,176.28 39.88,175.9 39.88,175.51 40.01,175.39 42.16,175.39 42.42,175.64 42.42,176.15 42.29,176.28 40.89,176.28 40.77,176.4 40.77,176.91 40.75,176.92 42.52,178.69 44.04,178.69 44.93,179.58 44.96,179.58 46.23,180.85 46.23,181.23 44.58,181.23 44.2,181.61 39.62,181.61 39.61,181.62 39.27,181.28 33.91,181.28 33.73,181.1 33.73,180.67 33.88,180.52 37.77,180.52 38.18,180.11 38.18,177.24
3.3V_PRE on BOTTOM: 38.35,169.04 39.75,169.04 40.01,169.29 40.01,169.67 40.13,169.8 40.51,169.8 40.77,169.54 40.77,169.16 40.89,169.04 41.27,169.04 41.53,168.78 41.53,168.4 41.4,168.28 39.5,168.28 39.24,168.02 39.24,165.23 39.5,164.97 40.99,164.97 41.12,164.85 41.12,164.46 37.07,164.46 37.07,165.09 37.21,165.23 37.21,165.66 37.41,165.86 38.13,165.86 38.35,166.09 38.35,166.8 38.35,166.8 38.35,168.17 38.15,168.38 36.34,168.38 36.12,168.6 36.12,168.96 36.32,169.16 38.23,169.16
3.3V_PRE on BOTTOM: 30.96,160.65 32.99,160.65 33.25,160.4 33.25,157.61 33.12,157.48 30.83,157.48 30.71,157.61 30.71,160.4
3.3V_PRE on BOTTOM: 33.78,173.23 33.77,173.21 33.61,173.21 33.5,173.1 30.71,173.1 30.33,172.72 30.33,172.08 30.45,171.96 31.88,171.96 33.66,171.96 33.91,172.21 34.42,172.21 34.42,170.18 34.67,169.93 35.69,169.93 35.86,170.1 35.86,172.87 35.51,173.23
3.3V_PRE on ART03: 46.51,56.74 46.51,52.37 50.5,48.39 55.27,48.39 56.64,47.02 61.8,47.02 61.9,47.12 62.71,47.12 63.6,46.23 73.84,46.23 74.12,46.51 74.12,47.07 73.08,48.11 71.48,48.11 70.55,49.03 70.55,52.91 67.45,56.01 58.45,56.01 58.34,55.91 58.34,54.28 58.72,53.9 66.09,53.9 69.06,50.93 69.06,48.23 68.55,47.73 64.82,47.73 64.24,48.31 57.61,48.31 55.73,50.19 52.68,50.19 52.3,50.57 51.44,50.57 48.74,53.26 48.74,54.15 48.79,54.2 48.79,56.26 48.06,57 46.76,57
3.3V_PRE on ART05: 77.08,189.88 72.69,185.5 49.04,185.5 48.48,186.06 48.48,188.89 48.77,189.18 51.61,189.18 53.72,187.07 71.75,187.07 75.06,190.37 75.06,196.22 74.5,196.77 67.94,196.77 66.75,197.97 66.75,204.19 67.21,204.65 67.21,208.23 67.6,208.62 67.6,212.61 72.03,217.04 83.54,217.04 84.28,216.31 84.28,213.13 84.26,213.12 84.26,211.53 84.03,211.3 82.89,211.3 82.87,211.32 82.36,211.32 82.14,211.53 82.14,211.96 82.18,212 82.18,213.37 81.48,214.07 75.08,214.07 74.04,213.03 74.04,205.66 73.66,205.28 72.77,205.28 72.57,205.08 72.57,204.17 77.08,199.66
3.3V_PRE on ART05: 166.6,198.48 172.9,198.48 173.74,197.64 173.74,196.7 174.7,195.73 180.26,195.73 181.36,194.64 182.32,194.64 182.6,194.92 182.6,195.66 181.28,196.98 175.69,196.98 175.39,197.28 175.39,199.24 174.83,199.8 166.52,199.8 166.22,199.49 166.22,198.86
3.3V_PRE on ART05: 145.62,163.14 148.13,160.63 182.17,160.63 184.91,163.37 184.91,177.19 182.54,179.57 172.91,179.57 172.39,179.04 172.39,177.01 173.08,176.33 180.95,176.33 182.02,175.26 182.02,165.02 181.28,164.29 174.42,164.29 173.05,162.92 148.06,162.92 146.86,164.11 145.9,164.11 145.62,163.83
3.3V_PRE on ART07: 181.31,178.26 180.01,178.26 179.63,178.64 179.63,180.62 181.05,182.04 181.05,193.47 180.77,193.75 180.77,195 181.28,195.5 182.85,195.5 184.07,194.28 184.07,191.92 184.73,191.26 195.91,191.26 197.46,189.71 197.46,186.59 200.38,183.67 202.9,183.67 203.23,183.34 203.23,182.6 202.64,182.02 199.87,182.02 198.83,183.06 197.43,183.06 194.44,186.06 194.44,187.81 193.42,188.82 184.73,188.82 183.57,187.66 183.57,180.52
3.3V_PRE on ART07: 46.93,19.32 48.01,18.24 48.97,18.24 49.26,18.53 49.25,18.54 49.25,20.4 47.96,21.69 39.4,21.69 39.07,21.36 39.07,20.32 40.07,19.32
3.3V_PRE on POWER14: 3.68,189.48 55.88,189.48 56.74,188.62 56.74,183.03 57.5,182.27 68.55,182.27 69.19,181.64 69.19,178.94 68.63,178.38 65.25,178.38 64.05,177.18 61.47,177.18 60.39,178.26 56.72,178.26 54.61,176.15 42.14,176.15 42.14,173.35 44.93,170.56 60.71,170.56 61.34,169.93 61.34,161.29 59.44,159.38 43.94,159.38 43.03,158.47 43.03,124.4 42.95,124.41 42.88,124.41 41.78,123.32 42.88,122.22 42.95,122.23 43.03,122.23 43.03,120.44 42.95,120.45 42.88,120.45 41.75,119.33 42.88,118.21 42.95,118.21 43.03,118.22 43.03,63.5 33.07,53.54 33.07,16.46 33.04,16.43 42.7,16.43 45.7,19.43 50.27,19.43 51.59,18.11 58.47,18.11 67.46,27.1 207.87,27.1 209.85,29.08 215.26,29.08 215.26,3.05 15.75,3.05 3.05,15.75 3.05,188.85 ; 6 cut-outs
3.3V_PRE on ART16: 135.18,212.29 137.87,212.29 138.25,212.67 155.47,212.67 156.34,211.81 156.34,209.98 155.7,209.35 149.05,209.35 148.49,208.79 148.49,205.99 151.46,203.02 162.97,203.02 164.08,201.9 164.08,199.19 165.1,198.17 166.9,198.17 167.46,198.73 167.46,203.96 165.63,205.79 160.45,205.79 159.44,206.81 159.44,213.03 158.32,214.15 135.31,214.15 134.8,213.64 134.8,212.67
3.3V_PRE on ART16: 57.58,164.77 57.58,164.01 65.35,156.24 97.03,156.24 97.76,155.5 105.26,155.5 106.35,156.59 129.51,156.59 134.47,161.54 134.47,164.47 134.72,164.72 135.53,164.72 139.45,160.81 148.84,160.81 150.16,159.49 150.16,158.42 148.34,156.59 148.34,149.02 145.41,146.1 145.41,139.42 145.75,139.09 147.37,139.09 147.73,139.45 147.73,143.92 152.12,148.31 152.12,161.72 149.81,164.03 139.67,164.03 137.72,165.99 133.63,165.99 132.56,164.92 132.56,162.61 128.65,158.7 106.83,158.7 105.84,157.71 81.03,157.71 80.75,157.99 67.51,157.99 59.54,165.96 58.78,165.96
3.3V_PRE on ART16: 57.23,167.26 65.89,167.26 67.46,168.83 67.46,174.65 66.22,175.9 63.83,175.9 63.22,175.29 63.22,171.63 62,170.41 57.3,170.41 56.9,170 56.9,167.59
3.3V_PRE on ART18: 164.08,126.72 161.57,126.72 160.35,127.94 160.35,129.16 158.19,131.32 157.35,131.32 149.53,139.14 146.15,139.14 145.97,139.32 145.97,140.18 146.51,140.72 150.72,140.72 156.74,134.7 157.99,134.7 162.48,130.2 162.48,129.26 163.3,128.45 164.08,128.45 164.36,128.17 164.36,127
3.3V_PRE on ART20: 173.51,14.27 173.96,14.27 174.68,14.99 174.68,40.84 173.25,42.27 163.5,42.27 161.49,44.27 161.49,58.39 163.6,60.5 163.6,73.76 164.08,74.24 164.08,75.77 159.59,80.26 159.59,83.79 160.17,84.38 160.17,90.4 160.45,90.68 160.45,91.21 160.25,91.41 158.42,91.41 158.19,91.19 158.19,85.45 158.24,85.39 158.24,84.84 157.43,84.02 157.43,79.22 161.87,74.78 161.87,60.99 160.2,59.31 160.2,44.07 163.19,41.07 171.37,41.07 173.18,39.27 173.18,14.61
3.3V_PRE_AGND on ART03: 69.8,175.59 73.88,179.67 73.88,180.96 73.81,181.03 71.96,181.03 71.7,181.28 59.77,181.28 59.41,180.92 59.41,176.96 59.69,176.68 64.34,176.68 65.43,175.59
5V on TOP: 182.99,205.66 181.64,204.33 181.64,202.16 182.63,201.17 183.77,201.17 184.51,201.9 188.62,201.9 189.45,202.74 189.45,209.38 189.15,209.68 183.29,209.68 182.99,209.38
5V on TOP: 60.35,47.68 60.35,46.58 60.13,46.37 60.13,41.69 59.98,41.54 58.23,41.54 58.04,41.73 58.04,45.92 56.9,47.07 56.9,47.83 57.1,48.03 59.99,48.03
5V on TOP: 46.1,14.96 46.1,11.07 46.33,10.85 46.33,9.55 46.69,9.19 49.15,9.19 49.61,9.65 49.61,14.38 48.74,15.24 46.38,15.24
5V on TOP: 59.54,141.99 61.59,141.99 61.8,142.19 61.8,146.13 61.57,146.35 59.94,146.35 59.46,145.87 59.46,144.75 58.67,143.97 56.59,143.97 56.13,143.51 56.13,142.6 56.44,142.29 59.23,142.29
5V on BOTTOM: 182.99,205.66 181.64,204.33 181.64,202.16 182.83,200.96 183.34,200.96 184.56,202.18 186.94,202.18 187.76,203 187.76,203.89 188.85,204.98 188.87,204.98 189.46,205.56 189.46,208.56 188.86,209.16 183.16,209.16 182.99,208.98
5V on BOTTOM: 46.35,15.01 46.35,10.06 46.84,9.58 49.61,9.58 49.91,9.88 49.91,14.68 49.28,15.32 46.66,15.32
5V on ART03: 166.37,144.91 170.05,144.91 171.07,143.89 171.07,136.53 166.37,131.83 162.18,131.83 161.8,132.21 161.8,133.73 162.69,134.62 166.37,134.62 167.26,135.51 167.26,137.79 165.99,139.06 165.99,144.53
5V on ART05: 195.33,208.28 196.82,206.78 196.82,196.32 195.96,195.45 195.96,184.05 201.22,178.79 201.22,162.99 202.16,162.05 203.43,162.05 204.39,161.09 204.39,149.81 203.5,148.92 203.5,140.56 202.54,139.6 196.09,139.6 195.33,138.84 195.33,135.13 194.74,134.54 193.12,134.54 191.26,136.4 191.26,139.45 189.48,141.22 167.39,141.22 166.62,141.99 166.62,144.65 167.26,145.29 170.46,145.29 173.18,148.01 173.18,150.04 174.02,150.88 186.18,150.88 187.45,152.15 192.84,152.15 193.5,152.81 195.05,152.81 195.86,153.62 195.86,158.57 193.14,161.29 189.84,161.29 188.34,162.79 188.34,197.84 186.54,199.64 183.46,199.64 182.8,200.3 182.8,201.65 182.35,202.11 181.97,202.11 181.56,202.51 181.56,204.6 182.42,205.46 182.42,207.21 183.49,208.28
5V on ART07: 46,15.04 46,9.86 46.35,9.5 49.91,9.5 50.24,9.83 50.24,14.78 49.56,15.47 46.43,15.47
5V on GND13: 190.32,207.9 190.32,198.22 185.62,193.52 143.99,193.52 142.81,192.34 77.03,192.34 71.81,187.12 67.77,187.12 60.17,179.53 60.17,149 62.36,146.81 62.36,142.16 58.67,138.48 35.59,138.48 23.65,126.54 23.65,119.66 18.83,114.85 11.01,114.85 10.01,115.85 10.01,129.59 28.5,148.08 49.73,148.08 52.22,150.57 52.22,187.63 66.75,202.16 98.3,202.16 98.37,202.08 133.78,202.08 135.08,203.38 180.59,203.38 182.58,205.36 182.58,206.98 184.28,208.69 189.53,208.69
5V on ART16: 51.59,12.6 51.59,18.21 51.56,18.24 51.56,18.47 60.1,27 60.1,45.72 59.79,46.02 56.97,46.02 55.19,44.25 55.19,28.19 45.54,18.54 45.54,12.19 45.82,11.91 50.16,11.91 50.18,11.9 50.89,11.9
5V on ART20: 45.87,22.76 44.2,24.43 9.45,24.43 1.02,32.87 1.02,113.39 7.01,119.38 20.9,119.38 22.42,120.89 23.58,120.89 23.9,120.57 23.9,107.87 15.25,99.23 15.25,42.38 18.72,38.91 18.72,34.26 20.4,32.59 47.7,32.59 54.86,25.43 54.86,11.89 52.78,9.8 46.53,9.8 45.87,10.46
5V on ART20: 191.39,155.19 193.17,153.42 193.17,134.37 194.18,133.35 204.6,133.35 205.23,133.99 205.23,135 203.71,136.53 200.58,136.53 199.8,137.31 199.8,156.74 196.09,160.45 196.09,166.98 195.08,167.98 191.86,167.98 191.39,167.51
5V_AGND on ART07: 183.72,195.15 186.92,195.15 187.25,195.48 187.25,198.48 184.84,200.89 179.2,200.89 178.82,200.51 178.82,197.36 179.58,196.6 182.27,196.6
12V on TOP (solid shape): 85.87,196.46 83.02,196.46 83.02,196.83 82.61,196.83 82.61,197.09 83.02,197.09 83.02,197.34 82.61,197.34 82.61,197.59 83.02,197.59 83.02,197.6 85.87,197.6
12V on TOP (solid shape): 90.71,197.59 91.12,197.59 91.12,197.34 90.71,197.34 90.71,197.09 91.12,197.09 91.12,196.83 90.71,196.83 90.71,196.46 87.87,196.46 87.87,197.6 90.71,197.6
12V on TOP (solid shape): 99.96,195.95 97.12,195.95 97.12,196.33 96.71,196.33 96.71,196.58 97.12,196.58 97.12,196.83 96.71,196.83 96.71,197.08 97.12,197.08 97.12,197.09 99.96,197.09
12V on TOP (solid shape): 104.81,197.08 105.22,197.08 105.22,196.83 104.81,196.83 104.81,196.58 105.22,196.58 105.22,196.33 104.81,196.33 104.81,195.95 101.97,195.95 101.97,197.09 104.81,197.09
12V on TOP (solid shape): 113.76,195.85 110.91,195.85 110.91,196.23 110.5,196.23 110.5,196.48 110.91,196.48 110.91,196.73 110.5,196.73 110.5,196.98 110.91,196.98 110.91,196.99 113.76,196.99
12V on TOP (solid shape): 118.6,196.98 119.01,196.98 119.01,196.73 118.6,196.73 118.6,196.48 119.01,196.48 119.01,196.23 118.6,196.23 118.6,195.85 115.76,195.85 115.76,196.99 118.6,196.99
12V on TOP (solid shape): 126.86,195.36 124.02,195.36 124.02,195.74 123.61,195.74 123.61,196 124.02,196 124.02,196.24 123.61,196.24 123.61,196.5 124.02,196.5 124.02,196.51 126.86,196.51
12V on TOP (solid shape): 131.71,196.5 132.12,196.5 132.12,196.24 131.71,196.24 131.71,196 132.12,196 132.12,195.74 131.71,195.74 131.71,195.36 128.86,195.36 128.86,196.51 131.71,196.51
12V on TOP (solid shape): outline of 109 points within 194.26,140.23 199.85,146
12V on ART03 (solid shape): 134.62,198.02 134.62,195.25 134.44,195.07 132.23,195.07 131.9,195.4 124.61,195.4 124.31,195.71 124.31,196.95 124.76,197.41 131.85,197.41 132.74,198.3 134.34,198.3
12V on ART03 (solid shape): 94.97,198.83 94.97,196.42 94.67,196.11 91.08,196.11 90.75,196.44 83.46,196.44 83.29,196.62 83.29,197.54 83.62,197.87 89.99,197.87 90.42,198.3 90.42,199.16 90.65,199.39 94.41,199.39
12V on ART03 (solid shape): 121.92,198.96 121.92,195.88 121.7,195.67 119.72,195.67 119.56,195.83 111.4,195.83 111.25,195.99 111.25,197.33 111.79,197.87 118.21,197.87 118.72,198.37 118.72,199.01 119.18,199.47 121.41,199.47
12V on ART03 (solid shape): 107.92,198.82 107.92,196.04 107.64,195.75 105.51,195.75 105.31,195.95 97.6,195.95 97.26,196.29 97.26,197.2 97.79,197.73 104.22,197.73 104.72,198.24 104.72,198.88 105.39,199.54 107.21,199.54
12V on ART07 (solid shape): 118.87,197.1 118.87,196.11 118.57,195.81 111.4,195.81 111.3,195.91 111.3,196.95 111.96,197.61 118.36,197.61
12V on ART07 (solid shape): 104.9,197.64 104.9,196.22 104.52,195.83 97.64,195.83 97.43,196.04 97.43,197.54 97.76,197.87 104.67,197.87
12V on ART07 (solid shape): 87.99,197.66 90.5,197.66 90.93,197.23 90.93,196.52 90.68,196.27 83.59,196.27 83.34,196.52 83.34,197.64 83.57,197.87 87.78,197.87
12V on ART07 (solid shape): 132.33,196.47 132.33,195.68 131.95,195.3 124.59,195.3 124.51,195.38 124.51,196.52 124.61,196.62 127.36,196.62 127.76,197.03 131.78,197.03
12V on TOP: 54.61,154.56 55.85,155.8 55.85,155.83 56.97,156.95 56.97,158.09 56.94,158.11 55.85,158.11 55.55,157.81 53.67,157.81 53.47,157.61 53.47,154.56
12V on TOP: 200.58,157.89 200.58,152.81 200.53,152.76 196.7,152.76 196.16,153.29 196.16,180.87 196.82,181.53 199.47,181.53 200.41,180.59 200.41,179.45 200.58,179.27 200.58,174.37 201.14,173.81 201.14,158.45
12V on TOP: 39.24,151 38.35,151 37.87,150.52 37.87,149.73 36.17,148.03 36.17,146.94 36.29,146.81 38.35,146.81 39.24,147.7
12V on TOP: 174.42,188.62 174.8,189 174.8,191.64 173.94,192.51 168.58,192.51 168.12,192.05 168.12,188.9 168.4,188.62
12V on TOP: 68.91,207.95 68.94,207.92 69.29,207.92 70.41,206.81 70.41,203.99 68.43,202.01 66.83,202.01 65.37,200.55 65.37,196.38 65.38,196.37 65.38,195.35 64.97,194.94 55.42,194.94 54.58,195.78 54.58,212.34 54.97,212.72 59.74,212.72 59.94,212.52 59.94,208.79 60.78,207.95
12V on TOP: 198.6,11.3 194.79,11.3 194.28,10.79 194.28,3.17 194.92,2.54 202.92,2.54 203.17,2.79 203.17,6.98 201.9,8.25 201.27,8.25 198.6,10.92
12V on TOP: 133.96,210.06 134.26,209.75 134.26,202.92 135.56,201.63 135.56,196.06 135.23,195.73 132.92,195.73 132.68,195.5 128.65,195.5 128.47,195.33 123.93,195.33 123.24,196.01 122.05,196.01 121.78,195.75 119.55,195.75 119.3,195.99 115.62,195.99 115.47,195.83 110.74,195.83 110.64,195.73 105.82,195.73 105.56,195.99 100.46,195.99 100.43,195.96 96.42,195.96 96.16,196.22 96.19,196.22 96.06,196.34 95.3,196.34 95.17,196.22 95.15,196.22 94.95,196.01 91.72,196.01 91.24,196.49 82.68,196.49 82.32,196.85 81.38,196.85 81.37,196.86 79.24,196.86 78.99,197.1 78.99,199.26 78.28,199.97 78.28,205.26 83.08,210.06 ; 2 cut-outs
12V on BOTTOM: 186.17,139.89 186.51,139.55 186.51,130.05 186,129.54 183.49,129.54 183.26,129.77 183.26,130.96 183.82,131.52 183.82,139.5 184.21,139.89
12V on BOTTOM: 16.53,113.87 19.4,113.87 19.76,114.22 20.67,114.22 20.85,114.4 20.85,117.22 18.74,119.33 18.74,120.4 18.46,120.67 17.22,120.67 16.38,119.84 16.38,114.02
12V on BOTTOM: 66.32,206.5 61.98,206.5 60.4,208.08 60.4,209.6 60.05,209.96 55.58,209.96 54.71,209.09 54.71,195.94 56.16,194.49 65.13,194.49 70.46,199.82 70.46,205.94 69.68,206.72 66.54,206.72
12V on BOTTOM: 90.3,210.06 132.94,210.06 135.38,207.62 135.38,202.95 135.66,202.67 135.66,195.55 135.43,195.33 124.61,195.33 123.9,196.04 122.71,196.04 122.35,195.68 118.59,195.68 118.47,195.81 111.51,195.81 111.44,195.75 105.37,195.75 105.21,195.91 91.21,195.91 90.73,196.39 83.62,196.39 83.19,196.82 79.15,196.82 78.92,197.05 78.92,198.25 79.2,198.53 85.98,198.53 86.56,199.11 86.56,200.38 89.41,203.23 89.41,209.17
12V on BOTTOM: 194.28,8.86 194.28,3.17 194.92,2.54 202.92,2.54 203.17,2.79 203.17,6.98 201.9,8.25 201.27,8.25 201.25,8.27 200.7,8.27 199.26,9.7 195.12,9.7
12V on BOTTOM: 168.07,192.15 168.07,188.98 168.48,188.57 175.18,188.57 175.59,188.98 175.59,191.57 174.6,192.56 168.48,192.56
12V on BOTTOM: 198.75,173.23 198.75,167 198.2,166.45 198.2,159.21 197.69,158.7 197.69,153.03 198.04,152.68 200.38,152.68 200.58,152.88 200.58,157.89 201.07,158.37 203.61,158.37 204.06,158.83 204.06,164.95 203.81,165.2 203.81,167.84 202.54,169.11 202.54,170.89 201.45,171.98 201.45,173.15 200.58,174.02 200.58,181.13 200.1,181.61 197.23,181.61 196.75,181.13 196.75,175.23
12V on GND02, GND04, ART05, GND06, GND08, GND10, GND13, GND15, ART16, GND17, ART18, GND19, GND21: 104.9,196.57 104.9,197.61 104.65,197.87 97.71,197.87 97.41,197.56 97.41,196.22 97.71,195.91 99.8,195.91 99.87,195.99 104.32,195.99
12V on GND02, GND04, ART05, GND06, GND08, GND10, GND13, GND15, ART16, GND17, ART18, GND19, GND21: 131.76,196 131.76,197.04 131.51,197.29 124.57,197.29 124.27,196.99 124.27,195.64 124.57,195.34 126.66,195.34 126.73,195.41 131.18,195.41
12V on GND02, GND04, ART05, GND06, GND08, GND10, GND13, GND15, ART16, GND17, GND19, GND21: 118.45,196.39 118.45,197.43 118.2,197.69 111.26,197.69 110.96,197.38 110.96,196.04 111.19,195.81 117.87,195.81
12V on GND02, GND04, ART05, GND06, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 91.44,208.03 91.44,203.96 91.69,203.71 93.98,203.71 94.23,203.96 94.23,208.03 93.98,208.28 91.69,208.28
12V on GND02, GND04, ART05, GND06, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 119.13,208.03 119.13,203.96 119.38,203.71 121.67,203.71 121.92,203.96 121.92,208.03 121.67,208.28 119.38,208.28
12V on GND02, GND04, GND06, GND08, GND10, GND13, GND15, ART16, GND17, GND19, GND21: 91.19,196.82 91.19,197.61 90.93,197.87 83.72,197.87 83.46,197.61 83.46,196.55 83.57,196.44 85.95,196.44 86,196.49 90.86,196.49
12V on GND02, GND04, GND06, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 134.29,204.01 134.29,208.28 134.11,208.46 130.45,208.46 130.25,208.25 130.25,204.09 130.58,203.76 134.04,203.76
12V on GND02, GND04, GND06, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 105.16,208.03 105.16,203.63 105.36,203.43 108.66,203.43 109.02,203.78 109.02,208.05 108.79,208.28 105.41,208.28
12V on ART03: 54.58,194.94 54.58,212.72 133.73,212.72 134.37,212.09 134.37,200.91 133.6,200.15 80.26,200.15 77.72,197.61 67.18,197.61 64.52,194.94
12V on ART05: 135.38,208.03 135.13,208.28 131.85,208.28 131.52,207.95 131.52,203.56 131.8,203.28 134.98,203.28 135.38,203.68
12V on ART05: 105.16,208.03 105.16,203.63 105.36,203.43 107.9,203.43 108.13,203.66 108.13,208 107.85,208.28 105.41,208.28
12V on ART05: 91.19,196.82 91.19,197.43 90.93,197.69 83.54,197.69 83.46,197.61 83.46,196.55 83.57,196.44 85.95,196.44 86,196.49 90.86,196.49
12V on ART05, ART07, ART16, ART18, ART20: 54.58,194.94 54.58,212.72 65.38,212.72 65.38,194.94
12V on POWER11: 56.87,145.16 34.29,145.16 29.08,150.37 3.05,150.37 3.05,215.26 34.39,215.26 34.39,198.75 37.56,195.58 64.23,195.58 72.62,203.96 201.78,203.96 203.43,202.31 203.43,181.36 205.59,179.2 215.26,179.2 215.26,100.96 198.09,100.96 198.09,12.7 215.26,12.7 215.26,3.05 182.47,3.05 182.47,130.2 183.85,131.57 191.87,131.57 193.52,133.22 193.52,171.05 191.59,172.97 59.43,172.97 56.87,170.41
12V on POWER12: 56.87,145.16 34.29,145.16 29.08,150.37 23.22,156.24 3.63,156.24 3.05,156.82 3.05,215.26 215.26,215.26 215.26,100.96 198.09,100.96 198.09,12.7 215.26,12.7 215.26,3.05 182.47,3.05 182.47,130.2 183.85,131.57 191.87,131.57 193.52,133.22 193.52,171.05 191.59,172.97 59.43,172.97 56.87,170.41
12V on ART16: 184.12,129.29 203.55,129.29 204.19,128.65 204.19,123.95 204.7,123.44 206.98,123.44 207.36,123.82 207.36,134.75 206.98,135.13 188.19,135.13 186.15,137.16 186.15,138.94 185.39,139.7 184.5,139.7 183.87,139.06 183.87,129.54
12V on ART18: 118.45,196.39 118.45,197.43 118.2,197.69 111.89,197.69 110.96,196.76 110.96,196.04 111.19,195.81 117.87,195.81
12V on ART18: 90.72,196.91 90.72,197.51 90.34,197.89 83.43,197.89 83.22,197.69 83.22,196.67 83.45,196.44 90.25,196.44
12V on ART20: 38.35,144.25 36.9,145.69 36.9,147.75 38.81,149.66 38.81,150.19 38.5,150.49 37.97,150.49 35.66,148.18 35.66,145.59 37.16,144.09 37.16,141.2 37.56,140.79 37.92,140.79 38.35,141.22
12V on ART20: 56.49,217.02 187.37,217.02 187.42,216.97 208.58,216.97 211.45,214.1 211.45,211.84 214.73,208.56 214.73,117.86 213.21,116.33 205.33,116.33 203.81,117.86 203.81,132.05 205.61,133.86 205.61,134.97 203.81,136.78 203.81,165.33 205.61,167.13 205.61,168.78 203.81,170.59 203.81,181.73 206.6,184.53 206.6,188.82 205.31,190.12 204.42,190.12 203.81,190.73 203.81,202.31 201.78,204.34 150.37,204.34 145.8,199.77 89.56,199.77 89.14,200.19 86.04,200.19 84.23,202.01 79.43,202.01 78.82,202.62 78.82,204.11 78.66,204.11 78.11,203.56 78.11,195.71 76.83,194.44 57.25,194.44 55.09,196.6 55.09,215.62 ; 4 cut-outs
12V_DCIN on TOP: 10.64,185.29 10.13,185.8 10.13,187.32 6.32,191.13 6.32,191.13 5.69,191.77 5.69,208.28 10.13,212.72 28.8,212.72 28.8,203.05 28.9,202.95 28.9,202.74 28.8,202.64 28.8,194.94 28.29,194.94 28.29,192.66 29.69,191.26 29.69,188.21 29.94,187.96 31.09,187.96 31.09,187.45 29.82,187.45 29.18,188.09 29.18,190.75 27.4,192.53 27.4,194.82 24.74,197.48 19.66,197.48 19.02,196.85 19.02,191.01 17.24,189.23 12.8,189.23 12.55,188.98 12.55,185.29
12V_DCIN on BOTTOM, ART03, ART05, ART07, ART16, ART18, ART20: 6.32,191.13 6.32,191.13 7.59,189.86 17.88,189.86 19.02,191.01 19.02,196.85 19.66,197.48 24.74,197.48 27.28,194.94 28.8,194.94 28.8,212.72 10.13,212.72 5.69,208.28 5.69,191.77
12V_IN on TOP (solid shape): 200.53,208.46 200.53,205.84 200.28,205.59 194.18,205.59 193.73,206.04 193.73,208.51 194.11,208.89 200.1,208.89
12V_IN on TOP (solid shape): 54.23,201.4 52.12,201.4 52.12,201.78 52.55,201.78 52.55,202.06 52.12,202.06 52.12,202.44 52.55,202.44 52.55,202.69 52.12,202.69 52.12,203.07 52.55,203.07 52.55,203.35 52.12,203.35 52.12,203.73 54.23,203.73
12V_IN on TOP: 173.71,201.88 176.02,201.88 176.86,201.04 178.36,201.04 178.61,201.29 178.61,205.46 177.98,206.1 177.98,208.76 177.72,209.02 173.99,209.02 173.53,208.56 173.53,202.06
12V_IN on TOP: 36.55,194.94 53.42,194.94 54.2,195.73 54.2,212.29 53.77,212.72 36.55,212.72
12V_IN on TOP: 74.49,176.91 74.49,178.31 74.87,178.69 77.47,178.69 77.85,178.31 77.85,173.91 77.39,173.46 72.26,173.46 71.83,173.02 71.83,172.34 71.78,172.34 71.45,172.01 70.31,172.01 70.03,172.29 70.03,175.03 70.82,175.82 73.39,175.82
12V_IN on BOTTOM: 173.71,201.88 176.02,201.88 176.86,201.04 178.36,201.04 178.61,201.29 178.61,205.08 178.18,205.51 178.18,208.66 177.83,209.02 174.09,209.02 173.53,208.46 173.53,202.06
12V_IN on BOTTOM: 54.2,196.09 54.2,212.72 36.55,212.72 36.55,196.06 54.18,196.06
12V_IN on ART03, ART05, ART07, ART16, ART18, ART20: 36.55,194.94 54.2,194.94 54.2,212.72 36.55,212.72
12V_IN on POWER09: 215.26,215.26 215.26,180.72 214.63,180.09 201.9,180.09 190.47,191.52 177.67,191.52 171.32,197.87 79.5,197.87 78.74,197.1 78.74,177.67 78.69,177.62 78.69,173.74 77.27,172.31 71.65,172.31 71.2,171.86 64.36,171.86 63.7,172.52 63.7,175.29 62.97,176.02 59.82,176.02 57.4,178.44 57.4,189.48 56.9,189.99 3.68,189.99 3.05,190.63 3.05,215.26
12V_IN on POWER11: 35.02,198.75 35.02,215.26 215.26,215.26 215.26,179.58 205.71,179.58 203.81,181.48 203.81,202.31 201.78,204.34 72.11,204.34 63.73,195.96 37.82,195.96
12V_IN on POWER14: 3.05,190.63 3.05,213.77 4.54,215.26 210.95,215.26 215.26,210.95 215.26,180.72 214.63,180.09 201.9,180.09 190.42,191.56 175.85,191.56 173.1,194.31 136.4,194.31 133.6,191.52 58.93,191.52 57.4,189.99 27.94,189.99 27.93,190.01 3.67,190.01
12V_PCIE on TOP (solid shape): 199.79,12.05 196.39,12.05 196.39,14.15 199.79,14.15
12V_PCIE on TOP: 201.01,18.03 212.19,18.03 212.32,17.91 212.32,9.4 211.81,8.89 210.16,8.89 208.51,7.24 206.73,7.24 206.73,7.62 206.47,7.87 204.57,7.87 204.44,7.75 204.44,7.11 203.43,7.11 201.9,8.64 201.52,8.64 200,10.16 200,11.3 199.24,12.06 194.03,12.06 193.65,12.45 193.65,19.68 194.66,20.7 198.98,20.7 200.63,19.05 200.63,18.41
12V_PCIE on BOTTOM: 201.01,18.03 212.19,18.03 212.32,17.91 212.32,9.4 211.81,8.89 201.27,8.89 200,10.16 200,11.3 199.24,12.06 194.03,12.06 193.65,12.45 193.65,19.68 194.66,20.7 198.98,20.7 200.63,19.05 200.63,18.41
AGND_1.2V on BOTTOM: 40.59,20.68 40.59,17.96 40.08,17.45 40.08,16.74 40.21,16.61 44.07,16.61 44.83,15.85 45.64,15.85 46.48,16.69 46.48,18.16 47.22,18.9 48.92,18.9 49.3,18.52 49.3,17.93 49.48,17.75 50.39,17.75 50.6,17.96 50.6,20.9 50.29,21.21 41.12,21.21
AGND_1.8V on BOTTOM: 158.8,17.98 158.37,17.55 158.37,14.15 157.84,13.61 156.84,13.61 156.64,13.41 156.64,12.98 156.44,12.78 156.29,12.78 155.93,12.42 155.93,12.06 155.73,11.86 154.61,11.86 154.43,12.04 154.43,14.05 154.58,14.2 156.01,14.2 156.62,14.81 156.62,17.83 156.18,18.26 156.18,19.02 156.31,19.15 158.67,19.15 158.95,19.43 161.59,19.43 161.87,19.71 161.87,22.91 161.8,22.99 160.96,22.99 160.88,23.06 160.88,23.7 161.04,23.85 162.56,23.85 162.64,23.77 162.64,21.92 162.81,21.74 163.4,21.74 163.47,21.67 163.47,20.02 163.37,19.91 162.89,19.91 162.64,19.66 162.64,17.93 162.41,17.7 161.11,17.7 160.83,17.98
AGND_2.5V on BOTTOM: 93.47,19.43 93.75,19.71 93.75,22.91 93.68,22.99 92.84,22.99 92.76,23.06 92.76,23.7 92.91,23.85 94.44,23.85 94.59,23.7 94.59,20.75 94.77,20.57 95.15,20.57 95.43,20.29 95.43,17.55 95.17,17.3 94.39,17.3 94.28,17.4 94.28,17.81 94.11,17.98 90.5,17.98 90.25,17.73 90.25,13.94 89.92,13.61 88.49,13.61 88.14,13.26 88.14,12.98 87.99,12.83 87.81,12.83 87.55,12.57 87.55,11.94 87.45,11.84 86.64,11.84 86.54,11.94 86.54,13.94 87,14.4 88.29,14.4 88.57,14.68 88.57,17.68 88.34,17.91 88.34,19.25 88.52,19.43
AGND_3.3V on TOP (solid shape): outline of 366 points within 203.45,188.33 209.42,192.89
AGND_3.3V on ART05 (solid shape): outline of 867 points within 203.56,181.86 211,193.47
AGND_VCCCLK_GXE_FPGA_2.5V on BOTTOM (solid shape): 55.73,142.8 55.73,141.37 55.7,141.35 55.64,141.32 55.6,141.27 55.4,141.27 55.29,141.23 55.24,141.12 55.24,140.82 55.25,140.78 55.24,140.7 55.17,140.66 54.99,140.54 54.91,140.34 55.24,140 55.58,140.34 55.55,140.47 55.47,140.58 55.46,140.63 55.5,140.67 55.6,140.67 55.68,140.6 55.78,140.56 55.82,140.55 55.83,140.51 55.83,135.08 55.32,134.57 54.46,134.57 54.2,134.82 54.2,135.31 54.69,135.79 54.69,140.97 53.54,142.11 53.04,142.11 52.93,142.21 52.93,143.76 53.09,143.92 54.61,143.92
AGND_VCCFUSEWR_SDM_FPGA_2.4V on BOTTOM: 60.1,48.54 60.1,48.9 59.33,49.66 55.88,49.66 55.54,50 55.54,51.14 55.83,51.44 56.41,51.44 56.98,52.01 57.7,52.01 57.73,51.97 58.17,51.97 58.6,52.4 58.6,53.72 58.41,53.91 57.24,53.91 56.06,52.73 55.32,52.73 55.22,52.83 55.22,53.37 55.23,53.38 55.23,54.39 55.32,54.48 56.59,54.48 56.95,54.84 59.08,54.84 59.33,54.58 59.33,54.03 61.34,52.02 61.34,50.93 62.13,50.14 62.13,48.56 61.77,48.21 60.43,48.21
AGND_VCCH_FPGA_0.9V on BOTTOM: 175.46,176.3 175.46,170.74 175.84,170.36 178.79,170.36 179.17,170.74 179.17,176.02 178.77,176.43 175.59,176.43
AGND_VCCH_FPGA_0.9V on ART03: 155.17,179.04 155.17,177.06 155.35,176.89 157.25,176.89 157.43,177.06 157.43,178.92 157.07,179.27 155.4,179.27
AGND_VCCH_FPGA_0.9V on ART16: 156.21,172.29 156.21,171.96 157.12,171.04 170.03,171.04 172.47,168.61 172.47,165.02 173.35,164.13 180.52,164.13 180.92,164.54 180.92,175.54 180.21,176.25 170.89,176.25 170.1,175.46 165.13,175.46 163.7,176.89 161.21,176.89 158.47,179.63 155.3,179.63 154.74,179.07 154.74,173.76
AGND_VCCH_GXE_FPGA_1.1V on BOTTOM: 13.56,40.36 14.55,39.37 14.55,37.85 14.76,37.64 16.08,37.64 16.43,37.29 16.43,36.58 16.21,36.35 14.5,36.35 13.72,37.13 13.69,37.13 12.29,38.53 11.2,38.53 10.95,38.79 9.4,38.79 8.89,39.29 8.89,43.51 8.7,43.7 5.52,43.7 5.33,43.51 5.33,42.93 5.28,42.88 4.62,42.88 4.47,43.03 4.47,44.09 4.75,44.37 8.92,44.37 9.12,44.58 9.12,45.06 9.14,45.09 9.88,45.09 10.11,44.86 13.74,44.86 13.84,44.75 13.84,44.04 13.61,43.81 10.62,43.81 10.26,43.46 10.26,40.74 10.64,40.36
AGND_VCCIO_FPGA_1.2V on BOTTOM: 197.87,171.53 198.07,171.73 198.07,173.08 197.84,173.3 195.15,173.3 194.89,173.56 194.89,179.58 194.79,179.68 193.93,179.68 193.8,179.55 193.8,173.91 193.88,173.84 193.88,171.75 194.11,171.53
AGND_VCCIO_FPGA_1.2V on BOTTOM: 206.02,166.73 206.02,165.25 205.79,165.02 204.22,165.02 204.11,165.13 204.11,166.9 204.24,167.03 205.71,167.03
AGND_VCCIO_FPGA_1.2V on ART07: 215.7,169.88 215.7,166.93 214.81,166.04 206.76,166.04 206.4,166.4 206.4,166.93 205.79,167.54 205.08,167.54 202.34,170.28 202.34,172.29 201.83,172.8 194.97,172.8 194.69,172.52 194.69,169.72 195.58,168.83 198.37,168.83 202.21,165 203.78,165 204.39,164.39 217.12,164.39 217.5,164.77 217.5,169.75 217.2,170.05 215.87,170.05
AGND_VCCIO_FPGA_1.5V on BOTTOM: 44.86,39.88 45.26,39.47 48.56,39.47 49.31,38.72 49.31,37.38 49.83,36.86 51.1,36.86 51.38,36.58 51.38,35.51 51.18,35.31 49.05,35.31 48.54,35.81 48.54,37.36 48.31,37.59 45.42,37.59 45.01,37.19 44.4,37.19 44.04,37.54 44.04,38.13 43.56,38.61 43.56,42.32 43.03,42.85 40.34,42.85 40.01,42.52 40.01,41.99 39.93,41.91 38.81,41.91 38.63,42.09 38.63,42.85 38.37,43.12 36.69,43.12 36.58,43.23 36.58,43.87 36.63,43.92 38.96,43.92 39.14,43.74 44.5,43.74 44.86,43.38
AGND_VCCIO_FPGA_1.8V on BOTTOM: 23.39,124.99 23.39,123.49 23.6,123.29 25.07,123.29 25.37,123.6 25.37,125.15 25.3,125.22 24.51,125.22 24.31,125.02 23.42,125.02
AGND_VCCIO_FPGA_1.8V on ART20: 23.24,123.14 23.23,123.15 18.94,123.15 16.81,125.27 16.81,135.18 14.68,137.31 14.68,144.81 15.39,145.52 18.77,145.52 19.28,145.01 19.28,138.28 20.68,136.88 20.68,128.65 22.05,127.28 27.36,127.28 27.71,126.92 27.71,123.49 27.36,123.14
AGND_VCCL_HPS_FPGA_0.9V on BOTTOM: 27.71,37.59 28.09,37.21 31.57,37.21 32.05,36.73 32.05,34.57 32.33,34.29 33.63,34.29 33.86,34.06 33.86,33.38 33.73,33.25 31.55,33.25 31.32,33.48 31.32,35.18 31.01,35.48 27.97,35.48 27.69,35.2 26.95,35.2 26.67,35.48 26.67,35.92 26.29,36.3 26.29,40.46 26.01,40.74 22.81,40.74 22.73,40.67 22.73,39.83 22.66,39.75 22.25,39.75 22.12,39.88 22.12,41.63 22.43,41.94 24.94,41.94 25.43,42.42 27.43,42.42 27.69,42.16 27.69,41.4 27.71,41.38
AGND_VCCL_SDM_FPGA_0.8V on BOTTOM: 135.69,18.14 135.28,17.73 135.28,17.7 135,17.42 135,14.25 134.59,13.84 133.3,13.84 132.64,13.18 132.64,11.94 132.41,11.71 131.34,11.71 131.11,11.94 131.11,14.2 131.29,14.38 132.94,14.38 133.4,14.83 133.4,17.25 133.1,17.55 133.1,18.67 133.3,18.87 134.34,18.87 134.9,19.43 138.35,19.43 138.63,19.71 138.63,22.91 138.56,22.99 137.72,22.99 137.64,23.06 137.64,23.7 137.79,23.85 139.32,23.85 139.47,23.7 139.47,20.75 139.65,20.57 140.03,20.57 140.31,20.29 140.31,18.39 140.06,18.14
AGND_VCCPT_FPGA_1.8V on TOP (solid shape): outline of 340 points within 202.06,123.57 208.03,127.38
AGND_VCCPT_FPGA_1.8V on ART05 (solid shape): outline of 898 points within 202.16,114.38 209.6,127.97
AGND_VCCPT_FPGA_1.8V on BOTTOM: 204.95,127.13 204.57,127.51 202.49,127.51 202.25,127.27 202.25,125.63 202.5,125.37 204.6,125.37 204.95,125.73
AGND_VCCPT_FPGA_1.8V on BOTTOM: 204.27,117.14 208.43,117.14 208.74,116.84 208.74,115.06 208.43,114.76 204.34,114.76 204.09,115.01 204.09,116.97
GND on TOP (solid shape): 54.58,217.04 54.58,213.61 54.33,213.36 48.99,213.36 47.22,211.58 44.8,211.58 43.53,212.85 43.53,214.38 46.45,217.3 54.33,217.3
GND on TOP (solid shape): 26.26,194.41 26.26,191.9 27.79,190.37 27.79,185.29 20.42,185.29 19.78,185.93 19.78,190.35 20.47,191.03 20.47,193.7 22.58,195.81 24.86,195.81
GND on TOP (solid shape): 87.5,193.21 87.24,193.21 87.24,193.62 87,193.62 87,193.21 86.74,193.21 86.74,193.62 86.49,193.62 86.49,193.21 86.24,193.21 86.24,196 87.5,196
GND on TOP (solid shape): 101.59,192.7 101.34,192.7 101.34,193.11 101.09,193.11 101.09,192.7 100.84,192.7 100.84,193.11 100.59,193.11 100.59,192.7 100.34,192.7 100.34,195.5 101.59,195.5
GND on TOP (solid shape): 115.38,192.6 115.13,192.6 115.13,193.01 114.88,193.01 114.88,192.6 114.63,192.6 114.63,193.01 114.38,193.01 114.38,192.6 114.13,192.6 114.13,195.39 115.38,195.39
GND on TOP (solid shape): 128.49,192.11 128.24,192.11 128.24,192.52 127.99,192.52 127.99,192.11 127.74,192.11 127.74,192.52 127.49,192.52 127.49,192.11 127.24,192.11 127.24,194.91 128.49,194.91
GND on TOP (solid shape): 73.95,194.27 73.95,188.94 71.7,186.69 64.39,186.69 63.37,187.71 63.37,194.18 65.15,194.18 65.21,194.12 65.28,194.18 66.52,194.18 68.43,196.09 72.14,196.09
GND on TOP (solid shape): 85.99,194.81 83.02,194.81 83.02,194.83 82.61,194.83 82.61,195.09 83.02,195.09 83.02,195.33 82.61,195.33 82.61,195.59 83.02,195.59 83.02,195.83 82.61,195.83 82.61,196.09 83.02,196.09 83.02,196.21 85.99,196.21
GND on TOP (solid shape): 90.71,196.09 91.12,196.09 91.12,195.83 90.71,195.83 90.71,195.59 91.12,195.59 91.12,195.33 90.71,195.33 90.71,195.09 91.12,195.09 91.12,194.83 90.71,194.83 90.71,194.81 87.74,194.81 87.74,196.21 90.71,196.21
GND on TOP (solid shape): 100.09,194.3 97.12,194.3 97.12,194.33 96.71,194.33 96.71,194.58 97.12,194.58 97.12,194.83 96.71,194.83 96.71,195.08 97.12,195.08 97.12,195.33 96.71,195.33 96.71,195.58 97.12,195.58 97.12,195.7 100.09,195.7
GND on TOP (solid shape): 104.81,195.58 105.22,195.58 105.22,195.33 104.81,195.33 104.81,195.08 105.22,195.08 105.22,194.83 104.81,194.83 104.81,194.58 105.22,194.58 105.22,194.33 104.81,194.33 104.81,194.3 101.84,194.3 101.84,195.7 104.81,195.7
