# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
REFCLK_GXEP3: length 151.6
  ART16 w0.094: v2(95.74,107.6) 95.74,107.93 95.81,107.99 arc(95.96,107.93) 96.08,107.8 96.08,107.8 arc(96.3,107.58) 96.6,107.5 arc(96.8,107.45) 96.95,107.3 96.95,107.3 arc(97.47,107) 97.99,107.3 97.99,107.3 arc(98.34,107.5) 98.68,107.3 arc(98.9,107.08) 99.2,107 99.2,107 arc(99.4,106.95) 99.55,106.8 99.55,106.8 arc(99.77,106.58) 100.07,106.5 100.07,106.5 arc(100.27,106.45) 100.41,106.3 100.41,106.3 arc(100.63,106.08) 100.93,106 100.94,106 arc(101.13,105.95) 101.28,105.8 101.28,105.8 arc(101.5,105.58) 101.8,105.5 101.8,105.5 arc(102,105.45) 102.14,105.3 102.15,105.3 arc(102.36,105.08) 102.66,105 102.67,105 arc(102.86,104.95) 103.01,104.8 103.01,104.8 arc(103.23,104.58) 103.53,104.5 103.53,104.5 arc(103.73,104.45) 103.88,104.3 103.88,104.3 arc(104.1,104.08) 104.4,104 104.4,104 arc(104.74,103.8) 104.74,103.4 arc(104.66,103.1) 104.74,102.8 arc(104.8,102.6) 104.74,102.4 arc(104.66,102.1) 104.74,101.8 arc(104.8,101.6) 104.74,101.4 arc(104.66,101.1) 104.74,100.8 arc(104.8,100.6) 104.74,100.4 arc(104.66,100.1) 104.74,99.8 arc(104.8,99.6) 104.74,99.4 arc(104.66,99.1) 104.74,98.8 arc(104.8,98.6) 104.74,98.4 arc(104.66,98.1) 104.74,97.8 arc(104.8,97.6) 104.74,97.4 arc(104.66,97.1) 104.74,96.8 arc(104.8,96.6) 104.74,96.4 arc(104.66,96.1) 104.74,95.8 arc(104.8,95.6) 104.74,95.4 arc(104.74,94.8) 105.26,94.5 105.26,94.5 arc(105.46,94.45) 105.61,94.3 105.61,94.3 arc(105.83,94.08) 106.13,94 106.13,94 arc(106.33,93.95) 106.47,93.8 106.48,93.8 arc(106.69,93.58) 106.99,93.5 107,93.5 arc(107.34,93.3) 107.34,92.9 107.34,92.9 arc(107.34,92.3) 107.86,92 107.86,92 arc(108.06,91.95) 108.21,91.8 108.21,91.8 arc(108.43,91.58) 108.73,91.5 108.73,91.5 arc(108.93,91.45) 109.07,91.3 109.07,91.3 arc(109.29,91.08) 109.59,91 109.6,91 arc(109.79,90.95) 109.94,90.8 109.94,90.8 arc(110.16,90.58) 110.46,90.5 110.46,90.5 arc(110.81,90.3) 110.81,89.9 arc(110.73,89.6) 110.81,89.3 arc(110.86,89.1) 110.81,88.9 arc(110.73,88.6) 110.81,88.3 arc(110.86,88.1) 110.81,87.9 arc(110.73,87.6) 110.81,87.3 arc(110.86,87.1) 110.81,86.9 arc(110.73,86.6) 110.81,86.3 arc(110.86,86.1) 110.81,85.9 arc(110.73,85.6) 110.81,85.3 arc(110.86,85.1) 110.81,84.9 arc(110.73,84.6) 110.81,84.3 arc(110.86,84.1) 110.81,83.9 arc(110.73,83.6) 110.81,83.3 arc(110.86,83.1) 110.81,82.9 110.8,82.9 arc(110.73,82.6) 110.81,82.3 arc(110.86,82.1) 110.81,81.9 arc(110.73,81.6) 110.81,81.3 arc(110.86,81.1) 110.81,80.9 arc(110.75,80.76) 110.73,80.6 arc(110.73,80.55) 110.73,80.51 122.94,68.3 128.51,68.3 131.05,65.76 131.05,64.08 131.84,63.29 131.84,61.75 132.92,60.67 132.92,59.47 134.32,58.06 154.51,58.06 155.41,58.97 159.35,58.97 161.7,61.32 173.62,61.32 176.25,63.95 176.25,65.55 176.93,66.23 179.23,66.23 179.46,66.46 188,66.46 194.32,60.13 194.32,55.02 193.25,53.95 193.04,53.95 192.84,53.75 192.84,53.54 192.46,53.16 192.46,52.66 192.9,52.22 193.11,52.22 v2(193.52,51.82)
REFCLK_GXPN0: length 52.2
  TOP w0.089: R430.1 159.09,135.36 157.82,135.36 v2(157.45,135)
  ART07 w0.094: v2(126.92,108.6) 126.63,108.44 126.53,108.47 arc(126.32,108.64) 126.05,108.7 126.05,108.7 arc(125.85,108.75) 125.71,108.9 125.7,108.9 arc(125.65,109.1) 125.7,109.3 arc(125.78,109.6) 125.7,109.9 arc(125.65,110.1) 125.7,110.3 arc(125.78,110.6) 125.7,110.9 arc(125.65,111.1) 125.7,111.3 125.8,111.4 arc(125.91,111.47) 126.05,111.5 126.05,111.5 arc(126.35,111.58) 126.57,111.8 126.57,111.8 arc(126.72,111.95) 126.92,112 126.92,112 arc(127.22,112.08) 127.44,112.3 127.44,112.3 arc(127.58,112.45) 127.78,112.5 127.78,112.5 arc(128.08,112.58) 128.3,112.8 128.3,112.8 arc(128.45,112.95) 128.65,113 128.65,113 arc(128.85,113.04) 129.02,113.15 129.17,113.3 129.17,113.3 arc(129.32,113.45) 129.51,113.5 129.52,113.5 arc(129.82,113.58) 130.03,113.8 130.04,113.8 arc(130.18,113.95) 130.38,114 130.38,114 arc(130.68,114.08) 130.9,114.3 130.9,114.3 arc(131.05,114.45) 131.25,114.5 131.25,114.5 arc(131.55,114.58) 131.77,114.8 131.77,114.8 arc(131.91,114.95) 132.11,115 132.12,115 arc(132.41,115.08) 132.63,115.3 132.63,115.3 arc(132.78,115.45) 132.98,115.5 132.98,115.5 arc(133.28,115.58) 133.5,115.8 133.5,115.8 arc(133.65,115.95) 133.84,116 133.85,116 arc(134.15,116.08) 134.36,116.3 arc(134.51,116.44) 134.71,116.5 134.72,116.5 arc(135.01,116.58) 135.23,116.8 arc(135.38,116.94) 135.57,117 135.58,117 arc(135.88,117.08) 136.1,117.3 136.1,117.3 arc(136.24,117.45) 136.44,117.5 136.44,117.5 arc(136.74,117.58) 136.96,117.8 136.96,117.8 arc(137.11,117.95) 137.31,118 arc(137.6,118.08) 137.82,118.29 137.83,118.31 arc(137.98,118.45) 138.17,118.5 138.18,118.5 arc(138.48,118.58) 138.69,118.8 arc(138.72,118.84) 138.76,118.88 138.85,118.98 138.86,118.98 138.99,119.11 139.14,119.11 139.27,119.25 139.27,119.4 139.47,119.59 139.47,119.78 139.58,119.89 139.58,120.08 139.47,120.18 139.47,120.37 139.58,120.48 139.58,120.67 139.47,120.77 139.47,120.96 139.58,121.07 139.58,121.25 139.47,121.36 139.47,121.55 139.58,121.66 139.58,121.84 139.47,121.95 139.47,122.14 139.58,122.25 139.58,122.43 139.47,122.54 139.47,122.73 139.58,122.83 139.58,123.02 139.47,123.13 139.47,123.34 139.6,123.47 139.6,123.65 139.47,123.78 139.47,125.64 140.04,126.22 140.46,126.63 140.87,127.05 141.29,127.47 141.71,127.88 142.12,128.3 142.58,128.75 147.35,128.75 147.84,129.24 149.5,129.24 155.67,135.4 157.36,135.4 157.45,135.31 v2(157.45,135)
REFCLK_GXPN2: length 51.1
  TOP w0.089: R432.1 163.06,130.13 163.06,129.93 v2(163.32,129.67)
  ART07 w0.094: v2(126.92,110.6) 126.63,110.44 126.54,110.46 arc(126.52,110.63) 126.57,110.8 126.57,110.8 arc(126.72,110.95) 126.92,111 126.92,111 arc(127.21,111.08) 127.43,111.29 127.44,111.3 arc(127.58,111.45) 127.78,111.5 127.78,111.5 arc(128.08,111.58) 128.3,111.8 128.3,111.8 arc(128.45,111.95) 128.65,112 arc(128.95,112.08) 129.17,112.3 129.17,112.3 arc(129.32,112.45) 129.51,112.5 129.52,112.5 arc(129.82,112.58) 130.03,112.8 130.04,112.8 arc(130.18,112.95) 130.38,113 130.38,113 arc(130.68,113.08) 130.9,113.3 130.9,113.3 arc(131.05,113.45) 131.25,113.5 131.25,113.5 arc(131.55,113.58) 131.77,113.8 131.77,113.8 arc(131.91,113.95) 132.11,114 132.11,114 arc(132.41,114.08) 132.63,114.3 132.63,114.3 arc(132.78,114.45) 132.98,114.5 132.98,114.5 arc(133.28,114.58) 133.5,114.8 133.5,114.8 arc(133.65,114.95) 133.84,115 arc(134.14,115.08) 134.36,115.3 134.37,115.3 arc(134.51,115.45) 134.71,115.5 134.71,115.5 arc(135.01,115.58) 135.23,115.8 135.23,115.8 arc(135.38,115.95) 135.57,116 135.58,116 arc(135.88,116.08) 136.1,116.3 136.1,116.3 arc(136.24,116.45) 136.44,116.5 136.45,116.5 arc(136.75,116.58) 136.96,116.8 arc(137.11,116.94) 137.31,117 137.32,117 arc(137.61,117.08) 137.83,117.3 arc(137.97,117.44) 138.17,117.5 138.53,117.5 138.71,117.68 138.86,117.68 138.99,117.81 138.99,117.96 139.12,118.09 139.27,118.09 139.41,118.23 139.41,118.38 139.54,118.51 139.96,118.93 140.66,119.63 140.66,125.25 141.71,126.3 142.55,127.13 142.76,127.34 142.97,127.56 147.68,127.56 148.19,128.07 150.48,128.07 151.57,129.16 155.84,129.16 157.57,127.43 161.3,127.43 163.01,129.15 163.01,129.36 v2(163.32,129.67)
REFCLK_GXPP0: length 51.9
  TOP w0.089: v2(157.45,136.01) 157.82,135.65 159.09,135.65 R429.1
  ART07 w0.094: v2(126.05,108.1) 126.33,108.26 126.36,108.35 arc(126.22,108.46) 126.05,108.5 126.05,108.5 arc(125.75,108.58) 125.53,108.79 arc(125.53,108.8) 125.53,108.8 arc(125.45,109.1) 125.53,109.4 arc(125.58,109.6) 125.53,109.8 arc(125.45,110.1) 125.53,110.4 arc(125.58,110.6) 125.53,110.8 arc(125.45,111.1) 125.53,111.4 125.67,111.55 arc(125.85,111.66) 126.05,111.7 arc(126.25,111.75) 126.39,111.9 126.39,111.9 arc(126.61,112.12) 126.91,112.2 126.92,112.2 arc(127.11,112.25) 127.26,112.4 127.26,112.4 arc(127.48,112.62) 127.78,112.7 127.78,112.7 arc(127.98,112.75) 128.12,112.9 128.13,112.9 arc(128.34,113.12) 128.64,113.2 128.65,113.2 arc(128.78,113.23) 128.9,113.3 128.99,113.4 arc(128.99,113.4) 129,113.41 arc(129.21,113.62) 129.51,113.7 129.51,113.7 arc(129.71,113.75) 129.86,113.9 129.86,113.9 arc(130.08,114.12) 130.38,114.2 130.38,114.2 arc(130.58,114.25) 130.72,114.4 130.72,114.4 arc(130.94,114.62) 131.24,114.7 131.25,114.7 arc(131.44,114.75) 131.59,114.9 131.59,114.9 arc(131.81,115.12) 132.11,115.2 132.11,115.2 arc(132.31,115.25) 132.45,115.4 132.46,115.4 arc(132.67,115.62) 132.97,115.7 132.98,115.7 arc(133.17,115.75) 133.32,115.9 133.32,115.9 arc(133.54,116.12) 133.84,116.2 133.84,116.2 arc(134.04,116.26) 134.19,116.4 arc(134.41,116.62) 134.7,116.7 134.71,116.7 arc(134.91,116.76) 135.05,116.9 arc(135.27,117.12) 135.57,117.2 135.57,117.2 arc(135.77,117.25) 135.92,117.4 135.92,117.4 arc(136.14,117.62) 136.44,117.7 136.44,117.7 arc(136.64,117.75) 136.78,117.9 136.79,117.9 arc(137,118.12) 137.3,118.2 137.31,118.2 arc(137.5,118.25) 137.65,118.39 137.66,118.41 arc(137.88,118.62) 138.17,118.7 arc(138.37,118.75) 138.51,118.9 138.52,118.9 arc(138.56,118.97) 138.61,119.03 139.27,119.68 139.27,120.44 139.27,120.44 139.27,125.73 142.49,128.96 147.27,128.96 147.75,129.44 149.42,129.44 155.59,135.61 157.36,135.61 157.45,135.7 v2(157.45,136.01)
REFCLK_GXPP2: length 51
  TOP w0.089: R431.1 162.77,130.13 162.77,129.93 v2(162.51,129.67)
  ART07 w0.094: v2(162.51,129.67) 162.81,129.36 162.81,129.23 161.21,127.63 157.66,127.63 155.93,129.36 151.48,129.36 150.39,128.27 148.11,128.27 147.6,127.76 142.89,127.76 140.46,125.33 140.46,119.72 138.44,117.7 138.17,117.7 arc(137.87,117.62) 137.65,117.4 arc(137.51,117.26) 137.31,117.2 137.3,117.2 arc(137,117.12) 136.79,116.9 arc(136.64,116.76) 136.44,116.7 136.44,116.7 arc(136.14,116.62) 135.92,116.4 135.92,116.4 arc(135.77,116.25) 135.57,116.2 135.57,116.2 arc(135.27,116.12) 135.05,115.9 135.05,115.9 arc(134.91,115.75) 134.71,115.7 arc(134.41,115.62) 134.19,115.4 134.19,115.4 arc(134.04,115.25) 133.84,115.2 133.84,115.2 arc(133.54,115.12) 133.32,114.9 133.32,114.9 arc(133.17,114.75) 132.98,114.7 132.97,114.7 arc(132.67,114.62) 132.46,114.4 132.45,114.4 arc(132.31,114.25) 132.11,114.2 132.11,114.2 arc(131.81,114.12) 131.59,113.9 131.59,113.9 arc(131.44,113.75) 131.25,113.7 131.24,113.7 arc(130.94,113.62) 130.72,113.4 130.72,113.4 arc(130.58,113.25) 130.38,113.2 130.38,113.2 arc(130.08,113.12) 129.86,112.9 129.86,112.9 arc(129.71,112.75) 129.51,112.7 arc(129.21,112.62) 128.99,112.4 128.99,112.4 arc(128.84,112.25) 128.65,112.2 128.64,112.2 arc(128.34,112.12) 128.13,111.9 128.12,111.9 arc(127.98,111.75) 127.78,111.7 127.78,111.7 arc(127.48,111.62) 127.26,111.4 127.26,111.4 arc(127.11,111.25) 126.92,111.2 126.91,111.2 arc(126.61,111.12) 126.39,110.9 arc(126.32,110.65) 126.35,110.39 arc(126.36,110.38) 126.36,110.37 126.33,110.26 v2(126.05,110.1)
REFERENCECLK_1: length 95.9
  BOTTOM w0.109: v2(191.35,34.16) 191.35,32.65 188.73,30.03 166.66,30.03 165.3,31.39 165.3,35.99 160.75,40.54 160.75,62 156.95,65.81 140.74,65.81 136.14,70.41 R940.1
REFERENCECLK_2: length 79.5
  TOP w0.109: v2(194.34,69.98) 194.34,63.8 193.55,63.02 193.55,59.99 192.64,59.09 R475.2
  ART18 w0.114: v2(194.34,69.98) 194.34,71.83 191.62,74.55 184.25,74.55 184.24,74.56 183.98,74.56 180.48,78.06 171.9,78.06 171.15,78.81 164.01,78.81 162.29,77.09 153.9,77.09 153.01,76.2 146.95,76.2 146.82,76.33 v2(146.82,77.19)
  BOTTOM w0.109: R1025.1 137.48,79.57 139.07,77.97 146.04,77.97 v2(146.82,77.19)
REFERENCECLK_3: length 1
  BOTTOM w0.109: R947.2 R1026.1
RESERVED_JTAG_BYPASSN: length 184.5
  TOP w0.109: U23.T17 v2(44.34,179.12)
  ART03 w0.114: v2(188.14,182.6) 186.97,183.77 183.39,183.77 177.95,189.2 177.95,190.86 174.3,194.51 171.4,194.51 170,195.91 165.28,195.91 164.97,196.22 144.4,196.22 142.62,194.44 141.48,194.44 140.84,193.8 140.84,193.17 136.09,188.42 136.09,173.56 134.11,171.58 79.88,171.58 78.36,173.1 78.36,175.13 77.85,175.64 77.85,182.75 75.31,185.29 64.77,185.29 62.74,183.26 53.34,183.26 48.39,178.31 46.2,178.31 45.39,179.12 v2(44.34,179.12)
REV0: length 11.3
  TOP w0.109: U23.D15 v2(33.93,177.52)
  BOTTOM w0.089: v2(33.93,177.52) 33.53,177.93 31.21,177.93
  BOTTOM w0.109: R1054.1 28.19,182.55 28.19,181.17 28.32,181.04 R1058.1 28.7,180.47 28.96,180.21 29.59,180.21 29.72,180.34 30.35,180.34 30.86,179.83 30.86,178.18 31.11,177.93 31.21,177.93
REV1: length 9.5
  TOP w0.109: U23.E15 v2(34.73,177.52)
  BOTTOM w0.089: v2(34.73,177.52) 34.29,177.96 34.29,178.56 34.16,178.69 33.02,178.69 32.77,178.94 32.77,179.98 32.41,180.34 31.21,180.34
  BOTTOM w0.109: R1055.1 R1059.1 30.61,181.42 30.61,180.78 31.05,180.34 31.21,180.34
REV2: length 6.3
  TOP w0.109: U23.C17 v2(33.13,179.12)
  BOTTOM w0.089: v2(33.13,179.12) 33.13,180.1 32.87,180.36
  BOTTOM w0.109: R1056.1 30.99,182.44 30.99,181.21 31.16,181.04 R1060.1 32.19,181.04 32.87,180.36
REV3: length 5.3
  TOP w0.109: U23.D17 v2(33.93,179.12)
  BOTTOM w0.089: 33.53,180.36 33.53,179.53 v2(33.93,179.12)
  BOTTOM w0.109: R1057.1 33.53,182.56 33.53,181.55 R1061.1 33.53,180.53 33.53,180.36
SC_RX: length 201.3
  TOP w0.109: U23.D5 v2(33.94,168.72)
  ART16 w0.114: v2(143.13,211.71) 144.53,211.71 144.91,211.33 144.91,207.13 145.21,206.83 145.21,204.65 144.63,204.06 144.63,196.39 142.13,193.9 142.13,192.86 136.4,187.13 136.4,168.11 135.62,167.34 133.33,167.34 130.94,164.94 130.94,163.58 129.67,162.31 109.88,162.31 106.36,165.82 100.77,165.82 93.83,158.88 82.58,158.88 72.56,168.89 72.56,180.03 73.66,181.13 73.66,181.74 71.75,183.64 56.01,183.64 55.12,182.75 48.39,182.75 46.74,184.4 40.01,184.4 39.12,183.51 31.62,183.51 28.8,180.69 28.8,179.41 29.24,178.97 29.24,175.98 29.25,175.97 29.25,173.93 29.25,173.93 29.25,173.21 31.01,171.45 31.01,171.02 32.13,169.9 33.27,169.9 33.55,169.62 33.55,169.11 v2(33.94,168.72)
SC_TX: length 194.8
  TOP w0.109: U23.D6 v2(33.94,169.52)
  ART16 w0.114: v2(145.54,211.52) 145.29,211.26 145.29,208.31 146.41,207.18 146.41,205.21 144.96,203.76 144.96,195.1 136.78,186.92 136.78,167.96 135.78,166.95 133.49,166.95 131.32,164.78 131.32,163.45 129.79,161.93 109.75,161.93 106.16,165.52 101.01,165.52 93.99,158.5 82.42,158.5 71.96,168.96 71.96,179.12 67.94,183.13 56.26,183.13 55.5,182.37 48.01,182.37 46.86,183.51 40.01,183.51 39.62,183.13 32.39,183.13 29.94,180.69 29.94,180.47 29.62,180.14 29.62,179.58 29.95,179.24 29.97,179.24 30.24,178.97 30.24,172.85 31.08,172.01 31.21,172.01 32.05,171.17 32.05,170.94 32.79,170.21 33.4,170.21 33.94,169.67 v2(33.94,169.52)
SDM_I2C_SCL: length 7.2
  TOP w0.109: R490.2 v2(178.92,95)
  ART20 w0.114: v2(178.92,95) 178.11,95 177.89,94.77 176.62,94.77 175.83,93.98 173.47,93.98 v2(173.07,93.58)
SDM_I2C_SDA: length 2
  TOP w0.109: R491.2 178.95,93.73 178.3,94.38 U29.V10
SDM_IO0: length 84
  ART16 w0.114: v2(177.07,91.98) 177.07,91.75 177.48,91.34 177.48,91.01 177.74,90.75 178.48,90.75 178.66,90.58 179.04,90.58 180.72,88.89 180.72,82.83 177.8,79.91 163.33,79.91 161.24,77.81 155.08,77.81 153.6,76.34 142.83,76.34 141.96,77.22 141.96,77.85 141.61,78.2 141.28,78.2 140.91,78.57 140.91,80.18 140.79,80.3 140.79,89.62 138.8,91.62 137.9,91.62 137.39,92.13 137.1,92.13 136.58,92.65 136.25,92.65 136.01,92.42 136.01,90.04 v2(135.57,89.6)
  BOTTOM w0.109: v2(135.57,89.6) 136.57,89.6 137.01,90.03 137.58,90.03 137.98,89.64 139.16,89.64 140.16,90.63 140.54,90.63 140.88,90.98 141.73,90.98 141.73,90.98 142.34,90.98 142.44,91.09 142.44,91.34 142.54,91.44 R487.2
SDM_IO1: length 6.1
  BOTTOM w0.109: v2(136.44,84.1) 136.77,83.77 136.77,83.42 137.11,83.08 137.41,83.08 137.86,82.64 138.39,82.64 139.55,83.79 139.55,84.14 R965.1
SDM_IO2: length 9
  BOTTOM w0.109: v2(135.57,84.6) 135.13,83.53 135.13,81.39 135.81,80.95 136.41,80.68 136.88,80.59 139.18,80.59 R961.1
SDM_IO3: length 9.6
  BOTTOM w0.109: R954.2 142.4,89.53 140.33,89.53 140.16,89.36 140.04,89.24 140.04,88.98 138.66,87.6 137.94,87.6 137.51,88.04 137.18,88.04 136.66,88.56 136.23,88.56 135.94,88.26 135.94,87.96 v2(135.57,87.6)
SDM_IO4: length 9.8
  BOTTOM w0.109: R953.2 142.56,88.42 142.56,87.5 142.06,86.99 140.31,86.99 138.88,85.57 138.88,85.22 138.35,84.68 137.92,84.68 137.51,85.09 137.26,85.09 136.44,85.91 v2(136.44,86.1)
SDM_IO5: length 10.7
  BOTTOM w0.109: v2(136.44,85.1) 136.78,84.76 136.78,84.33 137.06,84.05 137.61,84.05 138.02,83.64 138.48,83.64 139.21,84.38 139.21,85.08 R957.2 141.06,85.8 142.48,85.8 R3.2 R1.1
SDM_IO6: length 7
  BOTTOM w0.109: R963.1 138.91,87.31 138.91,87.04 138.55,86.69 137.49,86.69 136.6,87.58 136.14,87.58 135.57,87.01 v2(135.57,86.6)
SDM_IO7: length 10.7
  BOTTOM w0.109: R4.2 R2.1 142.53,82.04 141.01,82.04 R967.1 138.95,81 137.2,81 136.64,81.56 136.27,81.56 136.01,81.81 136.01,82.16 v2(135.57,82.6)
SDM_IO8: length 5.4
  BOTTOM w0.109: R958.2 140.38,87.63 138.44,85.69 137.86,85.69 v2(136.44,87.1)
SDM_IO9: length 11.9
  BOTTOM w0.109: R8.2 R7.1 142.4,83.18 140.66,83.18 140.5,83.35 R966.1 139.11,82.43 139.11,81.79 138.91,81.58 137.89,81.58 137.49,81.99 137.31,81.99 136.73,82.57 136.22,82.57 135.91,82.88 135.91,83.27 v2(135.57,83.6)
SDM_IO10: length 8
  BOTTOM w0.109: R964.1 139.04,93.98 138.73,93.67 138,93.67 137.64,94.03 136.79,94.03 136,93.24 136,92.37 135.68,92.05 135.35,92.05 134.71,91.4 v2(134.71,91.1)
SDM_IO11: length 11.3
  BOTTOM w0.109: v2(136.44,90.1) 136.85,90.51 136.85,90.73 137.18,91.06 137.61,91.06 138.05,90.63 139.66,90.63 140.48,91.44 R956.2 140.98,91.92 144.5,91.92 144.83,92.25 145.75,92.25 R481.2
SDM_IO12: length 14.1
  BOTTOM w0.109: v2(132.98,91.1) 132.98,92.04 134.24,93.31 134.24,94.31 134.52,94.59 135.24,94.59 136.31,95.66 136.6,95.66 137.08,96.14 137.54,96.14 137.97,95.71 140.04,95.71 R960.2 140.98,95.73 142.55,95.73 R488.2
SDM_IO13: length 5.7
  BOTTOM w0.109: v2(135.57,91.6) 136.6,91.6 137,92 137.56,92 137.97,91.59 139.38,91.59 R959.2
SDM_IO14: length 11.3
  BOTTOM w0.109: v2(136.44,89.1) 137.39,89.1 137.87,88.61 138.94,88.61 R962.1 140.95,90.63 141.04,90.63 141.05,90.63 143.1,90.63 143.41,90.93 145.9,90.93 146.21,91.25 R480.2
SDM_IO15: length 10.7
  BOTTOM w0.109: v2(134.71,92.1) 135.1,92.49 135.1,93.73 135.81,94.44 136.4,94.44 136.96,95 137.46,95 137.92,94.54 142.48,94.54 R955.2
SDM_IO16: length 80.5
  ART16 w0.089: v2(177.87,91.98) 178.66,91.19
  ART16 w0.114: 178.66,91.19 179.04,91.19 181.14,89.09 181.14,82.62 178.01,79.49 163.69,79.49 159.84,75.64 142.94,75.64 142.61,75.97 142.61,75.97 141.52,77.06 141.22,77.06 140.97,77.3 140.97,77.6 140.09,78.49 140.09,78.56 140.08,78.57 140.08,80.29 140.37,80.58 140.37,88.84 138.65,90.56 138.07,90.56 137.53,91.11 137.11,91.11 136.74,91.48 136.74,91.8 v2(136.44,92.1)
  BOTTOM w0.109: v2(136.44,92.1) 136.75,92.41 136.75,92.76 137.13,93.14 137.54,93.14 138,92.69 138,92.68 138.68,92.68 139.34,93.34 142.93,93.34 143.04,93.23 R482.2
SH_CLK: length 3.9
  TOP w0.109: U54.29 v2(71.78,211.36)
  BOTTOM w0.109: R6035.1 73.8,213.02 72.14,211.36 v2(71.78,211.36)
SHARE_CLK: length 2.9
  BOTTOM w0.109: R5318.1 207.9,188.07 v1(207.9,189.99)
SHARE_CLK_1: length 2.9
  BOTTOM w0.109: v1(206.5,124.49) 207.19,123.8 R5340.1
SI549_CLKN: length 2.7
  BOTTOM w0.089: U34.15 89.69,33.75 89.8,33.86 90.51,33.86 R411.2 91.79,33.59 C818.2
SI549_CLKP: length 2.8
  BOTTOM w0.089: C817.2 91.79,34.48 R411.1 90.44,34.14 89.83,34.14 89.72,34.25 U34.14
SI5338_0_CLK0P: length 1.4
  BOTTOM w0.109: U36.22 155.58,27.96 R444.1
SI5338_0_CLK1N: length 3.5
  BOTTOM w0.089: U36.17 158.18,30.57 158.26,30.48 158.46,30.48 158.85,30.1 158.85,28.81 158.94,28.72 159.05,28.72 R442.2
SI5338_0_CLK1P: length 3.5
  BOTTOM w0.089: R443.2 159.05,28.43 158.82,28.43 158.56,28.69 158.56,29.98 158.35,30.2 158.19,30.2 158.06,30.07 U36.18
SI5338_0_CLK2N: length 3.1
  BOTTOM w0.089: U36.13 158.08,32.57 158.19,32.46 158.27,32.46 158.44,32.63 158.44,33.5 158.74,33.8 159.05,33.8 R439.2
SI5338_0_CLK2P: length 3.1
  BOTTOM w0.089: R440.2 159.05,33.51 158.86,33.51 158.72,33.38 158.72,32.51 158.37,32.16 158.16,32.16 158.08,32.07 U36.14
SI5338_1_CLK0P: length 1.5
  BOTTOM w0.109: R452.2 50.93,105.86 U37.22
SI5338_1_CLK1N: length 3.1
  BOTTOM w0.089: U37.17 53.37,108.6 53.48,108.49 53.77,108.49 54.03,108.23 54.03,107.15 54.1,107.08 54.26,107.08 R450.2
SI5338_1_CLK1P: length 3.1
  BOTTOM w0.089: R451.2 54.26,106.79 53.98,106.79 53.74,107.03 53.74,108.11 53.65,108.2 53.44,108.2 53.33,108.1 U37.18
SI5338_1_CLK2P: length 2
  BOTTOM w0.109: U37.14 53.56,110.1 54.07,110.62 54.07,110.81 R449.2
SI5338_INTR: length 290
  ART03 w0.114: v2(170.67,88.78) 170.25,88.37 169.69,88.37 169.47,88.14 169.47,86.72 169.21,86.46 169.21,82.11 173.09,78.23 179.68,78.23 181.2,76.71 183,76.71 184.81,74.9 193.46,74.9 197.46,70.91 197.46,43.08 189.12,34.75 177.79,34.75 176.54,35.99 156.24,35.99 155.69,35.45 v2(155.07,35.45) 155.07,34.06 153.9,32.89 153.9,30.86 153.52,30.48 152.12,30.48 150.52,32.08 145.64,32.08 140.39,37.34 104.82,37.34 96.31,45.85 92.17,45.85 89.92,48.1 89.92,48.9 89.1,49.71 89.1,51.31 88.5,51.9 88.5,54.42 87.04,55.88 87.04,58.8 85.66,60.19 85.66,68.45 79.84,74.27 77.01,74.27 72.51,78.76 63.57,78.76 59.92,82.42 59.92,85.72 58.51,87.13 56.88,87.13 56.36,87.65 53.52,87.65 52.52,88.65 52.52,89.66 52.27,89.92 52.27,95.45 54.46,97.63 54.46,100.88 53.73,101.6 53.73,107 53.26,107.47 53.26,112.95 52.3,113.92 51.79,113.92 50.42,112.55 v2(50.42,112.46)
  BOTTOM w0.109: v2(155.07,35.45) 155.07,33.28 U36.8 ; U37.8 50.43,112.45 v2(50.42,112.46)
SI5338_OEN: length 295.2
  ART03 w0.114: v3(47.43,111.89) 47.43,112.61 49.25,114.43 52.42,114.43 53.63,113.22 53.63,107.72 54.04,107.31 54.04,101.73 54.96,100.8 54.96,95.99 54.07,95.1 54.07,91.92 54.79,91.21 54.79,88.9 55.57,88.11 56.74,88.11 57.03,87.82 58.46,87.82 60.37,85.91 60.37,82.61 63.76,79.21 72.83,79.21 77.32,74.72 80.03,74.72 85.96,68.78 85.96,60.31 87.49,58.79 87.49,56.07 88.94,54.62 88.94,52.1 89.55,51.48 89.55,50.02 90.3,49.28 90.3,48.36 92.43,46.22 96.57,46.22 104.01,38.79 139.9,38.79 146.2,32.49 152.12,32.49 152.5,32.11 152.5,31.5 v2(153.01,30.99) 153.52,31.5 153.52,33.15 154.53,34.16 154.53,35.61 154.79,35.86 155.65,35.86 156.34,36.55 176.64,36.55 177.99,35.2 189.11,35.2 197.13,43.22 197.13,70.77 193.35,74.55 184.6,74.55 182.88,76.28 181.12,76.28 179.5,77.9 172.59,77.9 168.05,82.45 168.05,86.18 168.68,86.82 168.68,89 168.88,89.2 170.29,89.2 v2(170.67,89.58)
  BOTTOM w0.109: v2(153.01,30.99) 153.09,31.07 U36.3 ; v3(47.43,111.89) R849.2 47.98,110.33 47.98,109.47 48.35,109.1 U37.3
SI52202_FS: length 5.3
  TOP w0.109: R970.1 158.76,137.67 159.76,137.67 R971.1 161.17,136.26 U35.11
SI52202_OE3N: length 5.5
  TOP w0.109: U35.27 167.81,134.76 168.18,135.13 168.94,135.13 R975.1 170.47,133.6 171.55,133.6 R974.1
SI52202_OEN: length 93.3
  TOP w0.109: U35.23 166.35,132.71 167.49,131.57 R848.1 168.02,130.85 168.02,129.66 168.42,129.25 169.61,129.25 170.36,130 173.53,130 174.08,129.45 v2(176.06,129.45) ; v2(161.64,131.25) R436.1 161.01,132.87 161.9,133.76 U35.16 ; U35.14 v2(161.66,134.76)
  ART03 w0.114: v2(161.64,131.25) 161.52,131.38 161.52,134.62 v2(161.66,134.76)
  ART07 w0.114: v2(176.06,129.45) 174.21,129.45 173.36,130.3 163.67,130.3 162.72,131.25 v2(161.64,131.25)
  ART20 w0.114: v2(170.67,91.18) 171.07,91.58 171.07,92.23 171.22,92.38 178.18,92.38 178.38,92.18 180.41,92.18 181.89,93.66 181.89,93.95 182.81,94.87 183.23,94.87 183.66,95.3 183.66,102.01 182.79,102.88 182.79,103.77 183.11,104.09 183.96,104.09 184.27,104.41 184.27,109.32 184,109.59 183.27,109.59 182.67,110.2 182.05,110.2 181.22,111.03 181.22,116.8 180.64,117.37 180.64,120.27 178.84,122.07 178.84,124.03 179.3,124.48 179.3,127.38 177.52,129.16 176.35,129.16 v2(176.06,129.45)
SI52202_PWRDNN: length 166.8
  TOP w0.109: U23.R8 v2(43.53,171.12) ; U35.2 166.35,138.31 167.49,139.45 R847.1 169.52,140.08 169.52,140.97 R435.1 169.54,142.27 169.54,144.27 171.14,145.87 v2(171.14,152.43)
  ART07 w0.114: v2(43.53,171.12) 43.53,172.13 44.17,172.77 53.42,172.77 55.75,170.43 60.71,170.43 61.34,169.8 61.34,168.53 63.31,166.56 63.88,166.56 64.9,165.54 66.36,165.54 67.94,163.96 73.28,163.96 79.25,169.93 79.25,170.69 79.76,171.2 127.76,171.2 128.14,170.81 128.14,165.48 128.91,164.72 130.94,164.72 132.08,163.58 135.89,163.58 136.14,163.32 138.43,163.32 138.94,162.81 138.94,161.54 140.34,160.15 147.07,160.15 148.72,158.49 159.64,158.49 164.85,153.29 167.89,153.29 168.75,152.43 v2(171.14,152.43)
SI52202_SA: length 4.1
  TOP w0.109: R972.1 163.29,141.1 163.29,139.95 R973.1 163.85,139.4 U35.7
SI52202_SS_EN: length 6.7
  TOP w0.109: R433.2 170.66,141.1 170.66,139.95 R434.2 169.64,138.94 167.61,138.94 166.85,138.18 U35.1
SI52202_XIN: length 6.1
  TOP w0.109: Y3.3 166.63,143.03 166.04,142.44 166.04,140 C824.1 166.34,139.45 165.85,138.95 U35.3
SI52202_XOUT: length 4.4
  TOP w0.109: Y3.1 165.71,141.42 165.71,139.95 C829.1 165.2,138.98 165.35,138.83 U35.4
SI53311_CLKOUT1N: length 27.4
  TOP w0.089: C809.1 63.1,22.97 63.1,23.36 v2(62.8,23.66)
  ART20 w0.094: v2(62.8,23.66) 63.17,23.29 63.17,22.87 63.51,22.53 64.32,22.53 78.64,36.86 81.76,36.86 81.85,36.76 v2(81.85,36.45)
SI53311_CLKOUT1P: length 27.4
  TOP w0.089: C810.1 63.39,22.97 63.39,23.36 v2(63.69,23.66)
  ART20 w0.094: v2(81.85,37.47) 81.85,37.15 81.76,37.06 78.56,37.06 65.9,24.4 65.75,24.4 65.62,24.27 65.62,24.11 65.48,23.98 65.33,23.98 65.2,23.85 65.2,23.7 65.07,23.57 64.92,23.57 64.78,23.43 64.78,23.28 64.65,23.15 64.5,23.15 64.37,23.02 64.37,22.86 64.23,22.73 63.6,22.73 63.37,22.96 63.37,23.34 v2(63.69,23.66)
SI53311_CLKSEL: length 216.9
  ART03 w0.114: v2(89.84,37.77) 90.5,38.43 95.91,38.43 96.24,38.1 96.24,32.51 98.26,30.49 103.36,30.49 106.68,33.81 137.46,33.81 142.44,28.83 151.23,28.83 153.5,26.56 157.76,26.56 160.83,29.62 162.95,29.62 163.3,29.97 190.35,29.97 196.87,36.5 196.87,40.02 199.57,42.71 199.57,71.28 193.81,77.04 189.53,77.04 188.17,78.4 186.31,78.4 186.05,78.66 181.91,78.66 180.77,79.81 173.99,79.81 171.6,82.2 171.6,84.75 171.31,85.04 171.31,86.12 171.87,86.68 171.87,87.58 v2(172.27,87.98)
  ART05 w0.114: v2(103.41,37.72) 102.91,37.21 97.13,37.21 96.24,36.32 93.32,36.32 92.33,37.31 90.3,37.31 v2(89.84,37.77)
  BOTTOM w0.109: U34.8 88.73,37.58 88.93,37.77 v2(89.84,37.77) ; R423.2 R918.2 R845.1 v2(103.41,37.72)
SI53311_OE: length 197.6
  ART03 w0.114: v2(172.27,87.18) 172.27,84.45 172.58,84.15 172.58,82.15 174.29,80.44 181.1,80.44 181.96,79.58 192.2,79.58 200.23,71.55 200.23,42.44 197.51,39.72 197.51,36.24 190.47,29.21 165.3,29.21 164.74,28.65 160.74,28.65 158.02,25.93 153.24,25.93 152.41,26.77 152.4,26.77 150.98,28.19 142.14,28.19 137.19,33.15 106.93,33.15 103.56,29.78 97.76,29.78 93.44,34.09 v2(93.44,36.89) 90.43,36.89 90.02,36.47 v2(90.02,35.25)
  BOTTOM w0.109: U34.12 v2(90.02,35.25) ; R412.2 v2(93.44,36.89)
SMA_REFCLKN: length 47.7
  ART20 w0.094: v2(90.78,35.59) 90.43,35.93 89.74,35.93 89.51,35.7 89.51,32.74 88.42,31.65 79.76,31.65 76.88,28.77 76.88,25.24 65.01,13.38 65.01,13.23 64.88,13.09 64.73,13.09 64.6,12.96 64.6,12.81 64.46,12.68 64.31,12.68 64.18,12.54 64.18,12.39 64.05,12.26 63.9,12.26 63.76,12.13 63.76,11.98 63.63,11.84 63.48,11.84 63.35,11.71 63.35,8.03 v3(63.75,7.62)
  BOTTOM w0.089: v2(90.78,35.59) 90.51,35.86 89.8,35.86 89.69,35.75 U34.11
SMA_REFCLKP: length 47.7
  ART20 w0.094: v2(90.78,36.48) 90.43,36.14 89.65,36.14 89.31,35.79 89.31,32.82 88.33,31.85 79.68,31.85 76.68,28.85 76.68,25.33 63.14,11.8 63.14,8.03 v3(62.74,7.62)
  BOTTOM w0.089: U34.10 89.72,36.25 89.83,36.14 90.44,36.14 v2(90.78,36.48)
SODIMM_I2C_SCL: length 68.1
  TOP w0.109: v2(78.08,62.1) 78.24,61.94 U2.A1
  ART18 w0.114: v2(124.32,87.1) 123.89,86.67 123.89,80.06 124.71,79.24 124.71,74.07 123.48,72.84 110.15,72.84 107.36,70.04 84.5,70.04 78.59,64.13 78.59,62.61 v2(78.08,62.1)
  BOTTOM w0.109: R105.1 78.08,62.8 v2(78.08,62.1)
SODIMM_I2C_SDA: length 68.1
  TOP w0.109: v2(78.97,62.1) 78.74,61.88 U2.A2
  ART18 w0.114: v2(126.05,87.1) 126.5,86.64 126.5,79.82 125.19,78.51 125.19,73.91 123.67,72.39 110.34,72.39 107.54,69.6 84.68,69.6 79.6,64.52 79.6,62.74 v2(78.97,62.1)
  BOTTOM w0.109: v2(78.97,62.1) 78.97,62.93 R106.1
SODIMM_IO_TSN: length 138.2
  ART18 w0.114: v2(81.51,63.05) 86.27,67.82 107.54,67.82 110.21,70.48 140,70.48 144.58,75.06 162.23,75.06 164.95,77.78 v2(170.08,77.78)
  BOTTOM w0.109: v2(170.08,77.78) 171.29,78.99 175.77,78.99 178.94,82.17 178.94,86.11 178.44,86.61 170.56,86.61 170.31,86.87 170.31,93 170.09,93.22 168.91,93.22 168.66,93.47 168.66,97.03 168.53,97.16 168.02,97.16 167.89,97.28 167.89,99.44 167.77,99.57 167.08,99.57 v2(166.67,99.98) ; v2(79.24,60.71) 79.22,60.73 79.22,61.26 80.36,62.41 R839.1 v2(81.51,63.05)
SODIMM_REFCLKN: length 96.8
  TOP w0.089: R56.1 v2(162.34,29.21)
  ART20 w0.094: v2(117.39,87.1) 117.39,86.77 117.31,86.7 arc(117.06,86.6) 116.87,86.41 arc(116.87,86.4) 116.87,86.4 arc(116.79,86.1) 116.87,85.8 arc(116.92,85.6) 116.87,85.4 arc(116.79,85.1) 116.87,84.8 arc(116.92,84.6) 116.87,84.4 arc(116.79,84.1) 116.87,83.8 arc(116.92,83.6) 116.87,83.4 arc(116.79,83.1) 116.87,82.8 arc(116.92,82.6) 116.87,82.4 arc(116.79,82.1) 116.87,81.8 116.87,81.8 arc(116.92,81.6) 116.87,81.4 arc(116.79,81.1) 116.87,80.8 116.87,80.8 arc(116.92,80.6) 116.87,80.4 arc(116.81,80.26) 116.79,80.1 116.79,76.06 123.57,69.28 123.57,61.31 124.64,60.24 124.64,59.05 126.44,57.24 126.44,54.14 128.17,52.42 128.17,50.04 v2(127.71,49.58) 128.22,49.07 128.22,43.55 131.89,39.88 158.34,39.88 163.34,34.88 163.34,30.77 163.24,30.66 163.24,30.47 163.34,30.37 163.34,30.18 163.24,30.07 163.24,29.88 163.34,29.78 163.34,29.59 163.24,29.48 163.24,29.29 163.34,29.19 163.34,28.96 163.06,28.68 162.46,28.68 162.34,28.79 v2(162.34,29.21)
SODIMM_REFCLKP: length 96.5
  TOP w0.089: R58.1 v2(162.34,27.94)
  ART20 w0.094: v2(162.34,27.94) 162.34,28.33 162.48,28.47 163.14,28.47 163.55,28.88 163.55,34.96 158.43,40.08 131.97,40.08 128.42,43.63 128.42,49.1 v2(128.9,49.58) 128.37,50.11 128.37,52.5 126.64,54.23 126.64,57.33 124.84,59.13 124.84,60.32 123.77,61.39 123.77,69.37 116.99,76.15 116.99,80.1 arc(117,80.2) 117.04,80.3 arc(117.12,80.6) 117.05,80.9 117.04,80.9 arc(116.99,81.1) 117.04,81.3 arc(117.12,81.6) 117.04,81.9 arc(116.99,82.1) 117.04,82.3 arc(117.12,82.6) 117.05,82.9 117.04,82.9 arc(116.99,83.1) 117.04,83.3 arc(117.12,83.6) 117.04,83.9 arc(116.99,84.1) 117.04,84.3 arc(117.12,84.6) 117.04,84.9 arc(116.99,85.1) 117.04,85.3 arc(117.12,85.6) 117.04,85.9 arc(116.99,86.1) 117.04,86.3 117.05,86.3 arc(117.16,86.43) 117.32,86.49 117.39,86.43 v2(117.39,86.1)
SODIMM_RZQ:
  vias: v2(118.26,86.6)
SODIMM_SA0: length 1.3
  TOP w0.254: v2(91.07,52.02) CON1.256
SODIMM_SA1: length 1.3
  TOP w0.254: v2(90.07,52.02) CON1.260
SODIMM_SA2: length 2.4
  TOP w0.109: v2(113.08,55.47) 113.57,54.98 CON1.166
SODIMM_SCL: length 20.6
  TOP w0.109: v2(91.16,63.5) 91.82,62.84 CON1.253 ; v2(78.2,59.28) 78.24,59.32 U2.C1
  ART18 w0.114: v2(91.16,63.5) 90.78,63.5 90.27,62.99 90.27,60.58 89.13,59.44 79.73,59.44 79.35,59.82 78.74,59.82 v2(78.2,59.28)
  BOTTOM w0.109: R102.2 78.2,58.86 v2(78.2,59.28)
SODIMM_SDA: length 22.6
  TOP w0.109: CON1.254 91.57,51.94 v2(91.74,51.76) ; v2(78.99,59.28) 78.74,59.53 U2.C2
  ART18 w0.114: v2(91.74,51.76) 91.54,51.97 91.54,57.53 90.14,58.93 79.35,58.93 v2(78.99,59.28)
  BOTTOM w0.109: R103.2 79.09,59.18 v2(78.99,59.28)
SODIMM_TYPE0: length 191
  TOP w0.109: U23.B2 32.61,166.72 32.33,166.44 v2(32.33,166.37)
  ART05 w0.114: v3(157.33,198.27) 156.03,199.57 150.82,199.57 149.61,200.79 145.74,200.79 142.94,197.98 141.37,197.98 138.23,194.84 138.23,190.58 135.18,187.53 135.18,177.98 134.11,176.91 80.52,176.91 77.22,180.21 77.22,183.64 76.45,184.4 48.82,184.4 44.42,188.8 33.7,188.8 32.96,188.05 32.96,187.55 32.66,187.25 29.46,187.25 26.74,184.53 26.74,181.63 26.37,180.82 25.99,180.1 25.99,172.97 26.26,172.69 26.26,172 26.26,171.99 26.26,169.01 27.33,167.94 27.33,166.12 27.56,165.89 29.18,165.89 29.19,165.88 29.53,165.88 29.54,165.89 31.85,165.89 v2(32.33,166.37)
  ART18 w0.114: v2(32.33,166.37) 32.33,165.78 32.1,165.56 32.03,165.56 30.91,164.44 29.65,164.44 29.58,164.38 v2(29.17,164.38)
  BOTTOM w0.109: R990.1 v2(29.17,164.38) ; v3(157.33,198.27) 156.84,198.75 156.84,199.39 157.05,199.6 U82.1
SODIMM_TYPE1: length 187.9
  TOP w0.089: 31.21,166.8 v2(31.53,167.12)
  TOP w0.109: 31.21,166.8 31.06,166.65 31.06,166.39 30.83,166.17 30.83,165.49 30.72,165.38 30.72,165.38 28.93,163.59 R991.1 ; v2(31.53,167.12) U23.A2
  ART05 w0.089: v2(31.53,167.12) 31.21,166.8
  ART05 w0.114: 31.21,166.8 31.14,166.72 28.95,166.72 28.17,167.51 28.17,172.08 27.02,173.23 27.02,179.3 26.64,179.68 26.64,180.69 27.05,181.56 27.05,184.4 29.59,186.94 33.44,186.94 33.92,187.42 33.92,187.94 34.43,188.44 44.27,188.44 48.69,184.02 76.2,184.02 76.83,183.39 76.83,179.96 80.39,176.4 134.16,176.4 135.56,177.8 135.56,187.05 139.04,190.52 139.04,193.98 140.65,195.59 140.65,196.2 142,197.55 143.19,197.55 145.92,200.28 149.48,200.28 150.62,199.14 155.6,199.14 v3(156.46,198.27)
  BOTTOM w0.109: v3(156.46,198.27) 156.46,199.67 157.04,200.25 U82.2
SODIMM_VDD_1P3V_SET: length 262.4
  TOP w0.109: U23.C5 v2(33.13,168.72)
  ART03 w0.114: v2(118.94,12.31) 116.45,12.31 114.68,10.54 109.78,10.54 108.18,8.94 105.59,8.94 103.99,10.54 95.61,10.54 92.46,13.68 92.46,13.89 92.05,14.3 77.32,14.3 75.39,16.23 75.39,37.64 79.59,41.84 79.59,43.85 79.14,44.31 78.63,44.31 74.06,48.88 74.06,49.09 73.75,49.39 73.28,49.39 72.83,49.85 72.83,52.45 73.68,53.3 73.68,60.96 72.83,61.82 72.83,61.99 70.99,63.83 70.99,68.13 68.22,70.89 63.65,70.89 61.82,72.72 61.82,75.64 58.37,79.09 48.13,79.09 45.7,81.52 32.05,81.52 27.46,86.12 27.46,119.56 29,121.1 29,124.18 30.6,125.77 30.6,134.81 33.2,137.41 37.35,137.41 39.77,139.83 39.77,142.49 41.4,144.12 41.4,145.57 42.14,146.3 42.14,151.46 41.68,151.92 41.68,152.83 42.26,153.42 42.26,154.18 40.65,155.79 40.65,157.64 40.36,157.93 40.36,160.15 39.32,161.19 37.46,161.19 36.68,160.4 34.36,160.4 33.53,161.23 33.53,161.28 33.43,161.39 33.43,162.57 33.19,162.82 32.77,162.82 32.51,163.08 32.51,164.21 33.53,165.23 33.53,168.33 v2(33.13,168.72)
  BOTTOM w0.109: Q5.1 118.94,13.56 R762.2 v2(118.94,12.31)
SODIMM_VDD_1P35V_SET: length 272.3
  TOP w0.109: U23.C4 v2(33.13,167.92)
  ART03 w0.114: v2(33.13,167.92) 32.74,167.52 32.74,165.91 32.51,165.68 32.2,165.68 31.93,165.4 31.93,163.5 31.98,163.45 31.98,162.53 33.12,161.39 33.12,161.26 33.23,161.16 33.23,161.1 34.24,160.09 34.26,160.09 34.47,159.89 37.06,159.89 37.82,160.65 39.22,160.65 39.98,159.89 39.98,157.88 40.34,157.52 40.34,154.58 41.12,153.8 41.12,146.43 40.1,145.41 40.1,143.56 39.46,142.91 39.46,140.05 37.17,137.76 33.11,137.76 29.31,133.96 29.31,124.92 28.7,124.31 28.7,121.41 27.15,119.86 27.15,85.39 31.47,81.08 45.23,81.08 47.83,78.48 57.1,78.48 59.42,76.16 59.89,76.16 61.21,74.84 61.21,72.69 63.32,70.59 63.52,70.59 63.52,70.58 67.97,70.58 70.68,67.87 70.68,63.7 72.52,61.87 72.52,61.69 73.37,60.84 73.37,53.43 72.42,52.48 72.42,49.42 73.4,48.43 73.84,48.43 78.25,44.02 78.3,44.02 78.32,44 79.01,44 79.28,43.73 79.28,42.35 74.98,38.05 74.98,15.67 77.06,13.59 82.14,13.59 82.83,12.9 92.07,12.9 92.46,12.51 92.46,12.01 96.52,7.95 107.62,7.95 109.91,10.24 114.96,10.24 v2(115.49,10.77)
  ART20 w0.114: v2(115.49,10.77) 118.03,13.31 v2(118.03,23.85)
  BOTTOM w0.109: v2(118.03,23.85) R763.2 118.94,23.34 Q4.1
SODIMM_VDDQ_AGND: length 3.3
  BOTTOM w0.254: 107.72,13.49 107.95,13.26 108.33,13.26 ; Q5.2 117.67,13.44 R762.1 ; R763.1 119.82,23.09 Q4.2
  vias: v1(107.06,12.32)
STBYN: length 89
  TOP w0.109: U31.14 173.29,111.14 174.82,109.61 v3(174.82,109.47)
  ART05 w0.114: v3(174.82,109.47) 175.45,110.11 181.23,110.11 182.57,111.45 187.94,111.45 188.87,110.52 189.43,110.52 190.37,111.45 197.53,111.45 v2(197.97,111.02)
  ART18 w0.114: v2(165.87,89.58) 166.27,89.18 166.27,87.83 166.04,87.6 165.72,87.6 165.51,87.39 165.51,87.33 165.51,87.33 165.51,87.03 165.51,87.03 165.51,87.01 168.22,84.3 170.43,84.3 170.76,83.96 173.41,83.96 175.78,81.6 180.4,81.6 181.86,83.06 183.69,83.06 184.33,83.69 184.33,84.86 186.1,86.64 190.42,86.64 190.84,87.06 190.84,88.73 191.28,89.18 191.28,90.58 191.84,91.13 193.14,91.13 194.13,92.12 194.13,96.36 196.49,98.72 196.49,109.55 v2(197.97,111.02)
SYNC: length 5.5
  TOP w0.109: U54.14 77.59,210.96 77.8,210.74 78.16,210.74 78.84,211.43 78.84,212.64 79.74,213.53 R5977.1
SYNC_1: length 1
  BOTTOM w0.109: v1(198.88,123.22) 199.01,123.09 R5341.1
SYNC_24971985: length 15.6
  ART03 w0.114: v1(200.28,188.72) 199.75,189.26 198.98,189.26 198.2,190.04 198.2,190.18 197.68,190.7 197.54,190.7 195.99,192.25 195.99,198.45 v2(194.23,200.2)
  BOTTOM w0.109: v2(194.23,200.2) 194.51,199.92 R5319.1
SYSMAX_I2C_SCL: length 409.8
  TOP w0.109: U45.2 171.81,125.04 171.49,124.71 R500.1 v2(171.49,122.49) 171.49,121.89 R498.2 ; U35.10 v2(161.77,136.76)
  TOP w0.127: v2(165.33,125.12) 165.46,125.25 U81.2
  ART03 w0.114: v2(171.49,122.49) 168.69,122.49 166.06,125.12 v2(165.33,125.12) 164.21,126.24 163.42,126.24 161.39,128.27 161.39,129.03 161.01,129.41 161.01,136 v2(161.77,136.76) ; v2(52.68,112.14) 52.68,107.36 53.31,106.73 53.31,100.37 52.68,99.74 52.68,98.34 50.9,96.56 50.9,94.06 51.74,93.22 51.74,89.67 52.08,89.32 52.08,87.97 52.88,87.17 55.9,87.17 56.46,86.61 58.16,86.61 59.26,85.52 59.26,82.43 63.35,78.33 72.35,78.33 76.84,73.85 79.67,73.85 85.24,68.28 85.24,60.01 86.44,58.81 86.44,50.21 93.67,42.98 97.03,42.98 99.98,40.02 99.98,34.53 99.44,33.99 v2(99.44,31.89) 103.08,31.89 106.65,35.46 137.72,35.46 143.13,30.05 149.12,30.05 149.71,30.63 151.33,30.63 151.99,29.97 153.72,29.97 154.33,30.58 154.33,32.69 154.79,33.15 156.31,33.15 v2(157.2,34.04) 159.36,34.04 161.9,31.5 189.58,31.5 194.87,36.78 194.87,39.56 197.94,42.63 197.94,71.11 193.58,75.46 184.96,75.46 183.21,77.22 181.38,77.22 179.9,78.69 173.31,78.69 170.17,81.84 170.17,86.73 170.27,86.83 170.27,87.58 v2(170.67,87.98)
  ART05 w0.114: v2(161.77,136.76) 162.38,137.37 163.88,137.37 164.95,138.43 164.95,139.83 164.27,140.5 164.27,147.36 J51.1
  ART16 w0.114: v2(189.28,123.39) 184.58,123.39 184.43,123.24 176.93,123.24 175.36,121.67 172.31,121.67 v2(171.49,122.49)
  ART20 w0.114: v2(170.67,87.98) 171.07,87.58 171.07,87.04 171.37,86.74 184.25,86.74 186.37,88.86 186.37,90 187.47,91.11 188.24,91.11 189.91,92.78 189.91,98.37 190.13,98.6 190.13,107.58 190.92,108.37 190.92,117.97 189.53,119.36 189.53,123.15 v2(189.28,123.39)
  BOTTOM w0.109: U36.12 157.08,33.92 v2(157.2,34.04) ; U37.12 52.43,111.89 v2(52.68,112.14)
SYSMAX_I2C_SDA: length 413.4
  TOP w0.109: v2(161.77,137.54) 162.05,137.26 U35.9 ; R497.2 172.63,121.82 v2(172.63,122.49) R501.1 172.63,124.56 172.21,124.98 U45.3
  TOP w0.127: v2(165.86,124.64) U81.3
  ART03 w0.114: v2(170.67,87.18) 170.67,82.25 173.75,79.17 180.51,79.17 181.96,77.72 183.39,77.72 185.16,75.95 194,75.95 198.4,71.55 198.4,42.44 195.86,39.9 195.86,36.88 189.9,30.92 161.25,30.92 158.9,28.57 v2(157.33,28.57) 156.56,29.34 151.86,29.34 151.04,30.16 150.11,30.16 149.44,29.49 142.72,29.49 137.21,35 106.93,35 103.08,31.15 99.38,31.15 98.91,31.62 98.91,34.57 99.44,35.1 v2(99.44,36.19) 99.44,39.85 96.82,42.47 93.59,42.47 86.02,50.04 86.02,58.64 84.82,59.84 84.82,66.36 82.59,68.59 77.9,68.59 74.71,71.78 74.71,75.07 71.91,77.88 63.02,77.88 58.83,82.07 54.94,82.07 54.28,82.73 53.13,82.73 52.32,83.54 52.32,86.97 51.66,87.63 51.66,89.03 51.25,89.43 51.25,92.99 50.39,93.85 50.39,96.77 52.17,98.55 52.17,99.95 52.8,100.58 v2(52.8,106.43) ; v2(161.77,137.54) 160.47,136.24 160.47,129.21 160.78,128.9 160.78,128.02 163.01,125.78 163.8,125.78 164.95,124.64 v2(165.86,124.64) 165.86,124.63 168.45,122.05 172.18,122.05 v2(172.63,122.49)
  ART05 w0.114: J51.2 164.69,145.41 164.69,140.67 165.58,139.78 165.58,138.3 164.56,137.29 164.56,136.91 163.93,136.27 161.64,136.27 161.32,136.6 161.32,137.09 v2(161.77,137.54)
  ART16 w0.114: v2(189.38,124.31) 188.91,123.84 182.81,123.84 182.01,124.64 179.45,124.64 178.53,123.72 176.72,123.72 175.12,122.12 173,122.12 v2(172.63,122.49)
  ART20 w0.114: v2(189.38,124.31) 189.95,123.74 189.95,119.54 191.34,118.15 191.34,108.15 190.55,107.36 190.55,97.99 190.4,97.84 190.4,90.63 189.94,90.17 187.63,90.17 186.79,89.33 186.79,88.69 184.3,86.2 171.33,86.2 170.67,86.86 v2(170.67,87.18)
  BOTTOM w0.109: v2(52.8,106.43) 52.43,106.8 U37.19 ; v2(157.33,28.57) 157.08,28.82 U36.19
SYSMAX_JTAG_BYPASSN: length 190.3
  TOP w0.109: U23.R15 v2(43.53,177.52)
  ART03 w0.114: v2(185.6,182.6) 185.16,183.05 182.84,183.05 176.02,189.86 176.02,191.49 173.99,193.52 170.84,193.52 169.93,194.44 164.08,194.44 163.03,195.49 160.78,195.49 159.98,194.69 159.51,194.69 158.71,195.49 157.99,195.49 157.06,194.56 145.29,194.56 143.08,192.35 142.15,192.35 136.98,187.19 136.98,173.3 135.13,171.45 135.13,169.42 134.24,168.53 74.17,168.53 71.88,170.81 71.88,174.37 74.65,177.14 74.65,182.14 72.52,184.28 65.28,184.28 63.37,182.37 53.98,182.37 48.74,177.14 43.91,177.14 v2(43.53,177.52)
SYSMAX_JTAG_TCK: length 302.5
  TOP w0.109: R374.2 162.23,84.58 v2(162.35,84.71) ; U23.V12 v2(45.94,175.12)
  ART03 w0.114: v2(198.73,107.32) 199.92,108.52 199.92,116 197.97,117.96 197.97,118.34 196.74,119.56 196.35,119.56 195.43,120.49 195.43,121.72 194.19,122.96 194.19,123.66 193.89,123.96 193.31,123.96 192.41,124.87 192.41,127.15 193.07,127.82 193.07,128.42 192,129.49 192,136.78 193.04,137.82 193.04,142.29 191.87,143.46 191.87,154.69 186.75,159.8 172.65,159.8 172.01,159.16 170.46,159.16 169.89,159.73 164.12,159.73 163.22,160.63 137.57,160.63 136.4,161.8 130.3,161.8 129.29,162.81 109.98,162.81 105.28,167.51 99.82,167.51 94.87,162.56 65.41,162.56 62.74,165.23 62.74,169.16 61.21,170.69 55.63,170.69 52.96,173.35 50.57,173.35 49.15,174.78 46.28,174.78 v2(45.94,175.12)
  ART05 w0.114: v2(170.67,92.78) 171.07,92.38 171.07,87.76 170.86,87.55 163.75,87.55 163.57,87.38 163.57,85.93 v2(162.35,84.71)
  ART20 w0.114: v2(198.73,107.32) 198.73,84.81 195.83,81.92 195.83,79.16 191.16,74.48 182.82,74.48 180.94,76.36 173.92,76.36 171.99,78.29 165.89,78.29 162.35,81.83 v2(162.35,84.71)
SYSMAX_JTAG_TDI: length 301.4
  TOP w0.109: U23.U11 v2(45.14,174.32) ; R372.2 v2(162.43,88.39)
  ART03 w0.114: v2(198.73,108.16) 198.73,108.16 199.5,108.93 199.5,111.42 196.57,114.35 196.57,115.87 197,116.3 197,118.3 195.01,120.3 195.01,121.53 194.06,122.47 193.68,122.47 191.97,124.18 191.97,128.88 190.73,130.12 190.73,136.15 192.61,138.02 192.61,142.01 191.23,143.38 191.23,154.69 186.54,159.38 173.05,159.38 172.39,158.72 170.15,158.72 169.57,159.31 163.88,159.31 163.07,160.12 137.31,160.12 136.14,161.29 129.92,161.29 128.91,162.31 109.86,162.31 105.16,167 99.95,167 93.6,160.66 66.67,160.66 62.23,165.1 62.23,169.04 61.09,170.18 55.5,170.18 52.83,172.85 50.29,172.85 48.89,174.24 47.04,174.24 46.53,173.74 45.72,173.74 v2(45.14,174.32)
  ART05 w0.114: v2(162.43,88.39) 163.13,88.39 163.24,88.28 163.24,87.97 163.36,87.86 163.59,87.86 163.7,87.97 163.7,88.28 163.82,88.39 169.75,88.39 169.87,88.51 v2(169.87,88.78)
  ART20 w0.114: v2(162.43,88.39) 162.89,88.39 163,88.28 163,86.95 162.89,86.84 162.46,86.84 162.34,86.72 162.34,86.49 162.46,86.38 162.89,86.38 163,86.26 163,86.04 162.89,85.92 162.46,85.92 162.34,85.81 162.34,85.58 162.46,85.46 162.89,85.46 163,85.35 163,81.77 166.06,78.71 172.17,78.71 173.6,77.28 180.79,77.28 183.06,75.01 191.09,75.01 195.33,79.24 195.33,83.19 198.31,86.17 198.31,107.73 v2(198.73,108.16)
SYSMAX_JTAG_TDO: length 299.6
  TOP w0.109: U23.U6 v2(45.14,169.52)
  ART03 w0.114: v2(45.14,169.52) 44.6,169.52 44.19,169.93 41.65,169.93 41.53,170.05 41.53,172.34 41.74,172.55 44.55,172.55 44.69,172.41 46.56,172.41 46.91,172.77 49.1,172.77 50.04,171.83 52.45,171.83 58.17,166.12 59.05,166.12 65.66,159.51 94.06,159.51 100.54,165.99 104.9,165.99 109.6,161.29 117.98,161.29 119,160.27 135.56,160.27 137.23,158.6 163.39,158.6 163.52,158.47 169.09,158.47 169.82,157.73 172.72,157.73 173.53,158.54 185.8,158.54 190.27,154.08 190.27,142.8 191.64,141.43 191.64,138.45 188.7,135.51 188.7,129.59 190.25,128.04 190.25,124.66 193.12,121.79 193.12,121.35 194.16,120.31 194.16,119.95 195.44,118.68 195.44,112.43 v2(198.13,109.74)
  ART20 w0.114: v2(198.13,109.74) 198.13,109.03 197.47,108.37 197.47,86.63 194.4,83.55 194.4,82.26 194.4,79.59 190.65,75.84 183.77,75.84 181.43,78.18 174.22,78.18 172.84,79.55 166.47,79.55 163.88,82.14 163.88,88.26 164.01,88.39 166.15,88.39 166.27,88.51 166.27,89.76 166.47,89.97 169.29,89.97 169.67,89.58 v2(169.87,89.58)
SYSMAX_JTAG_TMS: length 299.2
  TOP w0.109: R373.2 v2(162.43,89.66) ; U23.T10 v2(44.34,173.52)
  ART03 w0.114: v2(198.71,108.87) 198.71,110.87 195.86,113.72 195.86,118.85 194.59,120.12 194.59,121.35 193.89,122.05 193.51,122.05 190.89,124.67 190.89,127.99 190.87,128.01 190.87,128.02 190.07,128.83 190.07,132.44 189.46,133.05 189.46,135.51 192.1,138.15 192.1,141.83 190.81,143.11 190.81,154.22 186.07,158.96 173.26,158.96 172.54,158.24 170,158.24 169.35,158.89 163.69,158.89 162.96,159.61 137.14,159.61 135.97,160.78 129.67,160.78 128.65,161.8 109.73,161.8 105.03,166.5 100.33,166.5 93.85,160.02 65.79,160.02 59.18,166.62 58.29,166.62 52.58,172.34 50.2,172.34 48.83,173.71 47.19,173.71 46.43,172.95 44.91,172.95 v2(44.34,173.52)
  ART05 w0.114: v2(170.67,91.98) 170.28,91.59 170.28,89.43 170.03,89.18 162.92,89.18 v2(162.43,89.66)
  ART20 w0.114: v2(198.71,108.87) 197.89,108.05 197.89,86.34 194.82,83.27 194.82,82.08 194.82,79.32 190.92,75.42 183.38,75.42 181.08,77.72 173.75,77.72 172.34,79.13 166.24,79.13 163.42,81.95 163.42,88.67 v2(162.43,89.66)
SYSMAX_LED_G0: length 86.2
  ART18 w0.114: v2(174.72,144.4) 175.74,145.41 180.19,145.41 181.07,144.53 181.07,137.18 182.75,135.51 182.75,129.16 184.28,127.64 184.28,126.92 185.49,125.71 185.49,124.46 187.17,122.78 187.17,119.2 188.14,118.24 188.14,106.93 189.91,105.16 189.91,102.39 184.07,96.54 184.07,93.87 183.59,93.39 182.72,93.39 181.28,91.95 178.74,91.95 178.33,91.54 177.67,91.54 177.47,91.34 177.47,90.98 177.3,90.8 168.07,90.8 167.87,91.01 167.87,91.41 167.66,91.62 167.28,91.62 167.08,91.82 167.08,92.18 166.89,92.37 166.44,92.37 166.26,92.54 166.26,92.96 166.06,93.17 165.74,93.17 165.32,93.58 v2(165.07,93.58)
SYSMAX_LED_G1: length 78.3
  ART18 w0.114: v2(165.87,93.58) 166.08,93.58 166.47,93.19 167.64,93.19 167.87,92.96 167.87,92.64 168.13,92.37 177.25,92.37 177.47,92.58 177.47,92.96 177.8,93.29 181.53,93.29 181.79,93.55 181.79,94.44 182.2,94.86 182.2,96 188.19,101.99 188.19,104.48 186.66,106.01 186.66,117.23 184.29,119.6 184.29,122.29 182.83,123.75 182.83,125.53 181.1,127.25 181.1,130.05 181.36,130.3 181.36,135.52 180.02,136.86 180.02,143.34 180.57,143.89 180.57,144.53 180.19,144.91 177.93,144.91 v2(177.42,144.4)
SYSMAX_LED_G2: length 73.4
  ART18 w0.114: v2(179.8,144.4) 179.32,143.92 179.32,137.11 180.85,135.58 180.85,130.94 179.83,129.92 179.83,127.89 182.47,125.25 182.47,123.6 183.97,122.1 183.97,119.47 186.34,117.1 186.34,105.88 187.2,105.03 187.2,101.6 181.76,96.16 181.76,94.87 180.53,93.64 177.66,93.64 177.19,93.17 168.11,93.17 167.87,93.41 167.87,93.73 167.61,93.98 166.27,93.98 v2(165.87,94.38)
SYSMAX_LED_G3: length 83
  ART18 w0.114: v2(183.49,144.4) 185.65,142.24 188.57,142.24 189.2,141.6 189.2,140.08 188.49,139.37 188.49,136.65 187.43,135.59 187.43,129.85 186.23,128.65 186.23,124.21 187.49,122.95 187.49,122.24 188.49,121.23 188.49,119.25 190.04,117.7 190.04,114.83 188.49,113.28 188.49,107.11 190.32,105.28 190.32,101.7 186.71,98.09 186.71,94.82 184.07,92.18 181.96,92.18 181.41,91.63 179.36,91.63 178.51,90.78 177.71,90.78 177.44,90.51 177.44,90.17 177.24,89.97 168.08,89.97 167.84,90.21 167.84,90.6 167.64,90.8 167.27,90.8 167.05,91.02 167.05,91.36 166.67,91.75 v2(166.67,91.98)
SYSMAX_LED_G4: length 87.7
  ART18 w0.114: v2(186.54,144.4) 187.68,144.4 191.04,141.03 191.04,138.04 188.06,135.05 188.06,129.58 186.87,128.39 186.87,124.71 188.24,123.34 188.24,122.75 189.28,121.72 189.28,119.59 190.85,118.02 190.85,106.5 191.54,105.82 191.54,102.02 188.19,98.67 188.19,94.54 187.96,94.31 187.25,94.31 183.77,90.83 183.61,90.83 183.61,90.82 183.27,90.82 183.26,90.83 182.88,90.83 182.87,90.82 182.53,90.82 182.52,90.83 180.34,90.83 178.71,89.2 177.67,89.2 177.48,89.01 177.48,88.64 177.26,88.42 172.12,88.42 171.91,88.63 171.91,88.93 171.63,89.2 168.02,89.2 167.87,89.35 167.87,89.73 167.63,89.97 167.32,89.97 167.08,90.21 167.08,90.54 166.87,90.75 166.47,90.75 166.24,90.98 166.24,92.13 165.99,92.38 165.7,92.38 165.47,92.61 165.47,92.97 165.26,93.18 164.67,93.18 v2(164.27,93.58)
SYSMAX_LED_Y0: length 84
  TOP w0.109: D33.1 189.61,143.51 189.23,143.13 v2(180.52,143.13)
  ART18 w0.114: v2(166.67,92.78) 166.85,92.78 166.95,92.67 167.01,92.67 167.31,92.38 167.69,92.38 167.87,92.2 167.87,91.85 168.12,91.59 168.12,91.59 168.15,91.57 177.26,91.57 177.5,91.8 177.5,92.15 177.72,92.38 178.28,92.38 178.61,92.71 181.4,92.71 182.1,93.42 182.1,94.31 182.52,94.73 182.52,95.73 189.28,102.49 189.28,103.84 187.07,106.05 187.07,117.58 186.81,117.83 186.81,122.68 185.17,124.33 185.17,125.57 183.96,126.78 183.96,127.06 183.9,127.13 183.9,127.51 182.37,129.03 182.37,135.38 180.52,137.24 v2(180.52,143.13)
SYSMAX_LED_Y1: length 89.7
  ART18 w0.114: v2(164.27,90.38) 164.5,90.38 164.87,90.75 166.01,90.75 166.24,90.52 166.24,90.17 166.44,89.97 166.85,89.97 167.08,89.74 167.08,89.28 167.2,89.17 167.62,89.17 167.89,88.9 167.89,88.51 168.01,88.39 169.31,88.39 169.46,88.24 169.46,87.83 169.72,87.58 170.14,87.58 170.25,87.46 170.25,87.04 171.52,85.77 175.26,85.77 175.88,85.16 178.15,85.16 179.42,86.44 180.52,86.44 181.18,87.1 183.64,87.1 186.81,90.27 187.88,90.27 188.68,91.07 188.68,92.09 190,93.42 190,95.44 194.3,99.73 194.3,117.7 194.49,117.89 194.49,118.58 194.01,119.07 193.3,119.07 191.51,120.86 191.51,123.22 190.99,123.74 190.99,127.16 190.5,127.65 190.5,129.87 190.62,129.98 190.62,133.47 190.93,133.78 190.93,135.72 192.66,137.45 v2(192.66,144.84)
SYSMAX_PB0: length 125.6
  ART18 w0.114: v2(169.26,153.42) 170.66,154.82 175.01,154.82 176.21,156.02 177.49,156.02 178.31,155.19 193.29,155.19 194.08,154.41 194.08,154.06 194.09,154.05 194.09,146.94 193.98,146.83 193.98,137.21 193.37,136.6 193.37,133.81 193.55,133.63 193.55,130.68 192.5,129.64 192.5,128.99 193.07,128.42 193.07,127.57 192.02,126.52 192.02,124.36 194.84,121.54 194.84,119.87 195.43,119.28 195.43,117.51 195.23,117.31 195.23,98.86 191.13,94.77 191.13,92.56 190.55,91.97 190.55,89.48 190.17,89.1 189.46,89.1 188.29,87.93 186.28,87.93 183.61,85.27 182.6,85.27 179.57,82.24 177.06,82.24 174.73,84.58 171.02,84.58 170.68,84.91 168.48,84.91 166.67,86.72 v2(166.67,87.18)
SYSMAX_PB1: length 116.3
  ART18 w0.114: v2(174.09,153.42) 175.36,154.69 193.17,154.69 193.68,154.18 193.68,154.03 193.78,153.92 193.78,147.07 193.68,146.96 193.68,137.34 192.47,136.14 192.47,132.14 193.09,131.52 193.09,130.73 191.95,129.59 191.95,126.88 191.71,126.64 191.71,124.23 194.53,121.41 194.53,119.74 195.12,119.15 195.12,117.63 194.92,117.44 194.92,99.06 190.77,94.92 190.77,92.71 190.22,92.15 190.22,90.32 190.04,90.14 189.68,90.14 189.28,89.74 189.28,89.43 188.74,88.9 186.46,88.9 183.82,86.26 183.05,86.26 180.79,84 175.82,84 174.93,84.89 171.14,84.89 170.23,85.79 169.48,85.79 169.23,86.04 169.23,86.38 169.26,86.41 169.26,86.65 169.15,86.77 167.88,86.77 v2(167.47,87.18)
