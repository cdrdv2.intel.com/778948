# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_RC_RXN14: length 81.1
  TOP w0.097: J14.A77 202.09,93.6 arc(202.04,93.57) 201.99,93.56 200.73,93.56
  ART07 w0.114: 138.46,108.7 138.43,108.7 138.4,108.67 138.22,108.67 arc(137.99,108.73) 137.82,108.89 137.82,108.9 arc(137.77,109.06) 137.79,109.23 137.89,109.26 U1.AG62
  ART07 w0.135: 138.46,108.7 138.54,108.7 arc(138.57,108.71) 138.6,108.73 138.81,108.94 arc(138.9,109.08) 138.94,109.25 138.94,109.33 138.82,109.45 138.82,109.72 138.94,109.83 138.94,110.18 arc(138.97,110.33) 139.05,110.46 139.53,110.94 139.53,111.1 139.73,111.29 139.89,111.29 140.08,111.48 140.08,111.64 140.27,111.83 140.43,111.83 140.62,112.02 140.62,112.19 140.81,112.38 140.97,112.38 141.3,112.71 arc(141.49,112.83) 141.71,112.88 143.33,112.88 arc(143.96,113.14) 144.22,113.77 144.22,114.4 arc(144.53,115.16) 145.28,115.47 156.52,115.47 arc(156.96,115.38) 157.33,115.13 157.72,114.74 arc(158.01,114.54) 158.35,114.48 164.82,114.48 arc(165.07,114.53) 165.29,114.67 165.36,114.74 arc(165.66,114.94) 166,115.01 166.38,115.01 arc(166.81,114.92) 167.18,114.68 168.57,113.29 arc(168.82,112.92) 168.91,112.48 168.91,111.5 arc(168.98,111.16) 169.17,110.87 169.54,110.5 arc(169.83,110.3) 170.17,110.24 182.79,110.24 arc(183.23,110.15) 183.6,109.9 184.4,109.1 184.4,108.79 189.31,103.88 arc(189.47,103.63) 189.53,103.34 189.53,103.17 arc(189.58,102.92) 189.73,102.7 191.46,100.97 arc(191.74,100.78) 192.08,100.71 192.92,100.71 arc(193.36,100.62) 193.73,100.38 199.09,95.01 arc(199.33,94.66) 199.41,94.23 199.41,94.03 arc(199.46,93.8) 199.59,93.6 199.77,93.42 arc(199.93,93.31) 200.11,93.28 200.45,93.28 200.73,93.56
PCIE_RC_RXN15: length 82.6
  TOP w0.097: 200.73,97.56 201.99,97.56 arc(202.04,97.57) 202.09,97.6 J14.A81
  ART07 w0.114: 137.49,111.25 137.43,111.2 137.31,111.2 arc(136.99,111.11) 136.76,110.88 136.73,110.84 arc(136.7,110.79) 136.65,110.76 arc(136.55,110.71) 136.44,110.7 136.44,110.7 arc(136.14,110.61) 135.93,110.4 135.92,110.39 arc(135.61,110.2) 135.27,110.34 135.3,110.44 U1.AD59
  ART07 w0.135: 200.73,97.56 200.45,97.28 199.57,97.28 arc(198.72,97.44) 198.01,97.92 194.08,101.85 arc(193.71,102.1) 193.28,102.18 192.11,102.18 arc(191.77,102.25) 191.48,102.44 190.88,103.04 arc(190.69,103.33) 190.62,103.67 190.62,104.28 arc(190.54,104.71) 190.29,105.08 188.93,106.44 arc(188.74,106.73) 188.67,107.07 188.67,110.97 arc(188.33,111.78) 187.53,112.11 185.97,112.11 arc(185.63,112.18) 185.34,112.38 184.21,113.51 arc(183.84,113.75) 183.4,113.84 176.76,113.84 arc(176.71,113.85) 176.67,113.88 176.59,113.96 arc(176.46,114.04) 176.31,114.07 171.01,114.07 arc(170.67,114.14) 170.38,114.33 169.09,115.62 arc(168.72,115.86) 168.29,115.95 165.49,115.95 arc(165.13,115.88) 164.82,115.67 164.74,115.6 arc(164.52,115.44) 164.25,115.39 159.09,115.39 arc(158.75,115.46) 158.46,115.65 157.41,116.71 arc(157.03,116.96) 156.6,117.04 145.2,117.04 arc(144.76,116.96) 144.39,116.71 143.61,115.93 arc(143.37,115.56) 143.28,115.12 143.28,114.53 arc(143.07,114.02) 142.57,113.82 141.26,113.82 arc(140.82,113.73) 140.45,113.48 139.84,112.87 139.68,112.87 139.49,112.68 139.49,112.52 139.3,112.33 139.14,112.33 138.95,112.14 138.95,111.98 138.76,111.79 arc(138.69,111.74) 138.61,111.73 138.04,111.73 137.57,111.25 137.49,111.25
PCIE_RC_RXP0: length 104.2
  TOP w0.097: 200.73,32.74 200.78,32.69 arc(200.83,32.66) 200.88,32.65 J14.A16
  ART07 w0.114: U1.BP61 137.59,95.44 137.62,95.32 arc(137.61,95.31) 137.61,95.3 arc(137.58,95.04) 137.66,94.8 arc(137.71,94.6) 137.66,94.4 arc(137.58,94.1) 137.66,93.8 arc(137.66,93.8) 137.66,93.8 arc(137.88,93.58) 138.17,93.5 138.48,93.5 arc(138.51,93.5) 138.54,93.48 138.54,93.47 138.57,93.47
  ART07 w0.135: 138.57,93.47 138.58,93.47 arc(138.85,93.36) 138.96,93.09 138.96,90.82 arc(139.01,90.59) 139.13,90.41 140.85,88.69 arc(141.5,88.26) 142.27,88.11 144.66,88.11 arc(145.08,88.02) 145.43,87.79 145.65,87.56 arc(145.89,87.21) 145.97,86.79 145.97,84.78 arc(146.07,84.26) 146.37,83.83 150.98,79.21 arc(151.42,78.92) 151.94,78.82 152.73,78.82 arc(153.15,78.73) 153.5,78.5 154.52,77.48 arc(154.75,77.13) 154.84,76.71 154.84,76.04 arc(154.94,75.53) 155.23,75.09 161.32,69 arc(161.56,68.64) 161.64,68.22 161.64,61.54 arc(161.75,61.03) 162.04,60.59 165.15,57.48 arc(165.54,57.22) 166,57.12 166.12,57.12 arc(166.49,57.05) 166.79,56.85 167.34,56.3 arc(167.58,55.94) 167.66,55.52 167.66,53.99 arc(167.77,53.48) 168.06,53.04 170.74,50.36 arc(171.18,50.06) 171.7,49.96 174.88,49.96 arc(175.3,49.88) 175.65,49.64 175.98,49.31 arc(176.61,48.84) 177.34,48.56 arc(177.43,48.54) 177.52,48.54 183.33,48.54 arc(183.77,48.5) 184.19,48.37 arc(184.49,48.29) 184.79,48.26 190.07,48.26 arc(190.48,48.18) 190.84,47.94 195.97,42.81 arc(196.21,42.46) 196.29,42.04 196.29,37.31 arc(196.39,36.79) 196.68,36.35 199.54,33.5 199.83,33.21 arc(200.03,33.07) 200.28,33.02 200.45,33.02 200.73,32.74
PCIE_RC_RXP1: length 103.6
  TOP w0.097: J14.A21 200.88,37.65 arc(200.83,37.66) 200.78,37.69 200.73,37.74
  ART07 w0.114: 138.76,95.06 138.74,95.08 138.74,95.13 138.49,95.38 arc(138.35,95.47) 138.19,95.5 138.14,95.5 arc(137.89,95.57) 137.71,95.75 137.68,95.81 arc(137.53,95.95) 137.33,96.01 137.29,96.01 arc(137.05,96.07) 136.87,96.25 136.81,96.34 arc(136.48,96.53) 136.14,96.34 136.11,96.28 arc(135.78,96.01) 135.35,96.01 135.31,96.02 arc(135.29,96.03) 135.27,96.04 135.26,96.04 135.11,96.23 134.99,96.26 134.71,96.1
  ART07 w0.135: 200.73,37.74 200.45,38.02 199.92,38.02 arc(199.45,38.12) 199.05,38.38 198.23,39.2 arc(197.94,39.64) 197.84,40.15 197.84,42.06 arc(197.75,42.48) 197.52,42.83 190.43,49.92 arc(190.08,50.16) 189.66,50.24 186.13,50.24 arc(185.8,50.18) 185.53,49.99 185.44,49.91 arc(185.08,49.67) 184.66,49.58 180.21,49.58 arc(179.69,49.68) 179.26,49.98 176.31,52.92 arc(175.96,53.16) 175.54,53.24 172.75,53.24 arc(172.01,53.54) 171.7,54.28 171.7,56 arc(171.62,56.42) 171.38,56.78 169.73,58.43 arc(169.38,58.67) 168.96,58.75 165.75,58.75 arc(165.24,58.85) 164.8,59.14 163.26,60.69 arc(162.96,61.12) 162.86,61.64 162.86,68.78 arc(162.78,69.2) 162.54,69.56 156.37,75.72 arc(156.08,76.16) 155.98,76.68 155.98,77.04 arc(155.9,77.46) 155.66,77.81 154.03,79.44 arc(153.68,79.67) 153.26,79.76 152.37,79.76 arc(151.86,79.86) 151.42,80.15 147.28,84.29 arc(146.99,84.73) 146.89,85.24 146.89,87.15 arc(146.8,87.57) 146.57,87.92 145.34,89.14 arc(144.99,89.38) 144.57,89.46 142.1,89.46 arc(141.59,89.57) 141.15,89.86 140.27,90.74 arc(140.13,90.95) 140.08,91.2 140.08,93.15 arc(139.97,93.7) 139.66,94.16 138.76,95.06
PCIE_RC_RXP2: length 103.5
  TOP w0.097: 200.73,41.74 200.78,41.69 arc(200.83,41.66) 200.88,41.65 J14.A25
  ART07 w0.114: 138.46,96.45 138.43,96.45 138.4,96.48 138.22,96.48 arc(137.9,96.56) 137.66,96.8 arc(137.66,96.8) 137.66,96.8 arc(137.58,97.04) 137.61,97.3 137.62,97.32 137.59,97.44 U1.BK61
  ART07 w0.135: 138.46,96.45 138.6,96.45 arc(138.77,96.41) 138.91,96.32 139.24,95.99 arc(139.44,95.86) 139.67,95.81 140.08,95.81 arc(140.87,95.48) 141.2,94.69 141.2,91.58 arc(141.22,91.45) 141.26,91.32 arc(141.76,90.82) 142.44,90.63 144.92,90.63 arc(145.34,90.55) 145.7,90.31 147.61,88.4 arc(147.84,88.05) 147.93,87.63 147.93,85.82 arc(148.03,85.31) 148.32,84.87 152.05,81.14 arc(152.49,80.85) 153,80.75 153.8,80.75 arc(154.21,80.66) 154.57,80.43 163.81,71.18 arc(164.05,70.83) 164.13,70.41 164.13,62.38 arc(164.23,61.87) 164.53,61.43 165.57,60.39 arc(166,60.1) 166.52,59.99 174.65,59.99 arc(175.17,60.1) 175.6,60.39 177.74,62.52 arc(178.09,62.76) 178.51,62.84 182.7,62.84 arc(182.89,62.88) 183.06,62.99 183.14,63.07 arc(183.22,63.13) 183.32,63.14 184.3,63.14 arc(184.44,63.12) 184.56,63.03 184.65,62.95 arc(184.85,62.81) 185.09,62.76 186.23,62.76 arc(186.65,62.68) 187.01,62.44 190.05,59.4 arc(190.29,59.04) 190.37,58.63 190.37,52.09 arc(190.47,51.57) 190.76,51.14 199.14,42.76 199.67,42.23 arc(199.9,42.08) 200.17,42.02 200.45,42.02 200.73,41.74
PCIE_RC_RXP3: length 99.9
  TOP w0.097: 200.73,45.74 200.78,45.69 arc(200.83,45.66) 200.88,45.65 J14.A29
  ART07 w0.114: 134.71,98.1 134.99,98.26 135.11,98.23 135.12,98.21 arc(135.33,98.06) 135.57,98 135.63,98 arc(135.91,98.08) 136.12,98.29 arc(136.44,98.47) 136.76,98.29 136.77,98.28 arc(136.97,98.08) 137.24,98 137.31,98 arc(137.51,97.95) 137.65,97.81 137.66,97.8 arc(137.88,97.58) 138.17,97.5 138.4,97.5 138.43,97.47 138.46,97.47
  ART07 w0.135: 138.46,97.47 138.8,97.47 arc(139.01,97.43) 139.18,97.32 139.48,97.02 arc(139.72,96.86) 140,96.8 141.07,96.8 arc(141.14,96.79) 141.2,96.75 142.28,95.66 142.86,95.09 arc(143.09,94.73) 143.18,94.31 143.18,93.14 arc(143.54,92.26) 144.42,91.9 144.98,91.9 arc(145.38,91.82) 145.71,91.59 149.36,87.95 arc(149.6,87.59) 149.68,87.17 149.68,85.82 arc(149.78,85.31) 150.07,84.87 153.11,81.84 arc(153.25,81.74) 153.41,81.71 155.86,81.71 arc(156.18,81.65) 156.45,81.47 arc(156.68,81.11) 156.77,80.69 156.77,80.07 arc(156.79,79.92) 156.86,79.79 157.39,79.1 arc(157.52,78.93) 157.66,78.78 arc(161.2,76.42) 165.36,75.59 168.6,75.59 arc(169.02,75.51) 169.38,75.27 170.11,74.54 arc(170.55,74.24) 171.06,74.14 174.45,74.14 arc(174.87,74.06) 175.22,73.82 176.44,72.61 arc(176.67,72.25) 176.76,71.84 176.76,68.15 arc(176.86,67.63) 177.15,67.19 177.86,66.48 arc(178.3,66.19) 178.81,66.09 187.48,66.09 arc(187.9,66.01) 188.25,65.77 189.87,64.15 arc(190.11,63.79) 190.19,63.38 190.19,61.21 arc(190.3,60.69) 190.59,60.26 190.96,59.88 arc(191.2,59.52) 191.28,59.11 191.28,56.51 arc(191.38,56.04) 191.65,55.64 191.73,55.55 arc(191.95,55.23) 192.02,54.86 192.02,52.42 arc(192.12,51.91) 192.42,51.47 194.93,48.96 196.64,47.24 arc(198,46.34) 199.59,46.02 200.45,46.02 200.73,45.74
PCIE_RC_RXP4: length 91.5
  TOP w0.097: 200.73,51.74 201.99,51.74 arc(202.04,51.73) 202.09,51.7 J14.A35
  ART07 w0.114: U1.BF61 137.59,99.44 137.62,99.32 arc(137.62,99.31) 137.61,99.3 arc(137.58,99.04) 137.66,98.8 arc(137.66,98.8) 137.66,98.8 arc(137.9,98.56) 138.22,98.48 138.4,98.48 138.43,98.45 138.46,98.45
  ART07 w0.135: 138.46,98.45 139.18,98.45 arc(139.31,98.42) 139.42,98.35 139.74,98.03 arc(139.89,97.93) 140.07,97.89 142.68,97.89 arc(142.85,97.86) 143,97.76 143.33,97.43 arc(143.5,97.17) 143.56,96.86 143.56,96.32 arc(143.61,96.08) 143.75,95.87 151.32,88.3 arc(151.52,88.01) 151.58,87.67 151.58,85.64 arc(151.67,85.2) 151.92,84.83 153.56,83.19 arc(153.93,82.94) 154.37,82.85 156.09,82.85 arc(156.43,82.79) 156.72,82.59 157.76,81.55 arc(157.93,81.31) 158,81.01 158.06,80 arc(158.08,79.87) 158.14,79.75 158.39,79.38 arc(158.45,79.3) 158.53,79.23 arc(161.53,77.39) 164.96,76.56 arc(165.03,76.56) 165.09,76.55 169.55,76.55 arc(170.21,76.42) 170.78,76.05 171.04,75.78 arc(171.65,75.38) 172.36,75.23 176.84,75.23 arc(177.18,75.17) 177.47,74.97 179.06,73.38 arc(179.25,73.09) 179.32,72.75 179.32,69.87 arc(179.41,69.43) 179.66,69.06 181.27,67.44 arc(181.64,67.19) 182.08,67.11 188.8,67.11 arc(189.14,67.04) 189.43,66.85 193.51,62.77 arc(193.71,62.48) 193.77,62.14 193.77,60.24 arc(193.86,59.8) 194.11,59.43 196.16,57.38 arc(196.35,57.09) 196.42,56.75 196.42,55.57 199.56,52.42 199.76,52.23 arc(199.99,52.08) 200.25,52.02 200.45,52.02 200.73,51.74
PCIE_RC_RXP5: length 92.7
  TOP w0.097: 200.73,55.74 201.99,55.74 arc(202.04,55.73) 202.09,55.7 J14.A39
  ART07 w0.114: 138.46,99.47 138.43,99.47 138.4,99.5 138.17,99.5 arc(137.88,99.58) 137.66,99.8 137.65,99.81 arc(137.51,99.95) 137.31,100 137.26,100 arc(136.99,100.08) 136.79,100.28 136.78,100.3 arc(136.43,100.5) 136.09,100.3 136.09,100.3 arc(135.87,100.08) 135.57,100 arc(135.33,100.06) 135.12,100.21 arc(135.12,100.22) 135.11,100.23 134.99,100.26 134.71,100.1
  ART07 w0.135: 200.73,55.74 200.45,56.02 200.08,56.02 arc(199.86,56.07) 199.68,56.19 199.49,56.38 198,57.87 arc(197.07,59.26) 196.75,60.9 196.75,63.05 arc(196.68,63.39) 196.49,63.68 195.07,65.09 arc(194.83,65.46) 194.74,65.9 194.74,67.14 arc(194.67,67.48) 194.48,67.77 192.87,69.39 arc(192.58,69.58) 192.24,69.65 186.04,69.65 arc(185.61,69.73) 185.24,69.98 184.38,70.83 arc(184.09,71.03) 183.75,71.09 180.77,71.09 arc(180.39,71.25) 180.24,71.63 180.24,73.19 arc(180.17,73.53) 179.98,73.81 177.9,75.89 arc(177.61,76.08) 177.27,76.15 173.69,76.15 arc(173.42,76.26) 173.3,76.54 173.3,76.83 arc(173.27,76.99) 173.18,77.13 172.21,78.1 arc(171.92,78.29) 171.58,78.36 162.9,78.36 arc(162.46,78.45) 162.09,78.69 157.25,83.53 arc(156.96,83.73) 156.62,83.79 155.1,83.79 arc(154.67,83.88) 154.29,84.13 152.83,85.59 arc(152.59,85.96) 152.5,86.4 152.5,88.3 arc(152.43,88.64) 152.24,88.93 145.67,95.49 arc(145.44,95.84) 145.36,96.24 145.36,96.36 arc(145.3,96.67) 145.13,96.93 144.74,97.31 143.53,98.53 arc(143.05,98.85) 142.49,98.96 140.24,98.96 arc(140.09,98.99) 139.96,99.07 139.71,99.33 arc(139.55,99.44) 139.36,99.47 138.46,99.47
PCIE_RC_RXP6: length 87.3
  TOP w0.097: 200.73,59.74 201.99,59.74 arc(202.04,59.73) 202.09,59.7 J14.A43
  ART07 w0.114: 138.46,100.45 138.43,100.45 138.4,100.48 138.22,100.48 arc(137.9,100.56) 137.66,100.8 arc(137.66,100.8) 137.66,100.8 arc(137.58,101.04) 137.61,101.3 137.62,101.32 137.59,101.44 U1.BB61
  ART07 w0.135: 200.73,59.74 200.45,60.02 200.28,60.02 arc(199.96,60.09) 199.7,60.26 199.56,60.4 198.23,61.73 arc(197.94,62.17) 197.84,62.68 197.84,64.06 arc(197.75,64.48) 197.52,64.83 197.24,65.11 arc(196.95,65.54) 196.85,66.06 196.85,68.43 arc(196.76,68.85) 196.53,69.2 192.52,73.21 arc(192.16,73.45) 191.74,73.53 184.22,73.53 arc(183.7,73.63) 183.27,73.93 179.82,77.38 arc(179.46,77.61) 179.04,77.7 174.72,77.7 arc(174.2,77.8) 173.77,78.09 172.88,78.98 arc(172.53,79.21) 172.11,79.3 163.62,79.3 arc(163.11,79.4) 162.67,79.69 159.01,83.35 arc(158.72,83.79) 158.62,84.3 158.62,86.92 arc(158.54,87.34) 158.3,87.69 155.71,90.28 arc(155.36,90.52) 154.94,90.6 152.93,90.6 arc(152.41,90.7) 151.97,91 146.53,96.44 arc(146.44,96.58) 146.4,96.75 146.4,96.87 arc(146.39,96.94) 146.35,97.01 143.38,99.97 arc(143.13,100.14) 142.83,100.2 140.26,100.2 arc(140.09,100.24) 139.95,100.33 139.95,100.33 arc(139.82,100.42) 139.67,100.45 138.46,100.45
PCIE_RC_RXP7: length 87.3
  TOP w0.097: J14.A47 202.09,63.7 arc(202.04,63.73) 201.99,63.74 200.73,63.74
  ART07 w0.114: 138.33,101.47 138.3,101.47 138.27,101.5 138.17,101.5 arc(137.88,101.58) 137.66,101.8 137.65,101.81 arc(137.51,101.95) 137.31,102 137.3,102 arc(137,102.08) 136.78,102.3 136.77,102.33 arc(136.44,102.52) 136.1,102.33 136.05,102.24 arc(135.87,102.05) 135.61,101.98 135.61,101.98 arc(135.43,102.01) 135.27,102.09 135.23,102.12 arc(135.18,102.16) 135.14,102.22 135.08,102.28 arc(135.04,102.3) 135,102.31 arc(134.93,102.3) 134.86,102.25 134.71,102.1
  ART07 w0.135: 138.33,101.47 139.74,101.47 arc(139.84,101.46) 139.92,101.42 arc(139.94,101.4) 139.97,101.38 arc(140.07,101.32) 140.19,101.3 143.25,101.3 arc(143.32,101.28) 143.38,101.25 arc(143.43,101.21) 143.48,101.16 147.44,97.21 arc(147.48,97.15) 147.5,97.08 147.5,96.95 arc(147.53,96.78) 147.63,96.64 152.31,91.95 arc(152.68,91.7) 153.12,91.62 155.38,91.62 arc(155.72,91.55) 156.01,91.36 159.63,87.73 arc(159.82,87.44) 159.89,87.1 159.89,86.55 arc(159.98,86.11) 160.23,85.74 160.49,85.47 arc(160.69,85.18) 160.75,84.84 160.75,83.43 arc(160.84,82.99) 161.09,82.62 163.13,80.57 arc(163.5,80.32) 163.94,80.24 172.91,80.24 arc(173.25,80.17) 173.54,79.98 174.34,79.18 arc(174.71,78.93) 175.15,78.84 179.38,78.84 arc(179.72,78.77) 180.01,78.58 183.66,74.93 arc(184.03,74.69) 184.46,74.6 192.09,74.6 arc(192.43,74.53) 192.71,74.34 197.7,69.35 arc(197.9,69.06) 197.97,68.72 197.97,67.03 arc(198.16,66.04) 198.72,65.2 199.23,64.69 199.74,64.18 arc(199.92,64.06) 200.12,64.02 200.45,64.02 200.73,63.74
PCIE_RC_RXP8: length 85.1
  TOP w0.097: 200.73,68.74 201.99,68.74 arc(202.04,68.73) 202.09,68.7 J14.A52
  ART07 w0.114: 138.46,102.45 138.43,102.45 138.4,102.48 138.22,102.48 arc(137.9,102.56) 137.66,102.8 arc(137.66,102.8) 137.66,102.8 arc(137.58,103.04) 137.61,103.3 arc(137.62,103.31) 137.62,103.32 137.59,103.44 U1.AV61
  ART07 w0.135: 138.46,102.45 139.11,102.45 arc(139.48,102.48) 139.85,102.57 139.86,102.57 arc(140.23,102.66) 140.61,102.69 143.46,102.69 arc(143.71,102.62) 143.87,102.43 144.01,102.11 arc(144.05,102.04) 144.11,101.97 148.25,97.82 arc(148.37,97.66) 148.43,97.46 arc(148.54,97.11) 148.75,96.81 150.96,94.6 arc(151.39,94.31) 151.91,94.21 160.3,94.21 arc(160.67,94.05) 160.83,93.67 160.83,86.96 arc(160.93,86.45) 161.22,86.01 161.35,85.89 arc(161.59,85.53) 161.67,85.12 161.67,83.92 arc(161.77,83.4) 162.06,82.96 163.3,81.72 arc(163.74,81.43) 164.25,81.33 173.28,81.33 arc(173.7,81.25) 174.05,81.01 174.88,80.17 arc(175.32,79.88) 175.84,79.78 180.14,79.78 arc(180.56,79.7) 180.91,79.46 184.31,76.06 arc(184.75,75.77) 185.26,75.67 192.28,75.67 arc(192.7,75.58) 193.05,75.35 197.97,70.43 199.04,69.35 arc(199.41,69.11) 199.84,69.02 200.45,69.02 200.73,68.74
PCIE_RC_RXP9: length 90.6
  TOP w0.097: 200.73,72.74 201.99,72.74 arc(202.04,72.73) 202.09,72.7 J14.A56
  ART07 w0.114: 138.46,103.47 138.43,103.47 138.4,103.5 138.17,103.5 arc(137.88,103.58) 137.66,103.8 137.65,103.81 arc(137.51,103.95) 137.31,104 137.26,104 arc(136.99,104.08) 136.79,104.28 136.78,104.3 arc(136.43,104.5) 136.09,104.3 136.09,104.3 arc(135.87,104.08) 135.57,104 arc(135.33,104.06) 135.12,104.21 arc(135.12,104.22) 135.11,104.23 134.99,104.26 134.71,104.1
  ART07 w0.135: 138.46,103.47 139.58,103.47 arc(139.68,103.48) 139.79,103.5 arc(140.03,103.59) 140.26,103.7 arc(140.34,103.75) 140.41,103.8 arc(140.52,103.86) 140.64,103.89 144.88,103.89 arc(145.05,103.92) 145.19,104.01 arc(145.44,104.18) 145.74,104.24 149.21,104.24 arc(149.55,104.17) 149.83,103.98 150.31,103.51 arc(150.68,103.26) 151.11,103.17 160.56,103.17 arc(160.9,103.11) 161.19,102.91 162.47,101.63 arc(162.67,101.34) 162.74,101 162.74,100.29 arc(162.67,99.95) 162.47,99.67 162.08,99.27 arc(161.83,98.9) 161.74,98.46 161.74,87.36 arc(161.83,86.92) 162.08,86.55 164,84.64 arc(164.37,84.39) 164.81,84.3 172.22,84.3 arc(172.56,84.23) 172.85,84.04 175.83,81.06 arc(176.2,80.81) 176.64,80.72 181.31,80.72 arc(181.65,80.65) 181.94,80.46 182.26,80.14 arc(182.63,79.89) 183.07,79.81 192.13,79.81 arc(192.47,79.74) 192.76,79.55 197.86,74.44 198.85,73.46 arc(199.33,73.14) 199.9,73.02 200.45,73.02 200.73,72.74
PCIE_RC_RXP10: length 83.8
  TOP w0.097: J14.A60 202.09,76.7 arc(202.04,76.73) 201.99,76.74 200.73,76.74
  ART07 w0.114: U1.AP61 137.59,105.44 137.62,105.32 arc(137.62,105.31) 137.61,105.3 arc(137.58,105.04) 137.66,104.8 arc(137.66,104.8) 137.66,104.8 arc(137.9,104.56) 138.22,104.48 138.4,104.48 138.43,104.45 138.46,104.45
  ART07 w0.135: 200.73,76.74 200.45,77.02 199.92,77.02 199.92,77.02 arc(199.51,77.1) 199.16,77.34 198.66,77.84 197.18,79.32 arc(195.67,81.57) 195.15,84.23 195.15,92.85 arc(195.08,93.19) 194.89,93.47 191.82,96.54 arc(191.53,96.73) 191.19,96.8 186.61,96.8 arc(186.18,96.89) 185.81,97.13 180.53,102.41 arc(180.25,102.6) 179.91,102.67 178.85,102.67 arc(178.41,102.75) 178.04,103 177.93,103.12 arc(177.64,103.31) 177.3,103.38 162.95,103.38 arc(162.51,103.46) 162.14,103.71 162.03,103.83 arc(161.74,104.02) 161.4,104.09 151.62,104.09 arc(151.21,104.17) 150.87,104.4 150.35,104.92 arc(150.06,105.11) 149.72,105.18 140.89,105.18 arc(140.66,105.13) 140.46,105 arc(139.85,104.59) 139.12,104.45 138.46,104.45
PCIE_RC_RXP11: length 84.5
  TOP w0.097: J14.A64 202.09,80.7 arc(202.04,80.73) 201.99,80.74 200.73,80.74
  ART07 w0.114: 138.46,105.47 138.43,105.47 138.4,105.5 138.17,105.5 arc(137.88,105.58) 137.66,105.8 137.65,105.81 arc(137.51,105.95) 137.31,106 137.26,106 arc(136.99,106.08) 136.79,106.28 136.78,106.3 arc(136.43,106.5) 136.09,106.3 136.09,106.3 arc(135.87,106.08) 135.57,106 arc(135.33,106.06) 135.12,106.21 arc(135.12,106.22) 135.11,106.23 134.99,106.26 134.71,106.1
  ART07 w0.135: 138.46,105.47 138.67,105.47 140.28,106.02 140.52,106.26 140.56,106.26 140.65,106.35 arc(140.84,106.48) 141.07,106.53 144.45,106.53 arc(144.71,106.49) 144.95,106.36 arc(145.19,106.24) 145.46,106.2 178.66,106.2 arc(179.31,105.93) 179.58,105.28 179.58,105.22 arc(179.66,104.78) 179.91,104.41 186.27,98.05 arc(186.64,97.8) 187.08,97.71 191.8,97.71 arc(192.14,97.65) 192.43,97.45 195.82,94.06 arc(196.02,93.77) 196.09,93.43 196.09,87 arc(196.55,84.64) 197.89,82.65 198.69,81.85 199.22,81.31 arc(199.54,81.1) 199.92,81.02 199.92,81.02 200.45,81.02 200.73,80.74
PCIE_RC_RXP12: length 81.2
  TOP w0.097: J14.A68 202.09,84.7 arc(202.04,84.73) 201.99,84.74 200.73,84.74
  ART07 w0.114: U1.AK61 137.59,107.44 137.62,107.32 arc(137.62,107.31) 137.61,107.3 arc(137.58,107.04) 137.66,106.8 arc(137.66,106.8) 137.66,106.8 arc(137.9,106.56) 138.22,106.48 138.4,106.48 138.43,106.45 138.46,106.45
  ART07 w0.135: 138.46,106.45 138.71,106.45 arc(139.37,106.58) 139.92,106.95 140.61,107.64 arc(140.73,107.72) 140.88,107.75 144.62,107.75 arc(144.79,107.71) 144.93,107.62 arc(145.49,107.24) 146.16,107.11 168.11,107.11 arc(168.54,107.2) 168.92,107.45 169.18,107.71 arc(169.47,107.91) 169.81,107.97 171.02,107.97 arc(171.36,107.91) 171.65,107.71 171.9,107.47 arc(172.27,107.22) 172.7,107.14 181.53,107.14 arc(181.85,107) 181.99,106.68 181.99,104.33 arc(182.08,103.89) 182.32,103.52 186.88,98.96 arc(187.25,98.71) 187.69,98.63 192.16,98.63 arc(192.5,98.56) 192.79,98.37 196.82,94.34 arc(197.01,94.05) 197.08,93.71 197.08,89.23 arc(197.39,87.65) 198.28,86.32 199.32,85.28 arc(199.6,85.09) 199.95,85.02 200.45,85.02 200.73,84.74
PCIE_RC_RXP13: length 83
  TOP w0.097: 200.73,88.74 201.99,88.74 arc(202.04,88.73) 202.09,88.7 J14.A72
  ART07 w0.114: 134.71,108.1 134.99,108.26 135.11,108.23 arc(135.12,108.22) 135.12,108.21 arc(135.33,108.06) 135.57,108 arc(135.87,108.08) 136.09,108.3 136.1,108.33 arc(136.45,108.53) 136.79,108.33 136.81,108.29 arc(137.02,108.08) 137.31,108 arc(137.51,107.95) 137.65,107.81 137.66,107.8 arc(137.88,107.58) 138.17,107.5 138.4,107.5 138.43,107.47 138.46,107.47
  ART07 w0.135: 138.46,107.47 138.57,107.47 arc(139.04,107.57) 139.43,107.83 139.8,108.2 arc(140.06,108.59) 140.16,109.06 140.16,109.26 arc(140.18,109.36) 140.23,109.45 142.07,111.28 arc(142.37,111.48) 142.73,111.56 149.82,111.56 arc(150.16,111.49) 150.44,111.3 153.18,108.56 arc(153.55,108.32) 153.98,108.23 167.73,108.23 arc(168.16,108.32) 168.53,108.56 168.63,108.65 arc(168.91,108.85) 169.25,108.91 171.45,108.91 arc(171.73,108.86) 171.96,108.7 172.05,108.62 arc(172.36,108.4) 172.74,108.33 182.05,108.33 arc(182.39,108.26) 182.68,108.07 184.37,106.38 arc(184.56,106.09) 184.63,105.75 184.63,105.4 arc(184.72,104.96) 184.96,104.59 185.52,104.04 arc(185.77,103.87) 186.07,103.81 186.4,103.81 arc(186.84,103.63) 187.02,103.2 187.02,102.4 arc(187.1,101.96) 187.35,101.59 189.07,99.88 arc(189.44,99.63) 189.88,99.54 192.54,99.54 arc(192.88,99.47) 193.17,99.28 197.93,94.52 arc(198.13,94.23) 198.19,93.89 198.19,92.23 arc(198.46,90.89) 199.22,89.75 199.75,89.22 arc(199.97,89.07) 200.23,89.02 200.45,89.02 200.73,88.74
PCIE_RC_RXP14: length 81.2
  TOP w0.097: 200.73,92.74 201.99,92.74 arc(202.04,92.73) 202.09,92.7 J14.A76
  ART07 w0.114: 138.46,108.45 138.43,108.45 138.4,108.48 138.22,108.48 arc(137.9,108.56) 137.66,108.8 arc(137.66,108.8) 137.66,108.8 arc(137.58,109.04) 137.61,109.3 arc(137.62,109.31) 137.62,109.32 137.59,109.44 U1.AF61
  ART07 w0.135: 200.73,92.74 200.45,93.02 200.11,93.02 arc(199.83,93.08) 199.59,93.24 199.41,93.42 arc(199.22,93.7) 199.16,94.03 199.16,94.23 arc(199.09,94.56) 198.91,94.83 193.55,100.2 arc(193.26,100.39) 192.92,100.46 192.08,100.46 arc(191.65,100.54) 191.28,100.79 189.55,102.52 arc(189.35,102.82) 189.28,103.17 189.28,103.34 arc(189.24,103.54) 189.13,103.7 184.15,108.68 184.15,108.99 183.42,109.72 arc(183.13,109.91) 182.79,109.98 170.17,109.98 arc(169.73,110.07) 169.36,110.32 168.99,110.69 arc(168.74,111.06) 168.65,111.5 168.65,112.48 arc(168.59,112.82) 168.39,113.11 167.01,114.5 arc(166.72,114.69) 166.38,114.76 166,114.76 arc(165.75,114.71) 165.54,114.56 165.47,114.49 arc(165.17,114.29) 164.82,114.22 158.35,114.22 arc(157.92,114.31) 157.55,114.56 157.15,114.95 arc(156.86,115.15) 156.52,115.21 145.28,115.21 arc(144.71,114.98) 144.47,114.4 144.47,113.77 arc(144.14,112.96) 143.33,112.62 141.71,112.62 arc(141.59,112.6) 141.48,112.53 139.23,110.28 arc(139.2,110.23) 139.19,110.18 139.19,109.25 arc(139.14,108.98) 138.99,108.76 138.78,108.55 arc(138.67,108.47) 138.54,108.45 138.46,108.45
PCIE_RC_RXP15: length 82.6
  TOP w0.097: 200.73,96.74 201.99,96.74 arc(202.04,96.73) 202.09,96.7 J14.A80
  ART07 w0.114: 134.71,110.1 134.99,110.26 135.11,110.23 arc(135.12,110.22) 135.12,110.21 arc(135.32,110.06) 135.57,110 135.58,110 arc(135.87,110.09) 136.09,110.3 136.09,110.31 arc(136.24,110.45) 136.44,110.5 arc(136.6,110.53) 136.75,110.59 arc(136.83,110.66) 136.9,110.74 136.92,110.79 arc(137.09,110.95) 137.31,111 137.48,111 137.49,111
  ART07 w0.135: 137.49,111 137.67,111 138.15,111.47 138.61,111.47 arc(138.79,111.51) 138.94,111.61 140.63,113.3 arc(140.92,113.49) 141.26,113.56 142.57,113.56 arc(143.25,113.85) 143.53,114.53 143.53,115.12 arc(143.6,115.46) 143.79,115.75 144.57,116.53 arc(144.86,116.72) 145.2,116.79 156.6,116.79 arc(156.94,116.72) 157.23,116.53 158.28,115.47 arc(158.65,115.22) 159.09,115.14 164.25,115.14 arc(164.61,115.21) 164.92,115.42 165,115.49 arc(165.22,115.64) 165.49,115.7 168.29,115.7 arc(168.63,115.63) 168.91,115.44 170.2,114.15 arc(170.57,113.9) 171.01,113.82 176.31,113.82 arc(176.37,113.81) 176.41,113.78 176.49,113.7 arc(176.61,113.62) 176.76,113.59 183.4,113.59 arc(183.74,113.52) 184.03,113.33 185.16,112.2 arc(185.53,111.95) 185.97,111.86 187.53,111.86 arc(188.15,111.6) 188.41,110.97 188.41,107.07 arc(188.5,106.64) 188.75,106.26 190.11,104.9 arc(190.3,104.62) 190.37,104.28 190.37,103.67 arc(190.46,103.23) 190.71,102.86 191.3,102.26 arc(191.67,102.02) 192.11,101.93 193.28,101.93 arc(193.62,101.86) 193.9,101.67 197.28,98.3 197.83,97.74 arc(198.63,97.21) 199.57,97.02 200.45,97.02 200.73,96.74
PCIE_RC_TXN0: length 130.8
  ART05 w0.114: U1.BR56 132.7,95.26 132.6,95.23 arc(132.57,95.06) 132.63,94.9 arc(132.71,94.6) 132.63,94.31 132.63,94.3 arc(132.57,94.11) 132.61,93.92 arc(132.63,93.9) 132.64,93.88 132.73,93.8 arc(132.83,93.73) 132.95,93.7 arc(132.96,93.7) 132.97,93.7 132.98,93.7 arc(133.1,93.68) 133.23,93.65 arc(133.33,93.6) 133.41,93.51 133.55,93.32 arc(133.69,93.15) 133.86,93.02 134.1,92.87 arc(134.4,92.74) 134.71,92.69 arc(134.99,92.62) 135.2,92.43 135.21,92.42 arc(135.22,92.41) 135.22,92.4 135.23,92.39 arc(135.23,92.39) 135.23,92.39 135.23,92.39 arc(135.23,92.38) 135.23,92.38 arc(135.37,92.24) 135.56,92.2 135.57,92.2 arc(135.87,92.12) 136.09,91.9 arc(136.09,91.9) 136.09,91.9 136.09,91.89 arc(136.24,91.75) 136.44,91.7 136.49,91.7 arc(136.75,91.62) 136.95,91.43 arc(136.95,91.43) 136.96,91.42 136.98,91.39 arc(137.12,91.25) 137.31,91.2 arc(137.61,91.11) 137.82,90.9 137.82,90.89 arc(137.97,90.75) 138.17,90.7 138.4,90.7 138.44,90.73
  ART05 w0.135: C586.1 212.76,31.28 212.54,31.28 arc(212.3,31.23) 212.09,31.09 212.07,31.07 arc(211.79,30.66) 211.68,30.17 arc(211.68,30.15) 211.68,30.13 arc(211.68,30.11) 211.67,30.08 arc(211.54,29.71) 211.3,29.39 arc(211.3,29.38) 211.29,29.38 211.07,29.19 arc(211.04,29.17) 211.01,29.16 210.72,29.12 arc(210.65,29.11) 210.59,29.11 205.96,29.11 arc(204.77,28.87) 203.76,28.19 arc(203.25,27.85) 202.65,27.74 202.12,27.74 arc(201.12,27.93) 200.28,28.5 199.93,28.84 arc(198.91,29.53) 197.7,29.77 167.47,29.77 arc(165.91,30.08) 164.59,30.96 arc(163.78,32.17) 163.5,33.6 163.5,34.29 arc(162.95,36.84) 161.61,39.08 arc(161.39,39.37) 161.2,39.67 arc(161.11,39.82) 161.03,39.98 arc(160.86,40.32) 160.7,40.66 arc(159.98,42.86) 159.74,45.16 159.74,62.8 arc(159.65,63.23) 159.4,63.61 145.11,77.89 arc(144.92,78.18) 144.85,78.52 144.85,79.5 arc(144.77,79.94) 144.52,80.31 143.1,81.73 arc(142.73,81.97) 142.3,82.06 141.45,82.06 arc(141.15,82.19) 141.02,82.5 141.02,84.52 arc(140.93,84.96) 140.68,85.33 140.35,85.66 140.35,85.82 140.16,86.01 140,86.01 139.81,86.2 arc(139.5,86.66) 139.4,87.2 139.4,87.54 139.51,87.65 139.51,87.92 139.4,88.04 139.4,88.31 139.51,88.42 139.51,88.69 139.4,88.8 139.4,89.07 139.51,89.19 139.51,89.46 139.4,89.57 139.4,89.84 arc(139.33,90.19) 139.14,90.5 arc(138.91,90.67) 138.63,90.73 138.44,90.73
PCIE_RC_TXN1: length 132.3
  ART05 w0.114: 138.42,91.73 138.39,91.7 138.17,91.7 arc(137.97,91.75) 137.82,91.89 137.82,91.9 arc(137.61,92.11) 137.31,92.2 137.31,92.2 arc(137.11,92.25) 136.96,92.39 136.96,92.4 arc(136.74,92.62) 136.44,92.7 arc(136.24,92.75) 136.09,92.89 136.09,92.9 arc(135.87,93.11) 135.58,93.2 135.57,93.2 arc(135.37,93.25) 135.23,93.39 135.22,93.4 arc(135.01,93.62) 134.71,93.7 arc(134.51,93.75) 134.36,93.89 134.36,93.9 arc(134.14,94.12) 133.84,94.2 arc(133.64,94.25) 133.49,94.39 133.49,94.4 arc(133.44,94.6) 133.49,94.8 arc(133.57,95.1) 133.49,95.39 133.49,95.4 arc(133.27,95.62) 132.98,95.7 arc(132.78,95.75) 132.63,95.89 132.63,95.9 arc(132.41,96.11) 132.12,96.2 132.11,96.2 arc(131.81,96.12) 131.6,95.9 131.59,95.89 arc(131.45,95.75) 131.25,95.7 arc(131.04,95.75) 130.9,95.89 130.89,95.9 arc(130.68,96.11) 130.38,96.2 130.38,96.2 arc(130.21,96.23) 130.07,96.34 130.1,96.44 U1.BM53
  ART05 w0.135: C588.1 212.76,36.28 212.3,36.28 arc(212.06,36.23) 211.86,36.1 arc(211.67,35.82) 211.61,35.49 211.61,34.05 arc(211.54,33.73) 211.36,33.46 arc(210.99,33.21) 210.54,33.12 207.91,33.12 arc(207.15,33.27) 206.5,33.7 arc(204.95,34.74) 203.13,35.1 200.78,35.1 arc(198.83,34.71) 197.18,33.61 196.34,32.77 arc(194.82,31.75) 193.02,31.39 171.96,31.39 arc(171.13,31.56) 170.43,32.03 165.29,37.17 arc(162,42.09) 160.86,47.91 160.86,64.5 arc(160.77,64.94) 160.52,65.31 157.01,68.82 arc(156.69,69.04) 156.31,69.11 156.19,69.11 arc(155.9,69.17) 155.66,69.33 148.75,76.25 arc(148.55,76.54) 148.49,76.88 148.49,77.5 arc(148.4,77.94) 148.15,78.31 147.7,78.76 arc(147.33,79.01) 146.89,79.09 146.58,79.09 arc(146.24,79.24) 146.1,79.58 146.1,79.99 arc(146.02,80.36) 145.82,80.68 144.02,82.47 arc(143.83,82.76) 143.76,83.1 143.76,84.06 arc(143.67,84.49) 143.43,84.87 142.76,85.53 arc(142.44,85.75) 142.06,85.85 arc(141.69,85.94) 141.37,86.16 140.69,86.84 arc(140.64,86.9) 140.61,86.95 140.49,87.18 arc(140.47,87.24) 140.46,87.31 140.46,88.54 140.58,88.65 140.58,88.92 140.46,89.03 140.46,89.3 140.58,89.42 140.58,89.69 140.46,89.8 140.46,90.07 arc(140.38,90.47) 140.16,90.8 139.5,91.46 arc(139.21,91.66) 138.86,91.73 138.42,91.73
PCIE_RC_TXN2: length 124.9
  ART05 w0.114: 138.43,92.73 138.4,92.73 138.37,92.7 138.17,92.7 arc(137.99,92.74) 137.84,92.87 137.81,92.91 arc(137.6,93.1) 137.33,93.19 arc(137.13,93.25) 136.97,93.38 136.87,93.5 arc(136.74,93.61) 136.58,93.67 136.43,93.7 arc(136.22,93.78) 136.06,93.94 arc(135.87,94.12) 135.63,94.19 arc(135.4,94.26) 135.22,94.41 135.17,94.47 arc(135.01,94.61) 134.81,94.68 arc(134.8,94.68) 134.79,94.68 134.67,94.69 134.66,94.69 arc(134.5,94.73) 134.38,94.85 134.36,94.9 arc(134.3,95.1) 134.36,95.3 arc(134.42,95.45) 134.44,95.61 arc(134.38,95.85) 134.21,96.05 arc(134.2,96.06) 134.18,96.07 arc(133.99,96.16) 133.78,96.2 arc(133.63,96.23) 133.52,96.34 arc(133.52,96.34) 133.52,96.35 133.49,96.4 arc(133.28,96.6) 133.01,96.68 132.92,96.68 arc(132.77,96.72) 132.66,96.82 132.63,96.87 132.6,96.92 arc(132.55,97.07) 132.56,97.22 132.69,97.27 U1.BL56
  ART05 w0.135: 138.43,92.73 139,92.73 arc(139.47,92.63) 139.87,92.37 140.38,91.86 140.54,91.86 140.73,91.67 140.73,91.51 141.09,91.15 arc(141.38,90.72) 141.48,90.2 141.48,89.88 141.59,89.77 141.59,89.5 141.48,89.38 141.48,89.11 141.59,89 141.59,88.73 141.48,88.62 141.48,88.35 141.59,88.23 141.59,87.96 141.48,87.85 141.48,87.58 arc(141.61,87.26) 141.94,87.12 142.24,87.12 arc(142.57,87.06) 142.85,86.87 145.15,84.57 arc(145.4,84.2) 145.49,83.76 145.49,82.94 arc(145.56,82.6) 145.75,82.31 149.19,78.87 arc(149.44,78.5) 149.53,78.06 149.53,77.16 arc(149.59,76.81) 149.79,76.53 155.9,70.41 arc(156.19,70.22) 156.53,70.15 157.06,70.15 arc(157.5,70.07) 157.87,69.82 161.69,66 arc(161.94,65.63) 162.02,65.19 162.02,59.65 arc(162.09,59.31) 162.28,59.02 164.58,56.72 arc(164.83,56.35) 164.92,55.91 164.92,44.95 arc(165.37,42.71) 166.64,40.81 170.85,36.59 arc(172.64,35.39) 174.75,34.97 194.42,34.97 arc(195.02,35.09) 195.53,35.43 arc(196.48,36.07) 197.61,36.3 203.8,36.3 arc(205.03,36.54) 206.07,37.24 206.32,37.49 arc(207.08,38) 207.97,38.18 211.14,38.18 arc(211.31,38.21) 211.46,38.31 arc(211.55,38.44) 211.58,38.6 211.58,39.01 arc(211.67,39.45) 211.92,39.82 212.17,40.08 arc(212.39,40.22) 212.66,40.28 212.76,40.28 C590.1
PCIE_RC_TXN3: length 126.2
  ART05 w0.114: U1.BH53 130.1,98.44 130.07,98.34 arc(130.22,98.23) 130.39,98.19 130.42,98.19 arc(130.63,98.24) 130.78,98.39 arc(130.78,98.39) 130.78,98.4 130.79,98.41 130.82,98.45 arc(131.28,98.69) 131.73,98.43 arc(131.73,98.43) 131.73,98.43 arc(131.73,98.42) 131.74,98.42 131.76,98.38 arc(131.9,98.24) 132.09,98.2 132.12,98.2 arc(132.39,98.13) 132.6,97.94 arc(132.79,97.77) 133.04,97.69 arc(133.27,97.63) 133.46,97.47 arc(133.49,97.43) 133.53,97.39 133.68,97.26 arc(133.77,97.21) 133.87,97.19 133.87,97.19 arc(134.16,97.1) 134.37,96.89 arc(134.42,96.82) 134.49,96.77 134.52,96.75 arc(134.82,96.71) 135.06,96.9 135.07,96.91 arc(135.29,97.13) 135.58,97.2 arc(135.87,97.12) 136.09,96.9 136.09,96.9 arc(136.17,96.6) 136.09,96.3 arc(136.04,96.1) 136.09,95.9 136.09,95.9 arc(136.24,95.75) 136.44,95.7 arc(136.74,95.62) 136.95,95.4 136.96,95.39 arc(137.11,95.25) 137.31,95.2 arc(137.6,95.12) 137.82,94.91 137.82,94.9 arc(137.93,94.77) 138.09,94.7 138.58,94.7 138.61,94.73 138.64,94.73
  ART05 w0.135: 138.64,94.73 138.77,94.73 arc(138.94,94.69) 139.08,94.6 139.27,94.41 139.43,94.41 139.62,94.22 139.62,94.06 139.81,93.87 139.98,93.87 140.17,93.68 140.17,93.51 141.14,92.54 arc(141.57,92.25) 142.09,92.15 arc(142.73,91.86) 143.02,91.21 143.02,88.72 arc(143.11,88.3) 143.34,87.94 146.01,85.28 arc(146.3,84.84) 146.4,84.33 146.4,83.81 arc(146.49,83.4) 146.72,83.04 150.09,79.68 arc(150.38,79.24) 150.48,78.73 150.48,77.73 arc(150.56,77.32) 150.8,76.96 156.3,71.46 arc(156.65,71.23) 157.07,71.14 157.66,71.14 arc(158.17,71.04) 158.61,70.75 162.53,66.83 arc(162.82,66.4) 162.92,65.88 162.92,61.71 arc(163,61.29) 163.24,60.94 167.57,56.61 arc(167.87,56.17) 167.97,55.66 167.97,53.84 arc(168.05,53.42) 168.29,53.07 169.05,52.31 arc(169.34,51.87) 169.44,51.36 169.44,44.91 arc(169.73,43.43) 170.57,42.17 171,41.74 175.33,37.41 arc(176.49,36.64) 177.85,36.37 189.96,36.37 arc(193.01,36.98) 195.6,38.71 arc(197.32,39.86) 199.34,40.26 203.53,40.26 arc(203.95,40.34) 204.3,40.58 205.65,41.92 arc(206.08,42.21) 206.6,42.32 210.94,42.32 arc(211.11,42.35) 211.25,42.44 211.29,42.48 arc(211.43,42.69) 211.48,42.94 arc(211.58,43.44) 211.86,43.87 212.04,44.05 arc(212.3,44.22) 212.6,44.28 212.76,44.28 C592.1
PCIE_RC_TXN4: length 126.7
  ART05 w0.114: 139.03,96.12 139.04,96.11 ; U1.BG56 132.7,99.26 132.6,99.23 132.58,99.18 arc(132.57,99.17) 132.57,99.17 arc(132.56,99.04) 132.6,98.92 132.6,98.92 arc(132.62,98.89) 132.64,98.86 132.66,98.82 arc(132.77,98.71) 132.92,98.67 133,98.66 arc(133.27,98.59) 133.46,98.4 133.46,98.39 arc(133.47,98.39) 133.47,98.39 arc(133.47,98.39) 133.47,98.39 arc(133.57,98.28) 133.71,98.24 133.84,98.24 arc(134.12,98.16) 134.32,97.96 134.36,97.89 arc(134.71,97.7) 135.06,97.9 135.06,97.9 arc(135.57,98.2) 136.09,97.9 136.09,97.9 arc(136.09,97.9) 136.09,97.89 arc(136.23,97.76) 136.41,97.7 arc(136.49,97.69) 136.57,97.66 arc(136.64,97.64) 136.7,97.61 arc(136.78,97.56) 136.84,97.51 137.05,97.3 arc(137.14,97.23) 137.25,97.19 137.32,97.17 arc(137.34,97.17) 137.36,97.17 arc(137.37,97.17) 137.37,97.17 arc(137.46,97.15) 137.55,97.12 arc(137.63,97.07) 137.7,97.01 137.85,96.86 137.85,96.86 137.91,96.8 arc(137.91,96.8) 137.91,96.79 arc(138.05,96.71) 138.21,96.68 138.27,96.68 arc(138.41,96.65) 138.53,96.57 138.63,96.47 arc(138.66,96.45) 138.7,96.44
  ART05 w0.135: 138.7,96.44 139.03,96.12 ; 139.04,96.11 139.23,95.92 139.39,95.92 139.58,95.72 139.58,95.56 139.77,95.37 139.93,95.37 140.12,95.18 140.12,95.02 140.31,94.83 140.47,94.83 140.67,94.64 140.67,94.48 140.86,94.29 141.02,94.29 141.21,94.1 141.21,93.94 141.46,93.68 arc(141.81,93.45) 142.23,93.37 142.35,93.37 arc(142.79,93.28) 143.16,93.03 143.67,92.52 arc(143.96,92.08) 144.07,91.57 144.07,88.61 arc(144.09,88.5) 144.15,88.42 144.17,88.39 arc(144.26,88.34) 144.36,88.31 144.81,88.31 arc(145.32,88.21) 145.75,87.93 147.02,86.66 arc(147.31,86.23) 147.41,85.71 147.41,84.12 arc(147.49,83.7) 147.73,83.35 151.47,79.61 arc(151.76,79.17) 151.86,78.66 151.86,77.82 arc(151.95,77.41) 152.18,77.05 156.63,72.61 arc(156.98,72.37) 157.4,72.29 157.96,72.29 arc(158.48,72.18) 158.92,71.89 163.66,67.15 arc(163.95,66.71) 164.06,66.2 164.06,62.25 arc(164.14,61.84) 164.38,61.48 167.04,58.82 arc(167.4,58.58) 167.81,58.5 169.17,58.5 arc(169.68,58.39) 170.12,58.1 170.65,57.57 arc(170.94,57.14) 171.04,56.62 171.04,45.52 arc(171.41,43.66) 172.46,42.09 173.95,40.6 arc(175.06,39.86) 176.37,39.6 193.22,39.6 arc(193.64,39.68) 193.99,39.92 197.8,43.72 arc(198.24,44.02) 198.75,44.12 203.99,44.12 arc(204.41,44.2) 204.76,44.44 206.23,45.91 arc(206.67,46.2) 207.18,46.3 210.77,46.3 arc(211.29,46.52) 211.5,47.04 211.5,48.86 arc(211.64,49.52) 212.01,50.09 arc(212.22,50.23) 212.47,50.28 212.76,50.28 C594.1
PCIE_RC_TXN5: length 128
  ART05 w0.114: 139.01,97.38 138.69,97.7 138.17,97.7 arc(137.97,97.75) 137.82,97.89 137.82,97.9 arc(137.61,98.11) 137.31,98.2 137.31,98.2 arc(137.11,98.25) 136.96,98.39 136.96,98.4 arc(136.95,98.4) 136.95,98.4 arc(136.74,98.62) 136.44,98.7 arc(136.24,98.75) 136.09,98.89 136.09,98.9 arc(135.87,99.11) 135.58,99.2 135.57,99.2 arc(135.28,99.12) 135.06,98.9 arc(135.06,98.9) 135.06,98.9 135.06,98.89 arc(134.71,98.7) 134.36,98.89 134.36,98.9 arc(134.14,99.11) 133.85,99.2 133.84,99.2 arc(133.64,99.25) 133.49,99.39 133.49,99.4 arc(133.49,99.4) 133.49,99.4 arc(133.27,99.62) 132.98,99.7 arc(132.78,99.75) 132.63,99.89 132.63,99.9 arc(132.41,100.11) 132.12,100.2 132.11,100.2 arc(131.82,100.12) 131.6,99.9 arc(131.6,99.9) 131.6,99.9 arc(131.25,99.7) 130.89,99.9 arc(130.89,99.9) 130.89,99.9 arc(130.68,100.12) 130.38,100.2 130.38,100.2 arc(130.21,100.23) 130.07,100.34 130.1,100.44 U1.BD53
  ART05 w0.135: 139.01,97.38 139.44,96.94 arc(139.65,96.8) 139.9,96.75 140.17,96.75 140.22,96.8 140.62,96.8 140.67,96.75 141.35,96.75 arc(141.66,96.69) 141.92,96.51 142.13,96.3 142.29,96.3 142.48,96.11 142.48,95.95 142.67,95.76 142.83,95.76 143.02,95.57 143.02,95.41 143.39,95.04 arc(143.61,94.71) 143.69,94.33 143.69,94.23 arc(143.91,93.69) 144.45,93.47 144.71,93.47 arc(145.03,93.41) 145.3,93.23 145.32,93.21 arc(145.5,92.94) 145.56,92.62 145.56,90.34 arc(145.65,89.92) 145.88,89.57 147.91,87.54 arc(148.21,87.1) 148.31,86.59 148.31,84.5 arc(148.39,84.08) 148.63,83.73 164.8,67.55 arc(165.1,67.11) 165.2,66.6 165.2,62.76 arc(165.28,62.34) 165.52,61.99 167.43,60.07 arc(167.78,59.84) 168.2,59.75 169.35,59.75 arc(169.87,59.65) 170.3,59.36 172.93,56.73 arc(173.22,56.29) 173.33,55.78 173.33,46.61 arc(173.76,44.45) 174.98,42.62 175.74,41.86 arc(177.17,40.9) 178.87,40.56 192.13,40.56 arc(192.55,40.65) 192.9,40.88 201.41,49.39 arc(201.84,49.68) 202.36,49.78 203.17,49.78 arc(203.59,49.87) 203.95,50.1 205.62,51.78 arc(206.06,52.07) 206.57,52.17 211.02,52.17 arc(211.38,52.32) 211.53,52.68 211.53,53.05 arc(211.61,53.48) 211.86,53.85 212.07,54.06 arc(212.31,54.22) 212.6,54.28 212.76,54.28 C596.1
PCIE_RC_TXN6: length 107.2
  ART05 w0.114: 138.48,98.73 138.45,98.7 138.17,98.7 arc(137.97,98.75) 137.82,98.89 137.82,98.9 arc(137.82,98.9) 137.82,98.9 arc(137.6,99.12) 137.31,99.2 arc(137.31,99.2) 137.31,99.2 137.26,99.2 arc(137.23,99.2) 137.21,99.2 137.12,99.21 arc(137.05,99.24) 136.99,99.29 136.86,99.48 arc(136.79,99.55) 136.71,99.61 arc(136.59,99.66) 136.46,99.69 arc(136.24,99.77) 136.07,99.94 arc(135.56,100.19) 135.07,99.9 arc(135.06,99.88) 135.05,99.87 134.96,99.78 arc(134.87,99.72) 134.75,99.69 134.7,99.69 arc(134.51,99.75) 134.36,99.89 134.36,99.89 arc(134.36,99.9) 134.36,99.9 arc(134.36,99.9) 134.35,99.9 arc(134.14,100.11) 133.85,100.19 133.85,100.19 arc(133.64,100.24) 133.5,100.39 133.49,100.4 arc(133.49,100.4) 133.49,100.4 arc(133.28,100.61) 133,100.68 132.97,100.68 arc(132.78,100.74) 132.64,100.87 132.63,100.9 arc(132.57,101.06) 132.6,101.23 132.7,101.26 U1.BC56
  ART05 w0.135: C598.1 212.76,58.28 212.55,58.28 arc(212.33,58.32) 212.14,58.45 arc(212.08,58.53) 212.06,58.63 212.06,59 arc(211.98,59.45) 211.73,59.82 211.67,59.88 arc(211.23,60.17) 210.72,60.27 207.13,60.27 arc(206.62,60.17) 206.18,59.88 204.81,58.51 arc(204.46,58.28) 204.04,58.19 197.02,58.19 arc(196.6,58.28) 196.25,58.51 188.78,65.97 arc(188.35,66.27) 187.83,66.37 178.8,66.37 arc(178.38,66.45) 178.03,66.69 175.09,69.62 arc(174.86,69.98) 174.77,70.39 174.77,73.4 arc(174.7,73.8) 174.47,74.14 174.45,74.17 arc(174.11,74.39) 173.71,74.47 170.33,74.47 arc(169.91,74.55) 169.55,74.79 168.97,75.37 arc(168.53,75.66) 168.02,75.77 162.19,75.77 arc(158.22,76.56) 154.84,78.81 149.87,83.78 arc(149.64,84.14) 149.55,84.55 149.55,87.1 arc(149.45,87.61) 149.16,88.05 146.82,90.38 arc(146.59,90.74) 146.5,91.15 146.5,92.79 arc(146.4,93.31) 146.11,93.74 144.88,94.97 144.88,95.14 144.69,95.33 144.53,95.33 144.34,95.52 arc(144.18,95.76) 144.12,96.04 144.12,96.18 arc(143.97,96.91) 143.56,97.54 143.1,97.99 arc(142.9,98.12) 142.67,98.17 142.54,98.17 142.42,98.29 142.15,98.29 142.04,98.17 141.77,98.17 141.66,98.29 141.39,98.29 141.27,98.17 141,98.17 140.89,98.29 140.62,98.29 140.51,98.17 140.24,98.17 140.12,98.29 139.85,98.29 139.74,98.17 139.47,98.17 arc(139.4,98.18) 139.34,98.22 arc(139.3,98.26) 139.25,98.3 139.19,98.37 arc(139.17,98.38) 139.16,98.39 138.82,98.73 138.48,98.73
PCIE_RC_TXN7: length 107.2
  ART05 w0.114: 138.59,99.73 138.56,99.73 138.53,99.7 138.17,99.7 ; U1.AY53 130.1,102.44 130.07,102.34 arc(130.21,102.23) 130.38,102.2 130.38,102.2 arc(130.68,102.11) 130.89,101.9 130.9,101.89 arc(131.04,101.75) 131.25,101.7 arc(131.45,101.75) 131.59,101.89 131.6,101.9 arc(131.81,102.12) 132.11,102.2 132.12,102.2 arc(132.41,102.11) 132.63,101.9 132.63,101.89 arc(132.78,101.75) 132.98,101.7 arc(133.27,101.62) 133.49,101.4 133.49,101.39 arc(133.64,101.25) 133.84,101.2 133.85,101.2 arc(134.14,101.11) 134.36,100.9 134.36,100.89 arc(134.51,100.75) 134.71,100.7 arc(134.91,100.75) 135.06,100.89 135.06,100.9 arc(135.28,101.12) 135.57,101.2 135.58,101.2 arc(135.87,101.11) 136.09,100.9 136.09,100.89 arc(136.24,100.75) 136.44,100.7 arc(136.74,100.62) 136.96,100.4 136.96,100.39 arc(137.11,100.25) 137.31,100.2 137.31,100.2 arc(137.61,100.11) 137.82,99.9 137.82,99.89 arc(137.97,99.75) 138.17,99.7 ; 138.17,99.7 138.17,99.7
  ART05 w0.135: 138.59,99.73 138.88,99.73 arc(139.01,99.7) 139.12,99.64 139.33,99.47 arc(139.68,99.28) 140.06,99.21 140.33,99.21 140.44,99.33 140.71,99.33 140.83,99.21 141.1,99.21 141.21,99.33 141.48,99.33 141.59,99.21 142.06,99.21 142.13,99.28 142.38,99.28 142.44,99.21 142.81,99.21 arc(143.13,99.15) 143.4,98.97 145.48,96.89 arc(145.77,96.45) 145.87,95.94 145.87,95.75 arc(145.95,95.33) 146.19,94.98 147.08,94.09 arc(147.37,93.66) 147.47,93.14 147.47,92.55 arc(147.55,92.13) 147.79,91.78 150.1,89.47 arc(150.39,89.03) 150.49,88.52 150.49,84.91 arc(150.58,84.49) 150.81,84.13 155.07,79.88 arc(158.22,77.78) 161.93,77.04 169.87,77.04 arc(170.39,76.93) 170.83,76.64 171.69,75.78 arc(172.04,75.55) 172.46,75.46 174.17,75.46 arc(174.68,75.36) 175.12,75.07 176.54,73.65 arc(176.83,73.21) 176.93,72.69 176.93,71.77 arc(177.02,71.36) 177.25,71 180.65,67.6 arc(181.01,67.37) 181.42,67.28 188.57,67.28 arc(189.08,67.18) 189.52,66.89 193.91,62.5 arc(194.27,62.26) 194.68,62.18 204.62,62.18 arc(205.04,62.26) 205.4,62.5 206.64,63.74 arc(207.08,64.03) 207.59,64.13 211.3,64.13 arc(211.78,63.93) 211.99,63.44 211.99,63.08 arc(212.05,62.78) 212.21,62.53 212.38,62.37 arc(212.48,62.3) 212.6,62.28 212.76,62.28 C600.1
PCIE_RC_TXN8: length 104.5
  ART05 w0.114: 138.51,100.72 138.48,100.72 138.45,100.69 138.21,100.69 arc(138.02,100.73) 137.86,100.84 137.62,101.07 arc(137.47,101.17) 137.29,101.21 137.2,101.21 arc(137.12,101.23) 137.05,101.28 136.98,101.36 arc(136.97,101.37) 136.97,101.37 arc(136.75,101.57) 136.47,101.69 136.46,101.69 arc(136.42,101.71) 136.37,101.71 136.36,101.72 arc(136.21,101.77) 136.09,101.89 136.09,101.9 arc(136.09,101.9) 136.09,101.9 arc(135.87,102.12) 135.58,102.2 135.57,102.2 arc(135.28,102.12) 135.06,101.9 arc(135.06,101.9) 135.06,101.9 135.06,101.89 arc(134.91,101.75) 134.71,101.7 134.64,101.69 arc(134.5,101.73) 134.4,101.83 134.36,101.89 arc(134.36,101.89) 134.36,101.89 134.33,101.95 arc(134.17,102.1) 133.97,102.17 133.88,102.17 arc(133.66,102.23) 133.49,102.38 arc(133.27,102.59) 132.97,102.67 132.94,102.67 arc(132.78,102.72) 132.66,102.84 132.63,102.9 arc(132.57,103.06) 132.6,103.23 132.7,103.26 U1.AW56
  ART05 w0.135: C602.1 212.76,67.28 212.62,67.28 arc(212.19,67.1) 212.01,66.67 212.01,66.31 arc(211.94,65.95) 211.73,65.64 211.73,65.63 arc(211.53,65.5) 211.3,65.45 207.59,65.45 arc(207.17,65.54) 206.82,65.77 206.54,66.05 arc(206.11,66.34) 205.59,66.45 201.14,66.45 arc(200.62,66.34) 200.19,66.05 199.94,65.8 arc(199.58,65.56) 199.16,65.48 193.19,65.48 arc(192.77,65.56) 192.41,65.8 189.34,68.87 arc(188.91,69.16) 188.39,69.26 180.84,69.26 arc(180.42,69.35) 180.07,69.58 179.95,69.71 arc(179.71,70.06) 179.63,70.48 179.63,71.23 arc(179.51,71.83) 179.17,72.34 arc(179.13,72.39) 179.12,72.46 179.12,73.31 arc(179.02,73.82) 178.72,74.26 174.87,78.12 arc(174.43,78.41) 173.91,78.51 161.08,78.51 arc(157.96,79.13) 155.32,80.9 151.96,84.26 arc(151.72,84.62) 151.64,85.03 151.64,89.16 arc(151.53,89.67) 151.24,90.11 148.86,92.49 arc(148.62,92.85) 148.54,93.27 148.54,93.37 arc(148.43,93.89) 148.14,94.33 147.1,95.36 arc(146.87,95.7) 146.78,96.11 arc(146.78,96.18) 146.77,96.26 arc(146.6,96.89) 146.28,97.45 arc(146.23,97.51) 146.17,97.57 143.56,100.18 arc(143.5,100.24) 143.44,100.3 arc(143.19,100.47) 142.9,100.53 142.8,100.53 142.69,100.65 142.42,100.65 142.3,100.53 142.04,100.53 141.92,100.65 141.65,100.65 141.54,100.53 141.27,100.53 141.15,100.65 140.88,100.65 140.77,100.53 140.5,100.53 140.39,100.65 140.12,100.65 140,100.53 139.73,100.53 arc(139.72,100.53) 139.7,100.54 139.45,100.6 arc(139.37,100.62) 139.3,100.65 arc(139.08,100.7) 138.85,100.72 138.51,100.72
PCIE_RC_TXN9: length 106.8
  ART05 w0.114: U1.AT53 130.1,104.44 130.07,104.34 arc(130.21,104.23) 130.38,104.2 130.38,104.2 arc(130.68,104.12) 130.89,103.9 arc(130.89,103.9) 130.89,103.9 arc(131.25,103.7) 131.6,103.9 arc(131.6,103.9) 131.6,103.9 arc(131.82,104.12) 132.11,104.2 132.12,104.2 arc(132.41,104.11) 132.63,103.9 132.63,103.89 arc(132.78,103.75) 132.98,103.7 arc(133.27,103.62) 133.49,103.4 arc(133.49,103.4) 133.49,103.4 133.49,103.39 arc(133.64,103.25) 133.84,103.2 133.85,103.2 arc(134.14,103.11) 134.36,102.9 134.36,102.89 arc(134.71,102.7) 135.06,102.89 135.06,102.9 arc(135.06,102.9) 135.06,102.9 arc(135.28,103.12) 135.57,103.2 135.58,103.2 arc(135.87,103.11) 136.09,102.9 136.09,102.89 arc(136.24,102.75) 136.44,102.7 arc(136.74,102.62) 136.95,102.4 arc(136.95,102.4) 136.96,102.4 136.96,102.39 arc(137.11,102.25) 137.31,102.2 137.31,102.2 arc(137.61,102.11) 137.82,101.9 137.82,101.89 arc(137.97,101.75) 138.17,101.7 138.48,101.7 138.53,101.75
  ART05 w0.135: C604.1 212.76,71.28 212.27,71.28 211.89,70.89 arc(211.62,70.5) 211.53,70.03 211.53,69.8 arc(211.42,69.53) 211.15,69.42 207.97,69.42 arc(207.45,69.31) 207.02,69.02 205.7,67.71 arc(205.34,67.47) 204.93,67.39 200.58,67.39 arc(200.06,67.28) 199.62,66.99 199.4,66.77 arc(199.04,66.53) 198.63,66.45 196.77,66.45 arc(196.35,66.53) 195.99,66.77 192.42,70.34 arc(191.98,70.64) 191.46,70.74 186.95,70.74 arc(186.68,70.79) 186.46,70.94 186.38,71.02 arc(186.07,71.22) 185.71,71.3 181.58,71.3 arc(181.16,71.38) 180.81,71.62 180.76,71.67 arc(180.54,71.99) 180.46,72.37 180.46,73.59 arc(180.36,74.1) 180.07,74.54 175.48,79.13 arc(175.04,79.42) 174.53,79.53 162.92,79.53 arc(161.67,79.77) 160.62,80.48 160.52,80.58 arc(158.08,82.21) 155.21,82.78 155.19,82.78 arc(154.77,82.86) 154.41,83.1 152.87,84.64 arc(152.63,85) 152.55,85.41 152.55,90.75 arc(152.45,91.27) 152.16,91.71 148.25,95.61 arc(148.01,95.97) 147.93,96.39 147.93,96.5 arc(147.82,97.04) 147.51,97.5 143.67,101.34 arc(143.44,101.5) 143.17,101.55 142.3,101.55 142.2,101.65 141.91,101.65 141.8,101.55 141.53,101.55 141.46,101.63 141.11,101.63 141.04,101.55 140.77,101.55 140.68,101.64 140.36,101.64 140.27,101.55 140,101.55 arc(139.78,101.57) 139.57,101.65 arc(139.36,101.72) 139.15,101.75 138.53,101.75
PCIE_RC_TXN10: length 102
  ART05 w0.114: 139.01,103.3 138.99,103.32 138.98,103.32 arc(138.95,103.33) 138.93,103.34 138.85,103.43 arc(138.65,103.58) 138.41,103.67 arc(138.25,103.7) 138.09,103.71 arc(138.04,103.72) 137.99,103.75 arc(137.93,103.79) 137.89,103.84 arc(137.81,103.94) 137.72,104.03 137.71,104.04 arc(137.24,104.21) 136.82,103.93 136.82,103.93 arc(136.47,103.73) 136.12,103.94 136.07,104.02 136.05,104.02 arc(135.87,104.15) 135.65,104.2 135.57,104.2 arc(135.27,104.11) 135.06,103.9 135.03,103.85 arc(134.92,103.74) 134.76,103.7 134.68,103.69 arc(134.48,103.75) 134.34,103.89 arc(134.33,103.9) 134.33,103.9 134.31,103.93 arc(134.11,104.12) 133.84,104.2 arc(133.64,104.25) 133.5,104.39 133.49,104.4 arc(133.49,104.4) 133.49,104.4 133.48,104.42 133.39,104.51 arc(133.21,104.63) 133,104.67 132.95,104.67 arc(132.76,104.72) 132.63,104.86 132.62,104.87 arc(132.56,105.02) 132.58,105.18 132.7,105.26 U1.AR56
  ART05 w0.135: 139.01,103.3 139.18,103.14 arc(139.23,103.09) 139.28,103.04 arc(139.5,102.91) 139.75,102.87 140.02,102.87 140.13,102.98 140.4,102.98 140.52,102.87 140.79,102.87 140.9,102.98 141.17,102.98 141.28,102.87 141.55,102.87 141.67,102.98 141.94,102.98 142.05,102.87 142.32,102.87 142.43,102.98 142.7,102.98 142.82,102.87 143.27,102.87 arc(143.42,102.84) 143.55,102.75 143.85,102.45 144.02,102.45 144.21,102.26 144.21,102.1 148.53,97.77 arc(148.78,97.4) 148.87,96.96 148.87,96.63 arc(148.93,96.29) 149.13,96 153.13,92 arc(153.38,91.63) 153.46,91.19 153.46,85.74 arc(153.53,85.4) 153.72,85.11 154.78,84.05 arc(155.07,83.86) 155.41,83.79 156.67,83.79 arc(156.8,83.78) 156.94,83.75 arc(157.2,83.67) 157.46,83.58 arc(158.34,83.23) 159.18,82.8 arc(159.56,82.59) 159.94,82.38 160.71,81.97 arc(161.02,81.79) 161.32,81.59 arc(162.57,80.94) 163.95,80.72 174.96,80.72 arc(175.4,80.63) 175.77,80.39 182.16,74 arc(182.45,73.8) 182.79,73.74 192.34,73.74 arc(192.77,73.65) 193.14,73.4 195.16,71.38 arc(195.45,71.19) 195.79,71.12 203.85,71.12 arc(204.19,71.19) 204.47,71.38 206.04,72.94 arc(206.41,73.19) 206.85,73.28 211.14,73.28 arc(211.4,73.32) 211.64,73.45 arc(211.8,73.69) 211.86,73.98 211.86,74.64 arc(211.91,74.91) 212.06,75.13 arc(212.22,75.24) 212.41,75.28 212.76,75.28 C606.1
