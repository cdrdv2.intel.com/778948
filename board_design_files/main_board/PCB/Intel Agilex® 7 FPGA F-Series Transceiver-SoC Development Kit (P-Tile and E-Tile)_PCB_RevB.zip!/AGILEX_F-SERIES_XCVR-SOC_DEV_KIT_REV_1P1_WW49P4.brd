# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PG_5V: length 193.6
  TOP w0.109: U23.D2 v2(33.94,166.32)
  ART05 w0.114: v1(181.94,201.47) 181.15,200.69 176.87,200.69 v2(176.7,200.86)
  ART18 w0.089: 46.33,166.75 34.37,166.75 v2(33.94,166.32)
  ART18 w0.114: v2(176.7,200.86) 175.74,200.86 169.93,206.68 169.93,207.39 169.42,207.9 159,207.9 155.11,204.01 152.76,204.01 152.42,204.35 146.67,204.35 139.5,197.18 139.5,192.96 134.52,187.99 134.52,178.21 131.83,175.51 131.83,163.45 130.15,161.77 109.12,161.77 105.16,165.74 99.95,165.74 96.9,162.69 59.44,162.69 57.02,165.1 49.28,165.1 47.62,166.75 46.33,166.75
  BOTTOM w0.109: R2295.2 v2(176.7,200.86)
PG_12V: length 44.3
  TOP w0.109: U23.E4 v2(34.73,167.92)
  TOP w0.254: v2(50.14,188.72) 50.71,189.29 R542.1 50.96,189.11 U51.7
  ART20 w0.114: v2(50.14,188.72) 49.58,188.16 36.68,188.16 35.66,187.15 35.66,185.8 34.24,184.38 32.25,184.38 30.83,182.96 30.83,169.16 32.48,167.51 34.33,167.51 v2(34.73,167.92)
PG_12VIN: length 43.5
  TOP w0.109: U23.C2 v2(33.13,166.32) ; U48.10 33.86,192.26 v2(34.01,192.4)
  BOTTOM w0.109: v2(34.01,192.4) 34.01,192.12 35.53,190.6 35.53,186.37 v2(35.15,185.99) 28.38,185.99 26.54,184.15 26.54,181.48 28.32,179.71 29.21,179.71 29.66,179.25 30.17,179.25 30.48,178.94 30.48,173.51 28.8,171.83 28.8,168.53 28.95,168.38 28.95,166.69 R928.2 29.5,166.31 30.07,165.73 32.55,165.73 v2(33.13,166.32)
PG_FPGA: length 219
  TOP w0.109: U23.U8 v2(45.14,171.12)
  ART03 w0.114: v2(167.89,157.73) 167.89,157.58 167.45,157.14 137.68,157.14 135.05,159.77 118.75,159.77 117.73,160.78 109.35,160.78 104.65,165.48 100.75,165.48 94.27,159 64.52,159 52.22,171.3 49.88,171.3 49.35,171.83 45.85,171.83 v2(45.14,171.12)
  ART20 w0.114: v2(167.47,90.38) 167.47,90.41 167.87,90.8 167.87,92.12 168.09,92.35 168.4,92.35 168.65,92.61 168.65,92.89 168.92,93.15 169.17,93.15 169.49,93.48 169.49,93.75 169.72,93.98 172.57,93.98 172.69,94.11 172.69,94.61 172.87,94.79 175.84,94.79 176.62,95.57 178.1,95.57 178.41,95.88 178.41,96.49 179.8,97.89 179.8,104.36 179.55,104.62 179.55,105.29 177.59,107.24 177.59,119.56 175.7,121.45 175.7,123.23 174.85,124.08 174.85,124.31 174.85,124.31 174.85,124.97 174.51,125.31 173.69,125.31 169.92,129.08 169.92,133.74 169.12,134.54 169.12,139.74 169.39,140.01 169.39,144.27 170.53,145.41 170.53,148.21 168.4,150.34 168.4,157.22 v2(167.89,157.73)
PG_SYSMAX: length 218.9
  TOP w0.109: U23.R5 v2(43.53,168.72)
  ART03 w0.114: v2(170.33,155.68) 169.62,154.96 136.22,154.96 134.47,156.72 133.42,156.72 132.18,157.96 117.75,157.96 116.97,158.75 107.82,158.75 105.16,156.08 100.08,156.08 99.06,157.1 63.88,157.1 53.59,167.39 49.38,167.39 48.84,167.92 47.71,167.92 47.13,168.5 46.74,168.5 46.12,169.11 45.77,169.11 45.54,168.88 45.54,168.45 45.39,168.3 43.96,168.3 v2(43.53,168.72)
  ART20 w0.114: v2(168.27,90.38) 168.28,90.38 168.7,90.8 168.7,92.18 168.91,92.38 169.24,92.38 169.47,92.61 169.47,93.01 169.64,93.19 176.45,93.19 176.7,93.44 176.7,93.88 176.81,93.99 177.23,93.99 177.34,94.11 179,94.11 179.95,95.06 179.95,95.51 180.12,95.68 180.12,96.9 180.22,97 180.22,104.59 179.97,104.85 179.97,105.43 178.03,107.37 178.03,119.63 176.12,121.53 176.12,124.77 175.19,125.71 173.83,125.71 170.29,129.25 170.29,130.01 171.07,130.78 171.07,133.45 169.49,135.03 169.49,138.83 170.91,140.25 170.91,149.61 170.33,150.19 v2(170.33,155.68)
PG_VCC_FPGA_VID: length 145.1
  TOP w0.109: v2(79.83,212.98) 79.2,212.35 79.2,211.45 78.19,210.44 77.77,210.44 77.65,210.56 U54.13 ; v2(33.13,165.52) U23.C1
  ART16 w0.199: v2(33.13,165.52) 33.13,165.09 32.26,164.21 32.26,163.19 30.86,161.8 23.5,161.8 15.37,169.93 15.37,173.86 16.89,175.39 16.89,178.69 19.18,180.97 19.18,182.63 20.7,184.15 27.18,184.15 27.3,184.28 28.19,184.28 30.86,186.94 34.8,186.94 36.7,188.85 40.89,188.85 41.72,188.02 47.82,188.02 48.9,186.94 68.88,186.94 73.63,191.7 73.63,196.27 72.49,197.41 68.5,197.41 65.63,200.27 65.63,209.58 66.31,210.25 66.31,211.39 67.26,212.34 68.93,212.34 71.07,214.48 79.25,214.48 79.83,213.9 v2(79.83,212.98)
  BOTTOM w0.109: v2(79.83,212.98) 80.16,212.98 R1066.1
PG_VCCCLK_GXE_FPGA_2.5V: length 46.9
  TOP w0.109: U23.M2 v2(41.14,166.32)
  TOP w0.254: R5998.2 52.12,136.99 52.55,136.99 v2(52.76,137.2)
  ART03 w0.114: v2(41.14,166.32) 41.14,166.44 41.53,166.83 41.53,167.36 41.68,167.51 44.59,167.51 44.74,167.36 44.74,165.13 45.11,164.77 45.11,160.37 46.02,159.46 46.02,157.1 45.69,156.77 45.69,153.16 46.66,152.2 46.66,150.32 48.32,148.65 49.76,148.65 52.11,146.3 52.11,137.85 v2(52.76,137.2)
  ART05 w0.254: v2(52.76,137.2) 55.98,137.2 56.52,137.74 v2(56.52,139.06)
PG_VCCFUSEWR_SDM_FPGA_2.4V: length 192.1
  TOP w0.109: U23.L8 v2(40.34,171.12) ; v2(61.62,55.19) R6007.2 60.67,55.17 60.67,52.16 U66.C2
  ART07 w0.114: v2(61.62,55.19) 57.58,51.16 52.37,51.16 50.42,49.2 37.49,49.2 34.01,45.72 21.74,45.72 21.31,46.15 17.4,46.15 14.93,48.62 14.93,54.83 26.88,66.79 26.88,119.88 26.58,120.19 26.58,126.09 29.62,129.13 29.62,134.29 30.36,135.03 30.36,142.27 31.98,143.9 31.98,146.52 32.29,146.83 32.96,146.83 34.8,148.66 34.8,150.37 37.16,152.73 37.16,154.81 39.12,156.77 39.12,157.48 40.26,158.62 40.26,160.4 41.53,161.67 41.53,164.34 40.74,165.13 40.74,170.72 v2(40.34,171.12)
PG_VCCH_FPGA_0.9V: length 246.2
  TOP w0.109: v2(33.93,165.52) U23.D1 ; R1129.1 v2(170.66,176.53)
  ART16 w0.114: v4(153.19,181.25) 153.85,180.59 158.57,180.59 158.83,180.34 158.83,179.43 v4(159.54,178.71) 160.15,178.1 163.78,178.1 165.74,176.15 169.62,176.15 170,176.53 v2(170.66,176.53)
  ART20 w0.089: v2(33.93,165.52) 34.33,165.91 34.97,165.91 35.18,166.12 35.18,172.21 35.31,172.34 36.96,172.34 37.48,172.87 37.48,180.36 37.8,180.68 38.18,180.68 39.5,181.99 39.5,182.04
  ART20 w0.114: 39.5,182.04 39.5,182.37 40.01,182.88 41.02,182.88 41.4,183.26 46.99,183.26 48.13,182.12 51.5,182.12 52.27,182.88 66.04,182.88 67.06,181.86 70.23,181.86 72.16,179.93 72.16,169.77 75.95,165.99 83.06,165.99 83.69,166.62 98.93,166.62 99.44,167.13 106.05,167.13 106.56,166.62 129.59,166.62 135.76,160.45 162.23,160.45 162.88,161.1 166.18,161.1 168.58,163.5 168.65,163.5 168.66,163.5 170.97,163.5 174.07,166.6 175.01,166.6 176.83,168.42 176.83,168.73 177.73,169.62 177.73,170.36 181.12,173.76 181.12,178.87 180.52,179.48 173.28,179.48 172.57,178.77 172.57,176.73 172.97,176.33 173.48,176.33 173.48,176.33 173.69,176.33 173.89,176.12 173.89,174.02 173.48,173.6 172.33,173.6 172.09,173.36 170.12,173.36 169.77,173.71 160.81,173.71 160.07,174.45 160.07,178.18 v4(159.54,178.71)
PG_VCCH_GXE_FPGA_1.1V: length 141.5
  TOP w0.109: v2(11.33,45.42) 11.54,45.2 R707.1 ; U23.K1 v2(39.54,165.52)
  ART05 w0.114: v1(8.38,39.5) 9.73,40.84 9.73,43.81 v2(11.33,45.42)
  ART07 w0.114: v2(11.33,45.42) 10.06,46.69 10.06,50.04 11.61,51.59 11.61,52.73 26.27,67.39 26.27,119.63 25.96,119.93 25.96,128.04 28.35,130.43 28.35,134.49 29.74,135.89 29.74,143.49 30.48,144.22 30.48,145.67 31.16,146.35 31.16,146.78 32.21,147.83 32.21,148.85 34.48,151.13 34.48,151.94 36.34,153.8 36.34,157.73 39.54,160.93 v2(39.54,165.52)
PG_VCCIO_FPGA_1.2V: length 209.2
  TOP w0.089: 35.84,165.02 v2(36.33,165.52)
  TOP w0.109: R658.2 35.66,160.97 35.66,164.84 35.84,165.02 ; v2(36.33,165.52) U23.G1
  ART03 w0.254: v2(195.61,153.16) 196.09,153.16 198.02,155.09 208.89,155.09 209.55,155.75 209.55,158.14 208.86,158.83 208.86,163.58 v1(209.5,164.21)
  ART05 w0.114: v2(195.61,153.16) 193.29,153.16 192.79,152.65 187.37,152.65 186.1,151.38 182.63,151.38 181.23,152.78 174.04,152.78 172.13,150.88 164.08,150.88 161.29,153.67 143.51,153.67 139.95,157.23 139.95,157.99 139.57,158.37 138.43,158.37 133.86,162.94 v2(133.86,164.59)
  ART18 w0.114: v2(133.86,164.59) 133.86,162.66 133.51,162.31 132.04,162.31 129.61,159.87 109.71,159.87 104.69,164.88 100.79,164.88 99.93,164.02 99.89,164.02 96.01,160.15 59.82,160.15 56.05,163.92 47.18,163.92 46.17,164.93 37.49,164.93 36.89,165.52 v2(36.33,165.52)
  BOTTOM w0.254: v1(209.5,164.21) v1(209.5,165.48)
PG_VCCIO_FPGA_1.5V: length 178.9
  TOP w0.109: U23.L2 v2(40.34,166.32) ; R725.1 v2(46.11,44.03)
  ART07 w0.114: v2(40.34,166.32) 39.9,165.88 39.9,164.87 40.77,164.01 40.77,163.45 40.39,163.07 40.39,162.56 40.77,162.18 40.77,161.54 39.62,160.4 39.62,159.38 37.72,157.48 37.34,157.48 36.78,156.92 36.78,152.78 34.43,150.43 34.43,148.85 32.71,147.14 32.16,147.14 31.68,146.65 31.68,144.15 30.05,142.52 30.05,135.26 29.34,134.54 29.34,134.44 29.31,134.42 29.31,130.48 26.27,127.44 26.27,120.06 26.58,119.75 26.58,67.02 14.48,54.92 14.48,51.87 13.76,51.15 13.76,46.2 14.15,45.81 14.15,44.88 17.55,41.48 26.52,41.48 26.93,41.89 30.07,41.89 31.56,43.38 32.99,43.38 35.79,46.18 38.18,46.18 40.74,43.61 44.53,43.61 44.93,44.01 46.09,44.01 v2(46.11,44.03) 46.11,43.09 44.55,41.53 44.55,40.11 v1(43.05,38.61)
PG_VCCIO_FPGA_1.8V: length 71.1
  TOP w0.109: U23.K3 v2(39.54,167.12)
  ART20 w0.114: v2(39.54,167.12) 38.78,166.37 38.78,165 37.67,163.88 37.67,162.84 37.75,162.76 37.75,161.37 31.85,155.47 25.25,155.47 22.71,152.93 22.71,143.13 v1(23.39,142.44) 24,141.83 28.68,141.83 29.59,140.92 29.59,132.62 31.39,130.82 31.39,126.54 27.48,122.63 24.1,122.63 23.85,122.38 21.89,122.38 v3(21.54,122.73)
  BOTTOM w0.109: R1019.1 v3(21.54,122.73)
PG_VCCL_HPS_FPGA_0.9V: length 167.3
  TOP w0.109: U23.J1 37.96,166.29 v2(37.93,166.29) ; R687.1 v2(28.61,41.47)
  ART07 w0.114: v1(25.78,36.45) 25.83,36.45 27.64,38.25 28.32,38.25 28.88,38.81 28.88,39.01 29.69,39.83 29.69,41 29.22,41.47 v2(28.61,41.47) 27.88,41.47 26.35,39.94 16.78,39.94 16.64,40.08 14.94,40.08 14.1,40.92 14.1,43.31 13.14,44.26 10.58,44.26 8.81,46.02 8.81,49.81 10.29,51.28 10.29,52.96 25.96,68.63 25.96,119.35 25.65,119.66 25.65,128.27 28.04,130.66 28.04,134.67 29.44,136.07 29.44,146.23 31.08,147.87 31.08,148.38 33.78,151.08 33.78,153.58 34.28,154.08 35.2,154.08 35.86,154.73 35.86,157.99 37.97,160.1 37.97,163.36 37.76,163.57 37.76,163.96 38.48,164.68 38.48,165.75 v2(37.93,166.29)
PG_VCCL_SDM_FPGA_0.8V: length 292.7
  TOP w0.089: U23.K7 v2(39.54,170.32)
  ART03 w0.114: v1(134.34,19.94) 133.53,19.13 130.73,19.13 130.72,19.13 128.68,19.13 127.94,18.39 127.94,14.43 127.38,13.87 117.57,13.87 114.65,10.95 103.71,10.95 101.52,13.13 98.8,13.13 98.79,13.14 94.25,13.14 93.5,13.89 93.5,14.22 92.15,15.57 84.25,15.57 83.69,15.01 77.6,15.01 75.95,16.66 75.95,35.71 82.42,42.19 82.42,43.36 81.71,44.07 79.81,44.07 79.26,44.61 78.93,44.61 74.64,48.9 74.64,49.01 73.95,49.7 73.4,49.7 73.13,49.97 73.13,50.58 73.53,50.97 73.83,50.97 74.06,51.2 74.06,61.19 71.3,63.96 71.3,68.5 68.48,71.32 63.93,71.32 62.28,72.97 62.28,75.95 58.57,79.65 48.51,79.65 46.17,81.99 32.41,81.99 27.77,86.63 27.77,119.26 29.31,120.8 29.31,124.05 30.91,125.65 30.91,134.69 33.31,137.09 37.47,137.09 43.91,143.54 43.91,144.65 44.17,144.91 44.17,147.98 42.69,149.45 42.69,153.01 43.33,153.64 43.33,154 40.99,156.34 40.99,158.24 41.31,158.56 41.31,159.95 39.53,161.73 39.53,163.97 39.09,164.41 39.09,169.87 v2(39.54,170.32)
  ART05 w0.089: v2(39.54,170.32) 39.09,170.77 39.09,171.35 39.27,171.53 40.49,171.53 40.69,171.32 40.69,171.04 41.02,170.71 43.69,170.71 43.99,170.41 43.99,170.07 44.18,169.87 46.33,169.87
  ART05 w0.114: 46.33,169.87 47.22,169.87 49.06,168.03 v2(49.48,168.03)
  BOTTOM w0.109: R697.1 49.61,167.89 v2(49.48,168.03)
PG_VCCPT_FPGA_1.8V: length 245.5
  TOP w0.109: U23.F2 v2(35.54,166.32)
  ART03 w0.114: v1(200.15,129.57) 200.84,128.88 206.57,128.88 206.98,128.47 206.98,127.51 v1(206.5,127.03)
  ART07 w0.114: v2(131.93,162.84) 134.24,160.53 136.27,160.53 138.3,158.5 147.07,158.5 148.49,157.08 158.43,157.08 163.95,151.56 171.37,151.56 172.59,152.78 176.31,152.78 177.58,151.51 187.83,151.51 188.57,150.78 188.57,148.72 180.72,140.87 180.72,134.24 182.37,132.59 182.37,128.95 183.56,127.76 186.74,127.76 187.86,126.64 v2(189.08,126.64)
  ART16 w0.114: v1(200.15,129.57) 200.15,129.26 200.53,128.88 202.84,128.88 203.43,128.29 203.43,123.3 202.88,122.74 202.88,118.91 202.4,118.44 196.8,118.44 195.53,119.71 195.53,120.65 193.56,122.62 193.33,122.62 191.87,124.09 191.87,125.14 190.67,126.34 189.38,126.34 v2(189.08,126.64)
  ART18 w0.114: v2(35.54,166.32) 35.95,165.92 45.54,165.92 46.1,165.35 46.86,165.35 47.12,165.61 47.88,165.61 49.15,164.34 56.26,164.34 59.82,160.78 95.76,160.78 100.2,165.23 105.03,165.23 108.79,161.47 130.55,161.47 v2(131.93,162.84)
  BOTTOM w0.089: v2(35.54,166.32) 35.9,165.96 36.57,165.96 36.78,165.76 36.78,165.02
  BOTTOM w0.109: R636.1 36.78,163.05 36.78,165.02
PG_VDD_SODIMM: length 212.7
  TOP w0.089: U23.T3 v2(44.34,167.12)
  ART03 w0.114: v1(109.6,19.94) 108.99,20.55 102.57,20.55 101.6,21.51 99.87,21.51 98.4,22.99 98.4,28.47 92.84,34.04 90.36,34.04 89.56,34.83 89.56,37.34 88.97,37.92 88.97,46.41 85.6,49.78 85.6,58.47 84.4,59.67 84.4,65.46 81.69,68.17 77.73,68.17 74.27,71.63 74.27,74.86 71.68,77.44 62.81,77.44 58.77,81.48 52.83,81.48 51.74,82.57 51.74,86.54 49.96,88.31 49.96,98.4 49.3,99.06 49.3,101.07 47.7,102.67 43.81,102.67 33.4,113.08 33.4,114.99 33.37,115.02 33.37,115.36 33.66,115.64 33.66,130.99 33.45,131.2 33.45,135.12 34.19,135.86 37.98,135.86 44.25,142.14 45.54,142.14 47.09,143.69 47.09,147.57 47.6,148.08 47.6,148.72 45.95,150.37 45.95,151.64 45.29,152.3 45.29,156.95 45.64,157.3 45.64,159.21 44.68,160.17 44.68,164.54 43.94,165.27 43.94,166.73 v2(44.34,167.12)
  BOTTOM w0.089: 46.33,167.49 44.7,167.49 v2(44.34,167.12)
  BOTTOM w0.109: R757.1 46.59,167.49 46.33,167.49
PG_VTT_DDR4_0.6V: length 134.3
  TOP w0.109: v2(42.74,165.52) U23.P1
  TOP w0.254: U69.9 141.98,141.59 v2(142.34,141.22)
  ART03 w0.114: v2(142.34,141.22) 142.91,140.65 v3(145.29,140.65) 148.72,144.08 148.72,152.3 147.21,153.81 132.47,153.81 132.31,153.97 132.31,155.57 131.47,156.41 129.17,156.41 v2(128.78,156.8)
  ART20 w0.114: v2(128.78,156.8) 118.49,156.8 116.88,155.19 107.95,155.19 107.5,154.74 106.11,154.74 105.52,154.15 101.37,154.15 100.89,154.63 99.03,154.63 99.03,154.64 98.33,154.64 96.8,156.16 65.96,156.16 56.11,166.01 53.01,166.01 51.89,167.13 49.12,167.13 47.6,165.61 47.13,165.61 46.88,165.35 45.95,165.35 45.39,165.91 43.08,165.91 42.74,165.57 v2(42.74,165.52)
PG_VTT_SODIMM_0.6V: length 179.7
  TOP w0.127: U23.N3 v2(41.94,167.11)
  TOP w0.254: v2(75.39,49.96) 75.39,50.06 75.7,50.38 U67.9
  TOP w0.381: R745.2 v3(74.49,46.74)
  ART07 w0.114: v2(41.94,167.11) 42.34,166.71 44.63,166.71 44.75,166.59 44.75,161.31 45.97,160.1 45.97,158.19 45.46,157.68 45.46,156.87 45.06,156.46 45.06,151.94 44.35,151.23 44.35,147.62 43.84,147.12 43.84,144.17 43.44,143.77 41.78,143.77 41.51,144.04 41.51,144.97 40.91,145.57 40.52,145.57 40.21,145.26 40.21,144.04 42.14,142.11 42.14,130.76 40.71,129.33 33.5,129.33 28.96,124.79 28.96,109.94 32.21,106.68 32.21,80.01 33.32,78.9 33.32,70.81 40.89,63.25 45.97,63.25 46.74,62.48 46.74,61.46 48.76,59.44 62.64,59.44 71.44,50.63 74.68,50.63 74.97,50.33 74.97,49.79 75.29,49.48 75.29,47.54 v3(74.49,46.74)
  BOTTOM w0.254: v3(74.49,46.74) 75.39,47.64 v2(75.39,49.96)
PHY_SCL: length 29.3
  TOP w0.109: U23.G11 v2(36.33,174.32)
  ART03 w0.114: v2(36.33,174.32) 36.73,174.72 36.73,176.97 36.56,177.14 34.52,177.14 34.33,177.33 34.33,177.76 34.16,177.93 33.73,177.93 33.55,178.1 33.55,178.51 33.35,178.71 31.98,178.71 30.35,177.09 30.35,176.03 30.19,175.86 30.19,173.21 26.49,169.52 21.44,169.52 21.03,169.12 v3(18.82,169.12)
  BOTTOM w0.109: R292.2 v3(18.82,169.12)
PHY_SDA: length 18.9
  TOP w0.109: U23.B18 v2(32.33,179.92)
  ART03 w0.114: v3(20.85,169.81) 20.85,169.82 20.97,169.94 26.32,169.94 29.25,172.87 29.25,174 29.25,174.01 29.25,177.02 29.54,177.31 29.94,177.31 32.11,179.48 32.22,179.48 32.33,179.59 v2(32.33,179.92)
PMBUS_VID_EN: length 52.5
  TOP w0.254: U43.5 181.66,126.24 181.72,126.17 R851.1 R499.1 184.06,126.17 184.76,125.48 v2(184.76,125.35)
  ART16 w0.114: v2(184.76,125.35) 182.22,125.35 181.58,125.98 178.15,125.98 174.72,122.55 173.58,122.55 172.88,123.25 171.51,123.25 170.81,122.55 170.81,120.62 174.09,117.35 174.09,109.47 177.26,106.3 177.26,101.85 176.66,101.25 176.66,95.38 176.27,94.99 v2(176.27,93.58)
PWRMAX_DEBUGMDN: length 24.3
  TOP w0.109: U23.R1 v2(43.53,165.52)
  BOTTOM w0.089: v2(43.53,165.52) 43.47,165.47 43.47,165.02
  BOTTOM w0.109: J18.2 28.98,157.35 29.17,157.16 R309.2 30.44,157.16 31.4,156.21 33.69,156.21 R922.2 34.26,155.76 34.26,156.46 38.55,160.76 41.98,160.76 43.47,162.24 43.47,165.02
PWRMAX_LED_G0: length 199.1
  TOP w0.109: U23.D7 v2(33.94,170.32)
  ART16 w0.114: v2(33.94,170.32) 33.74,170.32 33.55,170.51 33.53,170.51 33.53,170.51 33.17,170.51 30.71,172.97 30.71,180.82 32.64,182.75 39.88,182.75 40.26,183.13 46.61,183.13 47.75,181.99 55.75,181.99 56.52,182.75 67.82,182.75 70.46,180.11 70.46,175.84 70.99,175.31 70.99,169.38 82.26,158.12 94.14,158.12 101.23,165.2 105.93,165.2 109.59,161.54 129.92,161.54 131.7,163.32 131.7,164.62 133.65,166.57 135.94,166.57 137.16,167.8 137.16,186.77 145.62,195.22 145.62,202.16 147.57,204.12 147.57,209.8 148.4,210.63 153.8,210.63 v2(154.69,211.52)
PWRMAX_LED_G1: length 202.2
  TOP w0.109: D20.1 156.65,210.44 155.96,210.44 v2(155.83,210.31) ; U23.D8 v2(33.94,171.12)
  ART16 w0.114: v2(33.94,171.12) 33.56,171.5 32.87,171.5 31.09,173.28 31.09,180.69 32.77,182.37 39.37,182.37 39.88,181.86 44.32,181.86 44.83,182.37 46.74,182.37 47.62,181.48 55.88,181.48 56.77,182.37 67.69,182.37 69.8,180.26 69.8,170.04 76.03,163.8 76.12,163.8 82.13,157.8 94.27,157.8 101.27,164.8 105.89,164.8 110.59,160.1 129.77,160.1 132.34,162.67 132.34,164.72 133.83,166.22 136.12,166.22 137.54,167.64 137.54,186.58 145.92,194.96 145.92,195.08 145.94,195.09 145.94,201.89 146,201.95 146,202.01 147.96,203.96 147.96,209.55 148.72,210.31 v2(155.83,210.31)
PWRMAX_LED_R0: length 208.2
  TOP w0.109: U23.B5 v2(32.33,168.72)
  ART16 w0.114: v2(148.56,211.48) 147.45,212.6 142.49,212.6 141.45,211.56 141.45,204.8 143.26,203 143.26,202.18 142.37,201.29 142.37,196.98 140.78,195.39 140.78,192.72 135.64,187.58 135.64,168.78 134.96,168.11 132.68,168.11 130.18,165.61 130.18,164.83 130.06,164.72 108.71,164.72 106.97,166.46 100.33,166.46 93.51,159.64 82.89,159.64 77.72,164.81 77.72,183.26 76.33,184.66 55.75,184.66 54.74,183.64 48.77,183.64 46.86,185.55 40.39,185.55 39.5,186.44 38.23,186.44 36.07,184.28 31.09,184.28 27.86,181.05 27.86,173.34 30.06,171.14 30.06,171.06 30.07,171.04 30.07,170.43 31.78,168.72 v2(32.33,168.72)
PWRMAX_LED_R1: length 211.3
  TOP w0.109: D24.1 151.64,210.46 151.53,210.35 v2(146.39,210.35) ; U23.C6 v2(33.13,169.52)
  ART16 w0.114: v2(33.13,169.52) 32.75,169.14 32.09,169.14 30.5,170.73 30.5,171.17 28.18,173.49 28.18,180.83 31.24,183.9 38.73,183.9 39.75,184.91 46.86,184.91 48.51,183.26 54.86,183.26 55.75,184.15 71.88,184.15 74.09,181.94 74.09,176.86 77.22,173.74 77.22,164.78 82.73,159.26 93.67,159.26 100.55,166.14 106.6,166.14 110.06,162.69 129.54,162.69 130.56,163.7 130.56,165.48 132.79,167.72 135.46,167.72 136,168.25 136,187.18 141.81,193 141.81,194.16 144.22,196.57 144.22,206.51 143.94,206.79 143.94,209.96 142.72,211.18 142.72,211.88 143.1,212.27 145.87,212.27 146.39,211.75 v2(146.39,210.35)
PWRMAX_PB0: length 189.3
  TOP w0.109: U23.B8 v2(33.13,171.92)
  ART20 w0.114: v2(33.13,171.92) 33.13,174.86 31.97,176.02 31.97,177.37 31.97,177.37 31.97,178.17 31.93,178.22 31.93,181.91 33.15,183.13 37.08,183.13 37.72,183.77 38.35,183.77 40.89,186.31 46.23,186.31 48.26,184.28 51.44,184.28 51.56,184.4 66.55,184.4 67.69,185.55 76.45,185.55 78.99,183.01 78.99,170.31 81.15,168.15 98.3,168.15 98.81,168.66 106.68,168.66 107.19,168.15 130.81,168.15 133.65,165.31 135.81,165.31 136.96,164.16 138.48,164.16 140.66,161.98 161.6,161.98 162.31,162.69 164.13,162.69 166.85,165.41 166.85,167.36 168.17,168.68 173.18,168.68 174.09,169.6 174.09,171.07 180.31,177.29 v3(180.31,177.93)
  BOTTOM w0.109: R359.1 v3(180.31,177.93)
PWRMAX_PORSTN: length 15.3
  TOP w0.109: U28.2 28.43,168.61 28.83,168.21 R358.1 v3(29.47,169.01) ; U23.H12 v2(37.13,175.12)
  ART05 w0.114: v3(29.47,169.01) 29.47,170.01 30.96,171.5 34.11,171.5 34.31,171.71 34.31,172.19 34.52,172.39 36.22,172.39 36.73,172.9 36.73,174.71 v2(37.13,175.12)
PWRMAX_SW0: length 207.5
  TOP w0.109: v3(178.69,184.15) 178.36,183.82 177.88,183.82 177.47,183.41 SW4.1 ; U23.D9 v2(33.94,171.92)
  ART05 w0.114: v3(178.69,184.15) 179.25,184.71 179.25,191.47 175.64,195.07 171.58,195.07 170.31,196.34 167.51,196.34 167,196.85 141.99,196.85 140.96,195.81 140.96,195.26 139.42,193.73 139.42,190.12 135.94,186.64 135.94,177.61 134.35,176.02 80.14,176.02 76.45,179.71 76.45,183.13 75.95,183.64 48.56,183.64 44.07,188.13 34.55,188.13 34.23,187.81 34.23,187.29 33.57,186.63 29.94,186.63 28.14,184.83 28.14,181.36 27.3,180.52 27.3,179.45 27.33,179.42 27.33,173.43 28.42,172.34 33.53,172.34 v2(33.94,171.92)
PWRMAX_SW1: length 207.5
  TOP w0.109: U23.D10 v2(33.94,173.52)
  ART05 w0.114: v2(33.94,173.52) 33.14,172.72 28.55,172.72 27.65,173.61 27.65,180.3 27.66,180.31 27.66,180.45 28.45,181.23 28.45,184.63 30.14,186.33 33.79,186.33 34.52,187.05 35.89,187.05 36.62,187.78 43.89,187.78 48.4,183.27 72.12,183.27 75.06,180.34 75.06,176.46 75.36,176.15 77.85,176.15 80.64,173.35 134.19,173.35 136.32,175.49 136.32,186.26 139.81,189.75 139.81,193.56 141.27,195.01 141.27,195.69 142.05,196.47 166.62,196.47 167.13,195.96 170.18,195.96 171.58,194.56 175.13,194.56 177.93,191.77 177.93,183.76 v3(178.74,182.95)
PWRMAX_SW2: length 204.9
  TOP w0.109: U23.A10 v2(31.53,173.52)
  ART05 w0.114: v2(31.53,173.52) 31.11,173.1 28.67,173.1 27.96,173.81 27.96,180.17 27.97,180.19 27.97,180.32 28.75,181.1 28.75,184.46 30.32,186.02 33.92,186.02 34.64,186.74 36.22,186.74 36.85,187.37 43.74,187.37 48.23,182.88 70.28,182.88 74.68,178.49 74.68,176.15 75.06,175.77 77.72,175.77 80.52,172.97 134.75,172.97 136.73,174.96 136.73,186.03 140.27,189.57 140.27,193.51 141.57,194.81 141.57,195.56 142.1,196.09 165.99,196.09 167.13,194.94 170.31,194.94 171.2,194.06 174.88,194.06 176.53,192.41 176.53,189.48 177.29,188.72 177.29,183.39 178.31,182.37 179.56,182.37 v3(180.01,182.82)
PWRMAX_SW3: length 204.7
  TOP w0.109: U23.A11 31.62,174.23 v2(31.62,174.32)
  ART05 w0.114: v3(181.28,182.88) 180.26,181.86 177.8,181.86 176.78,182.88 176.78,188.59 176.02,189.36 176.02,191.64 174.12,193.55 171.07,193.55 170.05,194.56 164.03,194.56 163.42,195.17 161.04,195.17 160.68,194.82 159.51,194.82 158.95,195.38 157.02,195.38 156.21,194.56 141.76,194.56 140.61,193.42 140.61,189.18 137.11,185.67 137.11,174.32 135.38,172.59 80.26,172.59 77.47,175.39 74.93,175.39 72.8,177.52 72.8,179.43 69.72,182.5 48,182.5 43.46,187.04 38.55,187.04 37.95,186.44 34.77,186.44 33.88,185.54 33.38,185.54 32.66,184.83 32.16,184.83 31.42,185.57 30.35,185.57 29.06,184.28 29.06,180.97 28.28,180.19 28.28,174.49 28.44,174.32 29.52,174.32 29.52,174.31 29.91,174.31 29.92,174.32 v2(31.62,174.32)
PWRMAX_SW4: length 174.5
  TOP w0.089: U23.G10 v2(36.34,173.51)
  ART20 w0.114: v3(175.36,169.54) 173.88,168.07 168.5,168.07 167.47,167.04 167.47,165.16 164.26,161.96 162.65,161.96 161.91,161.22 136.57,161.22 135.38,162.41 135.38,162.64 134.21,163.8 133.65,163.8 130.07,167.39 106.87,167.39 106.36,167.89 99.12,167.89 98.61,167.39 80.84,167.39 78.23,169.99 78.23,182.69 76.14,184.78 68.07,184.78 66.93,183.64 51.94,183.64 51.18,182.88 48.51,182.88 47.62,183.77 45.85,185.55 41.15,185.55 38.42,182.82 38.04,182.82 37.37,182.15 37.37,181.27 36.83,180.72 36.32,180.72 35.13,179.52 35.13,174.78 36.34,173.56 v2(36.34,173.51)
PWRMAX_SW5: length 178.2
  TOP w0.109: U23.F10 v2(35.55,173.5)
  ART20 w0.114: v3(176.63,169.67) 176.25,170.05 175.01,170.05 173.33,168.37 168.3,168.37 167.16,167.23 167.16,165.29 164.23,162.35 162.51,162.35 161.75,161.6 140.56,161.6 138.53,163.63 137.06,163.63 135.68,165 133.32,165 130.56,167.77 107.03,167.77 106.52,168.28 98.96,168.28 98.46,167.77 81,167.77 78.61,170.15 78.61,182.85 76.3,185.17 67.94,185.17 66.8,184.02 51.69,184.02 50.93,183.26 48.64,183.26 47.75,184.15 45.97,185.93 41.02,185.93 38.42,183.32 37.91,183.32 37.21,182.63 34.92,182.63 34.71,182.41 34.71,181.39 34.34,181.03 34.34,174.03 34.46,173.91 35.14,173.91 v2(35.55,173.5)
PWRMAX_TCK: length 37.2
  TOP w0.109: U23.J8 v2(37.93,171.12)
  ART18 w0.114: v2(37.93,171.12) 37.53,170.71 37.53,170.04 37.41,169.93 35.35,169.93 35.1,169.67 35.1,169.37 34.88,169.16 34.74,169.16 34.71,169.13 33.83,169.13 33.79,169.08 32.98,169.08 32.98,169.08 32.91,169.08 32.77,168.94 32.77,168.5 32.47,168.2 32.46,168 32.34,167.89 32.08,167.89 31.71,167.53 31.37,167.53 31.11,167.27 31.11,166.93 30.9,166.72 29.2,166.72 28.95,166.46 28.95,166.06 28.64,165.75 28.64,165.37 27.25,163.98 17.55,163.98 16.18,162.61 16.18,159.18 v3(16.76,158.6)
  BOTTOM w0.109: J18.1 19.4,157.35 18.83,157.92 R304.1 R310.1 v3(16.76,158.6)
PWRMAX_TDI: length 25
  TOP w0.109: U23.H3 v2(37.13,167.12)
  ART20 w0.114: v2(37.13,167.12) 37.13,165.33 35.51,163.71 32.96,163.71 32.77,163.9 28.07,163.9 24.58,167.39 v2(23.32,167.39)
  BOTTOM w0.109: R312.1 R305.1 18.1,167.51 J18.9 23.11,167.51 23.24,167.39 v2(23.32,167.39)
PWRMAX_TDO: length 26.7
  TOP w0.109: U23.H4 v2(37.13,167.92)
  ART18 w0.114: v2(37.13,167.92) 36.75,167.54 33.81,167.54 33.53,167.26 33.53,166.99 33.27,166.73 32.17,166.73 31.9,166.47 31.9,166.08 31.68,165.86 31.16,165.86 30.09,164.79 29,164.79 28.99,164.78 28.92,164.78 27.25,163.12 21.07,163.12 v3(18.03,160.08)
  BOTTOM w0.109: J18.3 20.8,159.89 20.61,160.08 v3(18.03,160.08)
PWRMAX_TMS: length 32.4
  TOP w0.109: U23.J7 v2(37.93,170.32)
  ART18 w0.114: v2(37.93,170.32) 38.45,169.8 38.45,169.26 38.33,169.14 35.89,169.14 35.84,169.09 35.39,169.09 35.39,169.08 35.29,169.08 35.18,168.97 35.18,168.88 35.18,168.87 35.18,168.44 35.06,168.33 33.75,168.33 33.53,168.1 33.53,167.72 33.37,167.56 32.18,167.56 31.92,167.29 31.92,166.91 31.68,166.68 31.38,166.68 31.38,166.68 31.32,166.68 31.06,166.42 31.06,166.29 30.25,165.48 29.92,165.48 29.53,165.87 29.19,165.87 28.95,165.63 28.95,165.25 27.25,163.55 17.82,163.55 v3(16.76,162.5)
  BOTTOM w0.109: v3(16.76,162.5) R303.1 18.1,162.43 21.4,162.43
QSFP_I2C_SCL: length 50.4
  TOP w0.109: v2(57.57,90.42) 57.25,90.42 57,90.17 U14.A3
  ART03 w0.114: v2(57.57,90.42) 58.07,90.93 58.7,90.93 61.91,94.15 65.87,94.15 66.24,93.78 66.24,92.47 67.39,91.33 67.39,90.09 68.73,88.75 68.73,87.44 67.78,86.49 67.78,83.24 68.47,82.55 76.43,82.55 79.35,79.63 89.05,79.63 90.14,80.72 90.14,82.2 v2(90.54,82.6)
QSFP_I2C_SDA: length 53.6
  TOP w0.109: U14.A4 57.3,89.67 v2(57.57,89.41)
  ART03 w0.114: v2(57.57,89.41) 58.07,89.92 58.88,89.92 59.47,90.51 59.47,90.94 61.4,92.88 62.69,92.88 63.35,92.21 65.8,92.21 66.94,91.07 66.94,89.33 67.36,88.91 67.36,82.98 68.3,82.04 76.25,82.04 79.19,79.09 90.55,79.09 92.68,81.23 92.68,84.64 v2(93.14,85.1)
QSFP_INITMODE: length 60.5
  TOP w0.109: U14.A1 56.26,91.44 v2(57.57,91.44)
  ART03 w0.114: v2(57.57,91.44) 56.9,90.77 56.9,89.38 57.38,88.9 58.93,88.9 60.11,90.08 64.54,90.08 65.66,91.2 66.17,91.2 66.51,90.86 66.51,88.7 66.12,88.3 66.12,87.64 66.94,86.82 66.94,82.58 67.93,81.58 76.05,81.58 79.1,78.54 91.41,78.54 94.03,81.15 94.03,84.99 93.39,85.62 92.92,85.62 92.4,85.1 v2(91.41,85.1)
QSFP_INTN: length 35
  TOP w0.109: v2(68.62,89.53) 68.48,89.67 U13.A4
  ART03 w0.114: v2(68.62,89.53) 67.83,90.32 67.83,91.62 68.08,91.87 68.08,92.88 68.4,93.21 69.77,93.21 71.15,91.83 74.26,91.83 75.41,90.68 83.86,90.68 84.46,90.07 85.6,90.07 85.99,89.69 86.22,89.69 86.78,89.13 87.29,89.13 87.76,88.66 88.02,88.66 88.56,88.13 89.07,88.13 89.5,87.69 89.76,87.69 90.3,87.16 90.65,87.16 91.01,86.8 91.01,84.36 90.54,83.89 v2(90.54,83.6)
QSFP_IO_TSN: length 253.6
  ART03 w0.114: v2(66.04,90.14) 65.43,89.54 65.43,87.86 64.62,87.05 64.62,85.13 64.96,84.79 66.22,84.79 66.55,84.45 66.55,82.28 67.78,81.05 75.18,81.05 79.62,76.62 81.14,76.62 90.22,67.54 90.22,59.8 91.33,58.69 91.33,56.5 92.48,55.35 92.48,54.49 93.09,53.88 93.09,50.67 94.23,49.53 95.96,49.53 103.81,41.68 126.92,41.68 128.24,40.36 186.84,40.36 189.41,42.93 189.41,47.93 190.8,49.33 190.8,63.27 191.5,63.97 191.5,69.2 189.41,71.3 v2(189.41,72.54)
  ART16 w0.114: v2(66.04,90.14) 65.52,89.63 65.52,88.04 65.19,87.71 57.93,87.71 v2(55.5,90.14)
  BOTTOM w0.109: R842.1 R228.1 66.75,89.43 v2(66.04,90.14)
  BOTTOM w0.114: v2(189.41,72.54) 186.23,72.54 182.44,76.33 169.67,76.33 163.32,82.68 163.32,85.09 162.05,86.36 162.05,87.5 162.47,87.92 162.72,87.92 164.01,89.2 164.44,89.2 164.69,89.46 164.69,96.36 v2(164.27,96.78)
QSFP_MODPRSN: length 28.1
  TOP w0.109: U13.A3 68.11,90.17 v2(68.62,90.68)
  ART03 w0.114: v2(68.62,90.68) 69.12,91.19 69.89,91.19 71.46,89.61 74.5,89.61 76,88.11 78.99,88.11 79.45,88.57 83.95,88.57 84.4,88.11 85.64,88.11 86.13,87.62 86.26,87.62 86.75,87.12 87.24,87.12 87.69,86.66 88.01,86.66 88.58,86.09 88.96,86.09 89.27,85.79 89.27,84.85 89.51,84.61 90.54,84.61 v2(90.54,84.6)
QSFP_MODSELN: length 28.8
  TOP w0.109: v2(68.62,92.71) 67.08,91.17 U13.A1
  ART03 w0.114: v2(89.68,85.1) 89.68,85.26 90.09,85.67 90.09,86.39 89.85,86.63 89.45,86.63 88.96,87.11 88.61,87.11 88.02,87.69 87.72,87.69 87.27,88.14 86.82,88.14 86.35,88.61 86.08,88.61 85.6,89.08 84.79,89.08 83.68,90.2 78.49,90.2 77.84,89.55 75.48,89.55 74.88,90.14 71.82,90.14 69.76,92.2 69.12,92.2 v2(68.62,92.71)
QSFP_RESETN: length 28.6
  TOP w0.109: v2(68.62,91.69) 67.6,90.67 U13.A2
  ART03 w0.114: v2(89.68,84.1) 88.64,84.1 88.39,84.35 88.39,85.39 88.21,85.57 87.68,85.57 87.1,86.16 86.77,86.16 86.28,86.64 86.06,86.64 85.6,87.1 84.75,87.1 84.33,87.52 75.51,87.52 74.84,88.19 72.03,88.19 70.13,90.09 68.58,90.09 68.2,90.47 68.2,91.28 v2(68.62,91.69)
QSFPDD_I2C_SCL: length 33.2
  TOP w0.109: v2(57.57,83.95) 57.32,83.7 U11.A3
  ART18 w0.114: v2(85.35,84.6) 84.48,83.73 79.16,83.73 75.21,79.78 62.57,79.78 58.93,83.43 58.09,83.43 v2(57.57,83.95)
QSFPDD_I2C_SDA: length 36.5
  TOP w0.109: v2(57.57,82.93) 57.3,83.2 U11.A4
  ART18 w0.114: v2(57.57,82.93) 61.13,79.36 75.62,79.36 79.37,83.12 85.56,83.12 85.98,82.7 86.56,82.7 86.92,83.06 87.42,83.06 87.88,82.6 v2(88.81,82.6)
QSFPDD_INITMODE: length 37.6
  TOP w0.109: v2(57.57,85.09) 57.17,84.7 U11.A1
  ART18 w0.114: v2(57.57,85.09) 58.11,84.54 58.69,84.54 62.98,80.25 74.96,80.25 79.46,84.76 84.79,84.76 85.14,85.12 85.49,85.12 85.93,84.68 86.44,84.68 86.86,85.1 87.21,85.1 87.71,84.6 v2(88.81,84.6)
QSFPDD_INTN: length 23.6
  TOP w0.109: U10.A4 68.5,83.2 v2(68.64,83.06)
  ART03 w0.114: v2(87.95,84.1) 87.95,83.83 87.17,83.06 86.81,83.06 86.38,82.63 86.05,82.63 85.62,82.19 84.73,82.19 84.15,81.61 79.37,81.61 77.45,83.53 69.11,83.53 v2(68.64,83.06)
QSFPDD_IO_TSN: length 250.2
  ART03 w0.114: v2(190.22,72.52) 191.06,71.67 191.06,70.18 192,69.24 192,60.33 191.67,59.99 191.67,56.29 192.99,54.97 192.99,53.44 191.67,52.12 191.67,44.55 187.1,39.98 127.99,39.98 126.67,41.3 103.53,41.3 95.68,49.15 93.98,49.15 92.16,50.97 92.16,52.24 91.57,52.83 91.57,54.99 90.8,55.76 90.8,58.16 89.67,59.28 89.67,67.14 80.75,76.07 79.07,76.07 74.52,80.62 67.21,80.62 66.42,81.41 65.33,81.41 65.04,81.7 65.04,82.64 v2(66.06,83.67)
  ART16 w0.114: v2(66.06,83.67) 64.4,83.67 61.58,86.49 57.58,86.49 56.08,84.99 56.08,83.95 55.78,83.64 v2(55.5,83.64)
  BOTTOM w0.109: R841.1 R189.1 66.52,82.05 66.52,83.21 v2(66.06,83.67)
  BOTTOM w0.114: v2(164.27,95.98) 163.83,95.54 163.83,89.58 163.42,89.18 162.46,89.18 161.67,88.39 161.67,86.23 162.94,84.96 162.94,82.47 169.46,75.95 182.24,75.95 186.18,72.01 189.71,72.01 v2(190.22,72.52)
QSFPDD_MODPRSN: length 23.1
  TOP w0.109: v2(68.64,84.07) 68.27,83.7 U10.A3
  ART03 w0.114: v2(87.08,84.6) 86.06,84.6 85.57,85.09 79.32,85.09 78.81,85.6 68.46,85.6 68.21,85.34 68.21,84.51 v2(68.64,84.07)
QSFPDD_MODSELN: length 23.4
  TOP w0.109: U10.A1 67.23,84.7 v2(68.64,86.11)
  ART03 w0.114: v2(68.64,86.11) 69.89,87.35 74.9,87.35 75.84,86.41 84.86,86.41 85.24,86.03 85.65,86.03 86.15,85.52 86.48,85.52 86.91,85.1 v2(87.95,85.1)
QSFPDD_RESETN: length 21.9
  TOP w0.109: v2(68.64,85.09) 67.75,84.2 U10.A2
  ART03 w0.114: v2(87.08,83.6) 86.01,83.6 85.52,83.11 80.21,83.11 78.74,84.58 69.15,84.58 v2(68.64,85.09)
QSFPDD_RXN0: length 66.8
  TOP w0.091: U12.18 48.92,62.74
  ART07 w0.097: U1.BE8 91.12,99.93 91.09,99.82 arc(91.1,99.82) 91.1,99.81 arc(91.13,99.55) 91.06,99.3 arc(90.84,99.09) 90.55,99.01 90.53,99.01 arc(90.34,98.96) 90.2,98.82 90.19,98.8 arc(90.14,98.6) 90.19,98.4 90.19,98.4 arc(90.27,98.1) 90.19,97.8 arc(90.14,97.6) 90.19,97.4 arc(90.27,97.1) 90.19,96.8 arc(90.14,96.6) 90.19,96.4 arc(90.27,96.1) 90.19,95.8 arc(90.14,95.6) 90.19,95.4 arc(90.27,95.1) 90.19,94.81 90.19,94.8 arc(90.14,94.6) 90.19,94.4 arc(90.27,94.1) 90.19,93.8 arc(90.14,93.6) 90.19,93.4 arc(90.27,93.1) 90.19,92.8 arc(90.19,92.8) 90.19,92.8 arc(89.99,92.6) 89.73,92.51 arc(89.49,92.43) 89.3,92.26 arc(89.12,92.09) 88.9,92.01 arc(88.85,92) 88.8,91.99 arc(88.63,91.91) 88.48,91.8 arc(88.44,91.77) 88.41,91.73 arc(88.23,91.58) 88,91.51 arc(87.77,91.44) 87.59,91.29 arc(87.37,91.11) 87.1,91.01 arc(86.88,90.93) 86.7,90.76 arc(86.49,90.57) 86.22,90.51 86.21,90.51 arc(86.01,90.45) 85.86,90.31 85.86,90.3 85.83,90.27 arc(85.62,90.1) 85.35,90.01 arc(85.35,90.01) 85.35,90.01 85.17,90.01 arc(85.15,90) 85.13,89.99 85.12,89.98 85.1,89.98
  ART07 w0.109: 48.92,62.74 49.2,63.03 49.38,63.03 arc(49.75,63.18) 49.91,63.56 49.91,65.48 arc(50.04,66.14) 50.41,66.69 50.81,67.09 arc(51.63,67.64) 52.61,67.84 57.47,67.84 arc(58.39,68.02) 59.17,68.54 60.15,69.53 arc(60.79,69.95) 61.54,70.1 61.99,70.1 arc(62.26,70.16) 62.48,70.31 63.93,71.76 arc(64.57,72.71) 64.79,73.84 64.79,74.23 arc(64.94,74.99) 65.38,75.64 65.94,76.2 arc(66.7,76.71) 67.59,76.88 67.92,76.88 arc(68.62,77.02) 69.22,77.42 70.28,78.48 76.17,84.37 arc(76.79,85.31) 77.01,86.41 77.01,86.92 arc(77.12,87.49) 77.44,87.97 77.6,88.12 arc(77.89,88.56) 78,89.09 arc(78.08,89.48) 78.3,89.81 78.68,90.18 arc(78.94,90.36) 79.24,90.42 83.53,90.42 arc(83.75,90.38) 83.93,90.26 arc(83.94,90.25) 83.95,90.25 84.01,90.18 arc(84.23,90.03) 84.49,89.98 85.1,89.98
QSFPDD_RXN1: length 54.4
  TOP w0.091: U12.21 57.71,63.14
  ART05 w0.097: 84.94,89.98 84.97,89.98 84.97,89.99 arc(84.99,90) 85.01,90.01 85.35,90.01 arc(85.65,90.09) 85.86,90.3 85.86,90.31 arc(86.01,90.45) 86.21,90.51 arc(86.51,90.58) 86.72,90.8 86.75,90.84 arc(86.87,90.96) 87.03,91.01 87.08,91.01 arc(87.38,91.09) 87.59,91.3 87.6,91.31 arc(87.74,91.45) 87.95,91.51 arc(88.24,91.58) 88.46,91.8 88.48,91.84 arc(88.6,91.96) 88.76,92.01 88.81,92.01 arc(89.11,92.09) 89.33,92.3 89.33,92.31 arc(89.48,92.45) 89.68,92.51 89.68,92.51 arc(89.97,92.58) 90.19,92.8 arc(90.19,92.8) 90.19,92.8 arc(90.19,92.8) 90.19,92.8 arc(90.26,93.07) 90.19,93.34 90.17,93.39 arc(90.11,93.59) 90.17,93.79 arc(90.25,94.09) 90.17,94.39 arc(90.11,94.59) 90.17,94.79 90.17,94.8 arc(90.25,95.09) 90.17,95.39 arc(90.11,95.59) 90.17,95.79 arc(90.25,96.09) 90.17,96.39 90.15,96.42 arc(90.11,96.57) 90.15,96.73 90.19,96.81 arc(90.34,96.95) 90.54,97.01 90.55,97.01 arc(90.84,97.09) 91.06,97.3 arc(91.13,97.55) 91.1,97.81 arc(91.1,97.82) 91.09,97.82 91.12,97.93 U1.BJ8
  ART05 w0.109: 84.94,89.98 81.6,89.98 arc(81.59,89.98) 81.57,89.98 81.49,89.96 arc(81.44,89.94) 81.39,89.9 76.02,84.53 arc(75.98,84.49) 75.95,84.44 75.77,84.16 arc(75.5,83.56) 75.41,82.92 75.41,81.61 arc(75.23,80.72) 74.73,79.96 69.77,75.01 arc(69.43,74.78) 69.04,74.7 68.02,74.7 arc(67.48,74.59) 67.02,74.29 66.04,73.3 62.05,69.32 arc(61.53,68.53) 61.34,67.61 61.34,67.21 arc(61.16,66.3) 60.65,65.53 58.93,63.81 58.8,63.68 arc(58.52,63.49) 58.19,63.43 57.99,63.43 57.71,63.14
QSFPDD_RXN2: length 75
  TOP w0.091: U12.15 48.92,65.14
  ART05 w0.097: 85.28,84.98 85.3,84.98 85.31,84.99 arc(85.33,85) 85.35,85.01 85.49,85.01 arc(85.9,85.36) 85.86,85.9 arc(85.81,86.1) 85.86,86.3 arc(85.94,86.6) 85.86,86.9 arc(85.81,87.1) 85.86,87.3 85.86,87.31 arc(86.01,87.45) 86.21,87.51 86.22,87.51 arc(86.51,87.59) 86.73,87.8 86.73,87.81 arc(86.88,87.95) 87.08,88.01 87.08,88.01 arc(87.38,88.09) 87.59,88.3 87.6,88.31 arc(87.74,88.45) 87.95,88.51 87.95,88.51 arc(88.24,88.59) 88.46,88.8 88.46,88.81 arc(88.61,88.95) 88.81,89.01 88.81,89.01 arc(89.11,89.09) 89.33,89.3 89.33,89.31 arc(89.48,89.45) 89.68,89.51 89.68,89.51 arc(89.98,89.59) 90.19,89.8 90.19,89.81 arc(90.34,89.95) 90.54,90.01 90.55,90.01 arc(90.84,90.09) 91.06,90.3 91.06,90.31 arc(91.21,90.45) 91.41,90.51 91.41,90.51 arc(91.71,90.59) 91.92,90.8 91.93,90.81 arc(92.07,90.95) 92.28,91.01 92.28,91.01 arc(92.57,91.09) 92.79,91.3 arc(92.87,91.6) 92.79,91.9 arc(92.74,92.1) 92.79,92.3 arc(92.87,92.6) 92.79,92.9 arc(92.74,93.1) 92.79,93.3 arc(92.87,93.6) 92.79,93.9 arc(92.74,94.1) 92.79,94.3 arc(92.87,94.6) 92.79,94.9 arc(92.74,95.1) 92.79,95.3 arc(92.87,95.6) 92.79,95.89 92.79,95.9 arc(92.74,96.1) 92.79,96.3 arc(92.87,96.6) 92.79,96.9 arc(92.74,97.1) 92.79,97.3 arc(92.87,97.6) 92.79,97.9 arc(92.74,98.1) 92.79,98.3 92.79,98.31 arc(92.94,98.45) 93.14,98.51 93.14,98.51 arc(93.39,98.56) 93.6,98.72 arc(93.6,98.73) 93.61,98.74 93.72,98.77 U1.BH11
  ART05 w0.109: 85.28,84.98 85.14,84.98 arc(85.07,84.97) 85,84.93 84.8,84.72 arc(84.62,84.46) 84.56,84.16 arc(84.52,83.92) 84.41,83.7 84.4,83.7 arc(84.39,83.69) 84.39,83.68 arc(83.97,83.41) 83.47,83.31 79.88,83.31 arc(79.61,83.27) 79.38,83.13 arc(79.34,83.09) 79.3,83.05 arc(79.18,82.84) 79.11,82.6 arc(79.1,82.54) 79.1,82.49 79.1,79.35 arc(79.09,79.25) 79.06,79.16 arc(78.93,78.89) 78.74,78.66 70.39,70.32 69.84,69.77 arc(69.31,69.41) 68.68,69.29 68.45,69.29 arc(67.91,69.18) 67.44,68.87 66.39,67.82 65.1,66.53 arc(64.91,66.24) 64.85,65.91 arc(64.78,65.59) 64.6,65.31 59.71,60.42 arc(58.36,59.52) 56.77,59.2 52.85,59.2 arc(51.76,59.42) 50.83,60.04 50.35,60.52 arc(49.83,61.29) 49.65,62.2 49.65,65.1 arc(49.55,65.33) 49.33,65.43 49.2,65.43 48.92,65.14
QSFPDD_RXN3: length 53.9
  TOP w0.091: U12.24 57.71,65.54
  ART07 w0.097: 85.13,88.98 85.15,88.98 85.18,89.01 85.31,89.01 arc(85.37,89.01) 85.44,89.02 arc(85.44,89.02) 85.45,89.02 arc(85.64,89.1) 85.8,89.23 arc(86.05,89.41) 86.33,89.52 arc(86.56,89.62) 86.72,89.8 86.73,89.8 arc(86.88,89.95) 87.08,90.01 87.08,90.01 arc(87.37,90.08) 87.59,90.3 87.59,90.3 arc(87.74,90.45) 87.94,90.51 87.95,90.51 arc(88.24,90.58) 88.46,90.8 88.46,90.8 arc(88.61,90.95) 88.81,91.01 88.81,91.01 arc(89.11,91.08) 89.32,91.3 89.33,91.3 arc(89.47,91.45) 89.67,91.51 89.68,91.51 arc(89.97,91.58) 90.19,91.8 90.19,91.8 arc(90.34,91.95) 90.54,92.01 90.54,92.01 arc(90.84,92.08) 91.06,92.3 91.06,92.3 arc(91.21,92.45) 91.41,92.51 91.41,92.51 arc(91.7,92.58) 91.92,92.8 91.92,92.8 arc(92.07,92.95) 92.27,93.01 92.28,93.01 arc(92.57,93.08) 92.79,93.3 92.79,93.31 arc(92.87,93.6) 92.79,93.9 arc(92.73,94.1) 92.79,94.3 arc(92.87,94.6) 92.79,94.89 92.79,94.9 arc(92.73,95.1) 92.79,95.3 92.79,95.31 arc(92.87,95.6) 92.79,95.9 arc(92.73,96.1) 92.79,96.3 arc(92.94,96.45) 93.14,96.51 93.14,96.51 arc(93.24,96.51) 93.33,96.54 arc(93.48,96.61) 93.6,96.72 arc(93.6,96.73) 93.61,96.74 93.72,96.77 U1.BM11
  ART07 w0.109: 57.71,65.54 57.99,65.83 58.33,65.83 arc(58.51,65.79) 58.67,65.68 58.86,65.49 arc(59.08,65.35) 59.33,65.3 59.84,65.3 arc(60.28,65.39) 60.66,65.64 60.73,65.71 65.88,70.86 arc(66.3,71.49) 66.45,72.24 66.45,72.49 arc(66.6,73.25) 67.03,73.89 77.57,84.43 arc(77.97,85.02) 78.11,85.72 78.11,86.39 arc(78.23,87.04) 78.6,87.59 79.27,88.27 arc(79.58,88.47) 79.93,88.54 83.62,88.54 arc(83.94,88.6) 84.21,88.78 84.22,88.79 arc(84.43,88.93) 84.68,88.98 85.13,88.98
QSFPDD_RXN4: length 63.8
  TOP w0.091: U12.56 51.85,62.74
  ART05 w0.097: U1.BN8 91.12,95.93 91.1,95.84 arc(91.24,95.73) 91.41,95.69 arc(91.92,95.4) 91.93,94.81 91.92,94.8 arc(91.87,94.6) 91.92,94.4 arc(92,94.12) 91.95,93.85 arc(91.89,93.61) 91.93,93.38 arc(91.98,93.09) 91.92,92.8 arc(91.9,92.76) 91.89,92.71 arc(91.88,92.61) 91.89,92.5 arc(91.89,92.49) 91.89,92.48 arc(91.9,92.44) 91.92,92.41 91.92,92.39 91.98,92.33 91.98,91.87 91.64,91.53 91.54,91.53 91.45,91.51 91.43,91.51 arc(91.21,91.42) 91.03,91.26 arc(90.82,91.07) 90.55,91.01 90.47,91.01 arc(90.33,90.97) 90.23,90.86 90.19,90.8 arc(89.97,90.58) 89.68,90.51 arc(89.49,90.46) 89.34,90.33 arc(89.1,90.11) 88.77,90 arc(88.6,89.95) 88.47,89.83 arc(88.43,89.77) 88.39,89.72 arc(88.23,89.6) 88.05,89.53 arc(87.99,89.51) 87.92,89.51 arc(87.75,89.45) 87.61,89.33 arc(87.36,89.11) 87.04,89 arc(86.87,88.95) 86.74,88.82 arc(86.7,88.77) 86.66,88.72 arc(86.5,88.6) 86.32,88.53 arc(86.26,88.51) 86.19,88.51 arc(86,88.45) 85.86,88.3 arc(85.83,88.25) 85.79,88.2 arc(85.59,88.06) 85.35,88.01 arc(85.35,88.01) 85.35,88.01 85.12,88.01 arc(85.09,88) 85.08,87.99 85.07,87.98 85.05,87.98
  ART05 w0.109: 85.05,87.98 84.94,87.98 arc(84.83,87.94) 84.78,87.83 84.78,87.04 arc(84.78,87.04) 84.78,87.04 84.78,87.08 arc(84.78,87.03) 84.78,86.98 84.74,86.49 arc(84.73,86.39) 84.69,86.3 arc(84.52,86.03) 84.32,85.79 83.95,85.42 arc(83.46,85.1) 82.89,84.98 79.47,84.98 arc(79.24,84.94) 79.04,84.8 78.22,83.98 arc(78.08,83.77) 78.03,83.52 78.03,80.74 78.02,80.74 arc(77.75,79.72) 77.15,78.85 76.96,78.66 69.23,70.93 arc(68.73,70.6) 68.15,70.48 68.03,70.48 arc(67.22,70.32) 66.54,69.87 63.34,66.67 arc(63.22,66.48) 63.17,66.27 63.17,66.14 arc(63.03,65.44) 62.64,64.85 59.14,61.35 58.85,61.06 arc(58.2,60.62) 57.43,60.47 54.86,60.47 arc(54.04,60.63) 53.35,61.1 52.95,61.5 arc(52.69,61.89) 52.6,62.36 52.6,62.75 arc(52.52,62.95) 52.32,63.03 52.13,63.03 51.85,62.74
QSFPDD_RXN5: length 56.5
  TOP w0.091: U12.59 54.78,63.14
  ART05 w0.097: 85.28,88.98 85.3,88.98 85.31,88.99 arc(85.33,89) 85.35,89.01 85.49,89.01 arc(85.71,89.12) 85.86,89.3 85.86,89.31 arc(86.01,89.45) 86.21,89.51 86.22,89.51 arc(86.51,89.59) 86.73,89.8 86.73,89.81 arc(86.88,89.95) 87.08,90.01 87.08,90.01 arc(87.38,90.09) 87.59,90.3 87.6,90.31 arc(87.74,90.45) 87.95,90.51 87.95,90.51 arc(88.24,90.59) 88.46,90.8 88.46,90.81 arc(88.61,90.95) 88.81,91.01 88.81,91.01 arc(89.11,91.09) 89.33,91.3 89.33,91.31 arc(89.48,91.45) 89.68,91.51 89.68,91.51 arc(89.98,91.59) 90.19,91.8 90.19,91.81 arc(90.34,91.95) 90.54,92.01 90.55,92.01 arc(90.84,92.09) 91.06,92.3 arc(91.14,92.6) 91.06,92.9 arc(91,93.1) 91.06,93.3 arc(91.13,93.55) 91.1,93.81 arc(91.1,93.82) 91.09,93.82 91.12,93.93 U1.BU8
  ART05 w0.109: 85.28,88.98 85.04,88.98 arc(84.56,88.89) 84.16,88.62 83.74,88.2 arc(83.63,88.04) 83.6,87.85 83.6,86.65 arc(83.49,86.39) 83.22,86.28 79.5,86.28 arc(79.21,86.22) 78.97,86.06 77.01,84.09 arc(76.84,83.84) 76.78,83.55 76.78,81.13 arc(76.53,79.88) 75.83,78.83 69.6,72.6 arc(68.77,72.05) 67.79,71.85 arc(67.27,71.75) 66.83,71.45 65.4,70.03 62.99,67.61 62.49,67.12 arc(62.33,66.88) 62.28,66.6 62.28,66.37 arc(62.16,65.78) 61.83,65.29 59.1,62.56 58.48,61.93 arc(57.98,61.6) 57.4,61.49 56.63,61.49 arc(56.17,61.58) 55.79,61.84 arc(55.61,62.1) 55.55,62.42 55.55,63.1 arc(55.45,63.33) 55.22,63.43 55.06,63.43 54.78,63.14
QSFPDD_RXN6: length 66.9
  TOP w0.091: U12.53 51.85,65.14
  ART07 w0.097: U1.BT11 93.72,94.77 93.63,94.74 arc(93.6,94.57) 93.65,94.4 93.66,94.39 arc(93.81,94.25) 94.01,94.19 94.01,94.19 arc(94.3,94.12) 94.52,93.9 arc(94.52,93.9) 94.52,93.9 arc(94.6,93.6) 94.52,93.3 arc(94.47,93.1) 94.52,92.9 arc(94.6,92.6) 94.52,92.3 arc(94.47,92.11) 94.51,91.92 arc(94.54,91.85) 94.56,91.78 arc(94.48,91.33) 94.12,91.03 arc(94.05,91.01) 93.98,91.01 arc(93.81,90.95) 93.68,90.84 arc(93.63,90.78) 93.59,90.74 93.47,90.64 arc(93.43,90.61) 93.38,90.58 93.22,90.53 arc(93.15,90.51) 93.08,90.5 93.08,90.5 arc(92.92,90.44) 92.79,90.33 arc(92.54,90.1) 92.22,90 92.19,90 arc(92.03,89.94) 91.92,89.83 91.9,89.79 arc(91.69,89.58) 91.39,89.5 91.39,89.5 arc(91.19,89.45) 91.04,89.3 91.04,89.29 arc(90.82,89.08) 90.53,89 90.48,89 arc(90.32,88.96) 90.2,88.84 90.17,88.79 arc(89.95,88.58) 89.66,88.5 89.66,88.5 arc(89.46,88.45) 89.31,88.3 89.31,88.29 arc(89.09,88.08) 88.79,88 88.79,88 arc(88.59,87.95) 88.44,87.8 88.44,87.79 arc(88.22,87.58) 87.93,87.5 87.93,87.5 arc(87.72,87.45) 87.58,87.3 87.57,87.29 arc(87.36,87.08) 87.06,87 87.06,87 arc(86.86,86.95) 86.71,86.8 86.71,86.79 arc(86.49,86.58) 86.2,86.5 86.19,86.5 arc(85.99,86.45) 85.84,86.3 arc(85.63,86.08) 85.34,86.01 85.15,86.01 85.12,85.98 85.1,85.98
  ART07 w0.109: 51.85,65.14 52.13,65.43 52.3,65.43 arc(52.49,65.35) 52.57,65.15 52.57,62.51 arc(52.71,61.81) 53.11,61.22 53.38,60.95 arc(53.87,60.61) 54.46,60.5 59.15,60.5 arc(60.09,60.68) 60.88,61.21 62.14,62.47 64.37,64.7 64.62,64.95 arc(64.9,65.37) 65,65.86 65,65.96 arc(65.07,66.34) 65.28,66.66 65.54,66.92 75.96,77.33 78.09,79.46 arc(78.69,80.35) 78.89,81.41 78.89,82.13 arc(78.99,82.59) 79.25,82.98 79.31,83.05 arc(79.63,83.26) 80,83.33 83.51,83.33 arc(83.84,83.4) 84.11,83.58 84.34,83.81 arc(84.56,84.13) 84.63,84.5 84.63,85.56 arc(84.66,85.73) 84.76,85.88 arc(84.88,85.96) 85.01,85.98 85.1,85.98
QSFPDD_RXN7: length 58.5
  TOP w0.091: U12.62 54.78,65.54
  ART07 w0.097: 85.05,87.98 85.07,87.98 85.1,88.01 85.35,88.01 arc(85.64,88.09) 85.86,88.3 85.86,88.31 arc(86.01,88.45) 86.21,88.51 86.22,88.51 arc(86.49,88.57) 86.7,88.76 arc(86.88,88.93) 87.1,89.01 arc(87.37,89.11) 87.59,89.3 arc(87.76,89.44) 87.96,89.51 arc(88.24,89.61) 88.47,89.81 arc(88.59,89.92) 88.74,89.99 arc(88.79,90) 88.84,90.01 arc(89.1,90.08) 89.3,90.26 arc(89.49,90.43) 89.73,90.51 arc(89.99,90.6) 90.19,90.8 90.27,90.93 arc(90.32,90.99) 90.39,91.01 90.55,91.01 arc(90.85,91.09) 91.06,91.3 91.09,91.35 arc(91.23,91.49) 91.44,91.55 91.44,91.55 arc(91.73,91.63) 91.95,91.84 91.95,91.85 arc(92.1,91.99) 92.3,92.05 92.3,92.05 arc(92.6,92.13) 92.82,92.34 92.82,92.35 arc(92.97,92.49) 93.17,92.55 93.24,92.55 arc(93.44,92.59) 93.6,92.72 arc(93.6,92.73) 93.61,92.74 93.72,92.77 U1.BY11
  ART07 w0.109: 54.78,65.54 55.06,65.83 55.27,65.83 arc(55.46,65.75) 55.54,65.55 55.54,62.67 arc(55.61,62.31) 55.81,62.01 55.93,61.9 arc(56.16,61.74) 56.43,61.69 57.76,61.69 arc(58.03,61.75) 58.27,61.9 58.82,62.46 62.79,66.42 63.19,66.82 arc(63.38,66.95) 63.6,66.99 63.9,66.99 arc(64.15,67.04) 64.36,67.18 64.83,67.65 76.71,79.53 arc(77.33,80.46) 77.55,81.56 77.55,82.19 arc(77.64,82.67) 77.91,83.07 79.24,84.4 arc(79.36,84.55) 79.46,84.71 arc(79.49,84.81) 79.5,84.91 79.5,85.65 arc(79.52,85.81) 79.58,85.95 arc(79.58,85.95) 79.58,85.96 79.62,86.02 arc(79.65,86.07) 79.69,86.11 arc(79.8,86.19) 79.94,86.24 arc(79.99,86.25) 80.04,86.26 83.51,86.26 arc(83.79,86.31) 84.03,86.47 84.1,86.54 arc(84.23,86.73) 84.27,86.97 84.27,87.31 arc(84.31,87.51) 84.43,87.68 84.62,87.87 arc(84.74,87.95) 84.89,87.98 85.05,87.98
QSFPDD_RXP0: length 66.8
  TOP w0.091: U12.17 48.92,63.54
  ART07 w0.097: U1.BF7 90.83,99.77 90.92,99.74 arc(90.95,99.57) 90.89,99.4 arc(90.75,99.25) 90.55,99.2 90.53,99.2 arc(90.25,99.12) 90.04,98.91 90.03,98.9 arc(89.95,98.6) 90.03,98.3 arc(90.08,98.1) 90.03,97.9 arc(89.95,97.6) 90.03,97.3 arc(90.08,97.1) 90.03,96.9 arc(89.95,96.6) 90.03,96.3 arc(90.08,96.1) 90.03,95.9 90.03,95.89 arc(89.95,95.6) 90.03,95.3 arc(90.08,95.1) 90.03,94.9 arc(89.95,94.6) 90.03,94.3 arc(90.08,94.1) 90.03,93.9 arc(89.95,93.6) 90.03,93.3 arc(90.08,93.1) 90.03,92.9 90.03,92.89 arc(89.89,92.76) 89.71,92.7 arc(89.39,92.59) 89.14,92.37 arc(89.02,92.25) 88.87,92.2 arc(88.81,92.19) 88.75,92.17 arc(88.54,92.08) 88.35,91.94 arc(88.31,91.9) 88.26,91.85 arc(88.14,91.74) 87.98,91.7 arc(87.68,91.61) 87.44,91.41 arc(87.28,91.27) 87.07,91.2 arc(87.05,91.19) 87.03,91.19 arc(86.76,91.1) 86.56,90.9 86.56,90.89 arc(86.55,90.88) 86.55,90.87 arc(86.4,90.74) 86.21,90.69 86.21,90.69 arc(85.91,90.61) 85.7,90.4 85.7,90.39 arc(85.69,90.4) 85.69,90.4 arc(85.49,90.25) 85.24,90.19 85.17,90.19 arc(85.15,90.2) 85.13,90.21 85.12,90.22 85.1,90.22
  ART07 w0.109: 48.92,63.54 49.2,63.26 49.38,63.26 arc(49.59,63.35) 49.67,63.56 49.67,65.48 arc(49.82,66.23) 50.25,66.86 50.65,67.26 arc(51.55,67.86) 52.61,68.07 57.47,68.07 arc(58.3,68.24) 59,68.71 59.99,69.69 arc(60.7,70.17) 61.54,70.34 61.99,70.34 arc(62.17,70.37) 62.32,70.47 63.77,71.92 arc(64.35,72.8) 64.56,73.84 64.56,74.23 arc(64.73,75.08) 65.21,75.81 65.77,76.37 arc(66.61,76.92) 67.59,77.12 67.92,77.12 arc(68.53,77.24) 69.05,77.59 75.17,83.7 76,84.54 arc(76.57,85.4) 76.78,86.41 76.78,86.92 arc(76.91,87.57) 77.28,88.13 77.43,88.28 arc(77.68,88.65) 77.77,89.09 arc(77.86,89.57) 78.14,89.97 78.51,90.35 arc(78.85,90.57) 79.24,90.65 80.8,90.65 80.92,90.77 81.14,90.77 81.26,90.65 81.48,90.65 81.6,90.77 81.82,90.77 81.94,90.65 82.17,90.65 82.29,90.77 82.51,90.77 82.63,90.65 82.85,90.65 82.97,90.77 83.19,90.77 83.31,90.65 83.53,90.65 arc(83.83,90.6) 84.09,90.43 arc(84.1,90.43) 84.1,90.42 arc(84.11,90.42) 84.11,90.41 84.11,90.41 84.18,90.35 arc(84.32,90.25) 84.49,90.22 85.1,90.22
QSFPDD_RXP1: length 54.4
  TOP w0.091: U12.22 57.71,63.94
  ART05 w0.097: 84.94,90.22 84.97,90.22 84.97,90.21 arc(84.99,90.2) 85.01,90.19 85.35,90.19 arc(85.55,90.25) 85.7,90.39 85.7,90.4 arc(85.91,90.61) 86.21,90.69 86.21,90.69 arc(86.41,90.75) 86.56,90.89 86.59,90.94 arc(86.77,91.13) 87.03,91.19 87.08,91.19 arc(87.28,91.25) 87.43,91.39 87.43,91.4 arc(87.65,91.61) 87.94,91.69 87.95,91.69 arc(88.15,91.75) 88.29,91.89 88.32,91.94 arc(88.51,92.13) 88.76,92.19 88.81,92.19 arc(89.01,92.25) 89.16,92.39 89.16,92.4 arc(89.38,92.61) 89.67,92.69 89.68,92.69 arc(89.88,92.75) 90.03,92.89 arc(90.03,92.89) 90.03,92.9 arc(90.08,93.07) 90.03,93.25 90,93.29 arc(89.93,93.59) 90,93.89 arc(90.06,94.09) 90,94.29 arc(89.93,94.59) 90,94.89 90.01,94.89 arc(90.06,95.09) 90,95.29 arc(89.93,95.59) 90,95.89 arc(90.06,96.09) 90,96.29 89.99,96.32 arc(89.92,96.57) 89.99,96.82 90.03,96.9 arc(90.2,97.08) 90.42,97.18 arc(90.48,97.19) 90.54,97.19 90.54,97.19 arc(90.74,97.25) 90.89,97.39 90.89,97.4 arc(90.95,97.57) 90.92,97.74 90.83,97.77 U1.BK7
  ART05 w0.109: 84.94,90.22 84.73,90.22 84.6,90.34 84.39,90.34 84.26,90.22 84.04,90.22 83.92,90.34 83.7,90.34 83.58,90.22 83.36,90.22 83.24,90.34 83.02,90.34 82.9,90.22 82.68,90.22 82.56,90.34 82.34,90.34 82.22,90.22 81.6,90.22 arc(81.55,90.21) 81.51,90.2 81.43,90.18 arc(81.32,90.14) 81.23,90.07 75.85,84.69 arc(75.8,84.63) 75.75,84.57 75.57,84.29 arc(75.28,83.63) 75.18,82.92 75.18,81.61 arc(75.02,80.81) 74.56,80.13 69.61,75.17 arc(69.34,75) 69.04,74.93 68.02,74.93 arc(67.39,74.81) 66.86,74.45 66.51,74.1 61.88,69.48 arc(61.31,68.62) 61.11,67.61 61.11,67.21 arc(60.95,66.39) 60.48,65.69 59.87,65.07 58.63,63.84 arc(58.43,63.71) 58.19,63.66 57.99,63.66 57.71,63.94
QSFPDD_RXP2: length 75
  TOP w0.091: U12.14 48.92,65.94
  ART05 w0.097: 93.14,99.1 93.43,98.93 93.45,98.84 arc(93.31,98.73) 93.14,98.69 93.14,98.69 arc(92.84,98.61) 92.63,98.4 arc(92.55,98.1) 92.63,97.8 arc(92.68,97.6) 92.63,97.4 92.63,97.4 arc(92.55,97.1) 92.63,96.8 92.63,96.8 arc(92.68,96.6) 92.63,96.4 arc(92.55,96.1) 92.63,95.8 arc(92.68,95.6) 92.63,95.4 92.63,95.4 arc(92.55,95.1) 92.62,94.81 92.63,94.8 arc(92.68,94.6) 92.63,94.4 arc(92.55,94.1) 92.63,93.8 arc(92.68,93.6) 92.63,93.4 92.63,93.4 arc(92.55,93.1) 92.63,92.8 92.63,92.8 arc(92.68,92.6) 92.63,92.4 arc(92.55,92.1) 92.63,91.8 arc(92.68,91.6) 92.63,91.4 92.63,91.39 arc(92.48,91.25) 92.28,91.19 92.28,91.19 arc(91.98,91.12) 91.76,90.9 91.76,90.9 arc(91.61,90.75) 91.41,90.69 91.41,90.69 arc(91.11,90.62) 90.9,90.4 90.89,90.4 arc(90.75,90.25) 90.55,90.19 90.54,90.19 arc(90.25,90.12) 90.03,89.9 90.03,89.9 arc(89.88,89.75) 89.68,89.69 89.68,89.69 arc(89.38,89.62) 89.16,89.4 89.16,89.4 arc(89.01,89.25) 88.81,89.19 88.81,89.19 arc(88.52,89.12) 88.3,88.9 88.3,88.9 arc(88.15,88.75) 87.95,88.69 87.95,88.69 arc(87.65,88.62) 87.43,88.4 87.43,88.4 87.43,88.39 arc(87.28,88.25) 87.08,88.19 ; 87.08,88.19 87.08,88.19 ; 87.08,88.19 arc(86.78,88.12) 86.57,87.9 86.56,87.9 arc(86.42,87.75) 86.22,87.69 86.21,87.69 arc(85.92,87.62) 85.7,87.4 85.7,87.4 arc(85.62,87.1) 85.7,86.8 arc(85.75,86.6) 85.7,86.4 arc(85.62,86.1) 85.7,85.8 arc(85.73,85.44) 85.47,85.19 85.35,85.19 arc(85.33,85.2) 85.31,85.21 85.3,85.22 85.28,85.22
  ART05 w0.109: 48.92,65.94 49.2,65.66 49.33,65.66 arc(49.72,65.5) 49.88,65.1 49.88,62.2 arc(50.05,61.38) 50.51,60.69 50.99,60.21 arc(51.85,59.64) 52.85,59.44 56.77,59.44 arc(58.27,59.73) 59.54,60.58 63.31,64.35 64.44,65.48 arc(64.57,65.68) 64.62,65.91 arc(64.7,66.33) 64.94,66.69 65.39,67.14 67.28,69.03 arc(67.82,69.39) 68.45,69.52 68.68,69.52 arc(69.22,69.63) 69.68,69.93 77.42,77.67 78.57,78.83 arc(78.73,79.02) 78.85,79.24 arc(78.86,79.3) 78.87,79.35 78.87,82.49 arc(78.87,82.56) 78.88,82.64 arc(78.96,82.93) 79.11,83.19 arc(79.17,83.25) 79.23,83.31 arc(79.53,83.48) 79.88,83.55 81.89,83.55 82.01,83.67 82.23,83.67 82.35,83.55 82.57,83.55 82.69,83.67 82.91,83.67 83.04,83.55 83.47,83.55 arc(83.88,83.63) 84.23,83.85 arc(84.3,84) 84.33,84.16 arc(84.41,84.55) 84.63,84.88 84.84,85.09 arc(84.98,85.18) 85.14,85.22 85.28,85.22
