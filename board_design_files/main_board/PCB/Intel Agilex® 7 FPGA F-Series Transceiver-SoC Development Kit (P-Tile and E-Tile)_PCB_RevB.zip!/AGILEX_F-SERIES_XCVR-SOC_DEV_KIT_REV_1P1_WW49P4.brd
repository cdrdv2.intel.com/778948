# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FX2_PD6: length 27.4
  TOP w0.109: U23.F16 v2(35.54,178.32) ; U21.51 23.3,181.39 v2(22.8,181.89)
  ART03 w0.114: v2(35.54,178.32) 35.13,178.73 35.13,179.68 34.95,179.85 34.79,179.85 34.64,179.71 34.48,179.71 34.32,179.87 34.32,180.03 34.46,180.18 34.46,180.34 34.3,180.5 34.14,180.5 34,180.36 33.84,180.36 33.67,180.52 33.67,180.68 33.82,180.82 33.82,180.99 33.63,181.18 32.97,181.18 32.85,181.29 32.85,181.47 32.74,181.58 32.51,181.58 32.4,181.47 32.4,181.29 32.28,181.18 32.05,181.18 31.94,181.29 31.94,181.47 31.83,181.58 31.6,181.58 31.48,181.47 31.48,181.29 31.37,181.18 31.14,181.18 31.03,181.29 31.03,181.47 30.91,181.58 30.68,181.58 30.57,181.47 30.57,181.29 30.45,181.18 30.23,181.18 30.11,181.29 30.11,181.47 30,181.58 29.77,181.58 29.65,181.47 29.65,181.29 29.54,181.18 29.26,181.18 29.01,180.93 28.85,180.93 28.48,181.3 28.31,181.3 28.15,181.14 28.15,180.98 28.52,180.61 28.52,180.44 28.42,180.34 27.74,180.34 27.63,180.45 27.63,180.78 27.51,180.9 27.29,180.9 27.17,180.78 27.17,180.45 27.06,180.34 26.83,180.34 26.71,180.45 26.71,180.78 26.6,180.9 26.37,180.9 26.26,180.78 26.26,180.45 26.14,180.34 25.91,180.34 25.8,180.45 25.8,180.78 25.68,180.9 25.46,180.9 25.34,180.78 25.34,180.45 25.23,180.34 25,180.34 24.88,180.45 24.88,180.78 24.77,180.9 24.54,180.9 24.43,180.78 24.43,180.45 24.31,180.34 24.08,180.34 23.97,180.45 23.97,180.78 23.86,180.9 23.63,180.9 23.51,180.78 23.51,180.45 23.4,180.34 22.93,180.34 22.8,180.47 v2(22.8,181.89)
FX2_PD7: length 27.3
  TOP w0.109: U23.G16 v2(36.33,178.32) ; v2(22.8,183.04) 22.2,182.44 22.2,181.71 22.8,181.11
  TOP w0.114: U21.52 22.8,181.11
  ART03 w0.114: v2(22.8,183.04) 23.47,182.37 23.92,182.37 24.03,182.49 24.03,182.54 24.15,182.65 24.38,182.65 24.49,182.54 24.49,182.49 24.61,182.37 24.83,182.37 24.95,182.49 24.95,182.54 25.06,182.65 25.29,182.65 25.41,182.54 25.41,182.49 25.52,182.37 26.13,182.37 27.35,183.59 27.84,183.59 28.17,183.26 28.72,183.26 28.84,183.37 28.84,183.6 28.95,183.72 29.18,183.72 29.29,183.6 29.29,183.37 29.41,183.26 29.64,183.26 29.75,183.37 29.75,183.6 29.87,183.72 30.09,183.72 30.21,183.6 30.21,183.37 30.32,183.26 30.55,183.26 30.67,183.37 30.67,183.6 30.78,183.72 31.01,183.72 31.12,183.6 31.12,183.37 31.24,183.26 31.47,183.26 31.58,183.37 31.58,183.6 31.69,183.72 31.92,183.72 32.04,183.6 32.04,183.37 32.15,183.26 32.38,183.26 32.49,183.37 32.49,183.6 32.61,183.72 32.84,183.72 32.95,183.6 32.95,183.37 33.07,183.26 33.29,183.26 33.41,183.37 33.41,183.6 33.52,183.72 33.75,183.72 33.87,183.6 33.87,183.37 33.98,183.26 34.74,183.26 35.63,182.38 35.63,181.64 35.88,181.39 35.88,181.23 35.8,181.15 35.8,180.99 35.96,180.83 36.12,180.83 36.2,180.91 36.36,180.91 36.73,180.54 36.73,178.71 v2(36.33,178.32)
FX2_RESETN: length 59.3
  TOP w0.109: U23.H11 v2(37.13,174.32) ; v3(30.08,179.77) R295.1 29.43,179.78 U21.42
  ART18 w0.114: v2(37.13,174.32) 37.13,174.55 37.51,174.93 37.51,175.26 37.74,175.49 38.2,175.49 38.68,175.97 38.68,180.14 37.88,180.94 31.25,180.94 v3(30.08,179.77) 29.62,179.77 29.56,179.7 28.25,179.7 27.14,178.59 21.43,178.59 20.37,177.52 20.37,167.89 23.11,165.15 v2(23.98,165.15)
  BOTTOM w0.109: v2(23.98,165.15) 23.62,164.8 23.62,157.51 25.81,155.32 28.8,155.32 29.61,154.51 U22.2
FX2_SCL: length 4.3
  TOP w0.109: R296.1 v3(18.82,171.35) 20.32,171.35 20.8,171.83 U21.15
  BOTTOM w0.109: v3(18.82,171.35) R296.1
FX2_SDA: length 3.1
  TOP w0.109: R297.1 R293.1 21.3,171.14 U21.16
FX2_SLRDN: length 24.3
  TOP w0.109: U23.E16 v2(34.73,178.32)
  TOP w0.114: U21.1 20.15,180.23 v3(20.04,180.34)
  ART03 w0.114: v2(34.73,178.32) 34.44,178.61 34.44,178.82 34.34,178.92 34.34,179.4 34.21,179.53 33.73,179.53 32.54,180.72 30.27,180.72 29.47,179.92 22.21,179.92 21.72,180.42 21.72,182.98 21.41,183.29 19.85,183.29 19.1,182.54 19.1,181.28 v3(20.04,180.34)
FX2_SLWRN: length 25.2
  TOP w0.109: U23.D16 v2(33.94,178.32)
  TOP w0.114: v3(19.25,179.42) 19.25,179.39 19.36,179.28 U21.2
  ART03 w0.114: v2(33.94,178.32) 33.94,178.56 33.51,178.99 33.51,179.31 32.52,180.3 31.27,180.3 30.28,179.3 29.23,179.3 29.03,179.5 27.84,179.5 27.72,179.39 27.72,177.61 27.61,177.5 27.38,177.5 27.26,177.61 27.26,179.39 27.15,179.5 20.8,179.5 20.69,179.39 20.69,177.69 20.57,177.57 20.35,177.57 20.23,177.69 20.23,179.39 20.12,179.5 19.33,179.5 v3(19.25,179.42)
FX2_WAKEUP: length 23.2
  TOP w0.109: v2(17.68,173.63) 17.17,174.14 R300.2 R299.2 ; v2(27.67,183.17) 27.11,183.17 26.8,182.86 C669.1 26.8,182.27 U21.44
  ART20 w0.114: v2(27.67,183.17) 27.07,182.57 20.8,182.57 17.45,179.22 17.45,173.86 v2(17.68,173.63)
HPS_DC_JTAG_TCK: length 41.7
  TOP w0.109: v2(38.99,157.99) 39.18,158.18 R74.1 39.85,158.18 40.11,157.91 J5.55 ; U23.C16 v2(33.13,178.32)
  ART03 w0.114: v2(33.13,178.32) 33.13,178.07 33.55,177.65 33.55,177.11 32.7,176.26 32.7,172.91 31.02,171.23 31.02,168.64 29.99,167.61 29.99,166.95 29.82,166.78 29.82,165.15 29.61,164.95 28.52,164.95 27.76,164.18 27.76,161.09 28.29,160.55 28.29,157.99 29.49,156.79 30.76,156.79 31.26,156.29 36.24,156.29 37.51,157.56 38.55,157.56 v2(38.99,157.99)
  BOTTOM w0.089: R1005.2 31.94,178.88 32.13,178.69 32.51,178.69 32.88,178.32 v2(33.13,178.32)
HPS_DC_JTAG_TDI: length 42.4
  TOP w0.089: U23.A14 v2(31.56,176.69)
  TOP w0.109: v2(40.11,148.41) J5.56
  ART03 w0.114: v2(31.56,176.69) 31.56,175.07 31.06,174.57 31.06,172.73 28.34,170.01 28.34,166.45 26.01,164.11 26.01,158.52 29.41,155.12 36.12,155.12 40.1,151.13 40.1,148.83 40.11,148.82 v2(40.11,148.41)
HPS_DC_JTAG_TDO: length 46.1
  TOP w0.109: U23.A15 v2(31.53,177.52) ; J5.58 39.61,147.9 39.91,147.6 v2(40.1,147.6)
  ART03 w0.114: v2(40.1,147.6) 39.65,148.06 39.65,150.95 36.55,154.05 31.95,154.05 31.64,154.36 29.58,154.36 24.89,159.05 24.89,163.88 27.38,166.37 27.38,169.64 30.6,172.86 30.6,175.69 30.81,175.9 30.81,176.8 v2(31.53,177.52)
HPS_DC_JTAG_TMS: length 40.6
  TOP w0.109: U23.C15 v2(33.13,177.52) ; J5.57 v2(39.61,157.22)
  ART03 w0.114: v2(33.13,177.52) 32.18,176.57 32.18,174.1 31.93,173.85 31.93,173 29.93,171 29.93,168.69 28.93,167.69 28.93,166.19 27.15,164.41 27.15,158.04 29.66,155.54 37.28,155.54 37.39,155.65 37.39,155.97 37.5,156.08 37.73,156.08 37.85,155.97 37.85,155.65 37.96,155.54 38.19,155.54 38.3,155.65 38.3,155.97 38.42,156.08 38.65,156.08 38.76,155.97 38.76,155.65 38.88,155.54 39.15,155.54 39.61,156 v2(39.61,157.22)
HPS_DC_PRSNTN: length 338.1
  TOP w0.109: 42.23,146.75 42.32,146.66 v2(42.62,146.66) ; R357.1 41.27,181.84 41.94,181.17 v2(41.94,179.92) U23.N18 ; J5.52 41.11,147.99 41.78,147.32 R79.1
  TOP w0.127: R79.1 42.23,146.75
  ART07 w0.114: v2(41.94,179.92) 42.2,179.92 43.43,178.69 43.74,178.69 43.91,178.51 43.91,178.1 44.09,177.93 46.1,177.93 46.86,177.16 46.86,175.77 47.75,174.88 50.16,174.88 50.8,175.51 52.96,175.51 56.9,171.58 60.83,171.58 62.36,170.05 62.36,168.78 63.37,167.77 64.26,167.77 65.53,166.5 67.44,166.5 68.07,165.86 73.53,165.86 78.23,170.56 78.23,171.32 79.12,172.21 128.14,172.21 129.29,171.07 129.29,168.02 132.21,165.1 135.79,165.1 136.72,164.17 138.93,164.17 139.95,163.15 139.95,161.93 140.72,161.16 147.32,161.16 148.46,160.02 160.12,160.02 165.8,154.34 171.58,154.34 172.43,155.19 174.88,155.19 175.73,154.34 187.54,154.34 190.6,151.28 190.6,141.39 191.5,140.49 191.5,137.65 188.87,135.03 188.87,130.35 190.41,128.82 190.41,127.45 190.81,127.05 190.81,124.21 190.27,123.66 190.27,118.26 193.73,114.81 v2(197.46,114.81)
  ART20 w0.114: v2(197.46,114.81) 196.89,114.24 196.89,86.85 193.93,83.89 193.93,80.29 192.33,78.69 190.55,78.69 189.24,77.38 187.59,77.38 186.77,78.2 184.95,78.2 184.33,77.57 183.03,77.57 181.92,78.68 174.91,78.68 173.58,80.01 166.72,80.01 164.51,82.22 164.51,86.71 164.67,86.87 164.67,87.58 v2(164.27,87.98) ; v2(42.62,146.66) 41.98,146.66 40.54,148.11 40.54,158.57 39.47,159.64 39.47,162.18 41.55,164.26 41.55,166.52 41.75,166.72 42.09,166.72 42.34,166.98 42.34,167.29 42.56,167.51 43.7,167.51 43.81,167.63 43.81,168.07 44.24,168.5 44.24,169.92 43.99,170.18 43.99,171.27 42.33,172.94 42.33,179.53 v2(41.94,179.92)
HPS_DC_RESETN: length 243.2
  TOP w0.109: J5.53 40.61,157.79 40.89,158.07 R84.2 40.13,158.94 40.13,159.51 40,159.64 v2(38.94,159.64) ; U23.C13 v2(33.13,175.92)
  ART03 w0.114: v2(33.13,175.92) 33.43,175.63 33.43,172.92 32.05,171.55 32.05,170.81 31.9,170.66 31.9,167.68 31.75,167.54 31.37,167.54 30.98,167.15 30.98,166.13 30.38,165.53 30.38,164.92 28.67,163.22 28.67,161.37 29.49,160.55 29.49,158.3 30.54,157.25 35.02,157.25 36.82,159.04 38.34,159.04 v2(38.94,159.64)
  ART05 w0.114: v2(166.47,152.15) 165.84,151.51 164.21,151.51 161.54,154.18 143.76,154.18 140.37,157.57 140.37,158.71 137.38,161.71 135.73,161.71 v2(134.49,162.94)
  ART18 w0.114: v2(38.94,159.64) 40.55,161.25 43.72,161.25 45.16,162.69 56.39,162.69 59.43,159.64 96.14,159.64 100.97,164.47 104.52,164.47 109.54,159.45 130.11,159.45 132.46,161.8 133.76,161.8 134.49,162.53 v2(134.49,162.94)
  ART20 w0.114: v2(177.87,95.98) 177.46,96.39 177.46,97.06 177.61,97.2 178.25,97.2 178.79,97.74 178.79,101.6 178.51,101.88 178.51,105.54 177.14,106.91 177.14,119.38 175.23,121.28 175.23,123.06 174.43,123.87 173.34,123.87 172.24,124.97 172.24,125.88 171.21,126.91 170.29,126.91 169.63,127.57 169.63,128.7 169.48,128.86 169.48,130.48 167.87,132.09 167.87,138.43 166.22,140.08 166.22,145.29 165.33,146.18 165.33,151 v2(166.47,152.15)
HPS_GPIO0: length 82.9
  TOP w0.109: v2(53.82,153.54) 53.11,154.25 J5.3
  ART18 w0.114: v2(53.82,153.54) 53.06,152.78 53.06,149.35 47.22,143.51 47.22,132.71 52.7,127.23 61.59,127.23 69.06,119.76 73,119.76 74.89,117.87 74.89,116.7 75.6,115.99 76.13,115.99 77.49,114.64 78.88,114.64 79.5,114.02 79.5,113.86 79.15,113.52 79.15,113.35 79.31,113.19 79.47,113.19 79.82,113.54 79.98,113.54 80.14,113.38 80.14,113.22 79.8,112.87 79.8,112.71 79.96,112.55 80.12,112.55 80.47,112.89 80.63,112.89 80.92,112.6 80.92,112.6 84.01,112.6 84.49,113.08 85.51,113.08 86,112.59 86.47,112.59 86.96,112.1 87.23,112.1 87.72,111.61 88.18,111.61 88.7,111.1 89,111.1 89.24,110.86 89.24,109.03 v2(88.81,108.6)
HPS_GPIO1: length 77.7
  TOP w0.109: J5.4 53.11,147.93 53.26,147.78 53.26,146.15 52.02,144.91 51.42,144.91 v2(51.05,144.55)
  ART20 w0.114: v2(85.35,110.6) 71.36,110.6 69.19,112.78 67.54,112.78 63.2,117.12 63.2,125.37 63.02,125.54 62.86,125.54 62.26,124.94 62.1,124.94 61.94,125.11 61.94,125.27 62.54,125.87 62.54,126.03 62.38,126.19 62.21,126.19 61.61,125.59 61.45,125.59 61.29,125.75 61.29,125.91 61.89,126.51 61.89,126.68 61.73,126.84 61.57,126.84 60.97,126.24 60.81,126.24 60.64,126.4 60.64,126.56 61.24,127.16 61.24,127.32 61.08,127.48 60.92,127.48 60.32,126.88 60.16,126.88 60,127.04 60,127.21 60.6,127.81 60.6,127.97 60.44,128.13 60.27,128.13 59.67,127.53 59.51,127.53 59.35,127.69 59.35,127.85 59.95,128.45 59.95,128.62 59.79,128.78 59.63,128.78 59.03,128.18 58.87,128.18 58.7,128.34 58.7,128.5 59.19,128.99 59.19,129.15 59.03,129.31 58.87,129.31 58.38,128.82 58.22,128.82 58.06,128.98 58.06,129.15 58.39,129.48 58.39,129.64 57.55,130.49 57.38,130.49 57.18,130.28 57.01,130.28 56.85,130.44 56.85,130.61 57.33,131.08 57.33,131.24 56.74,131.83 56.74,135.61 51.71,140.64 51.71,143.89 v2(51.05,144.55)
HPS_GPIO2: length 85
  TOP w0.109: J5.5 52.61,153.78 v2(52.63,153.77)
  ART18 w0.114: v2(89.68,109.1) 90.12,109.54 90.12,111.35 89.84,111.63 89.33,111.63 88.97,111.99 88.65,111.99 88.12,112.52 87.86,112.52 87.34,113.04 86.97,113.04 86.39,113.63 86.02,113.63 85.55,114.1 80.59,114.1 78.78,115.91 77.11,115.91 75.75,117.26 75.6,117.26 75.31,117.56 75.31,118.21 73.32,120.2 69.65,120.2 69.16,120.69 69.16,120.85 69.63,121.31 69.63,121.48 69.47,121.64 69.31,121.64 68.84,121.17 68.68,121.17 68.52,121.33 68.52,121.49 68.98,121.96 68.98,122.12 68.82,122.28 68.66,122.28 68.19,121.82 67.64,121.82 61.69,127.76 52.93,127.76 47.72,132.97 47.72,143.26 50.14,145.67 50.9,145.67 53.82,148.59 53.82,152.78 54.33,153.29 54.33,153.8 54.07,154.05 52.91,154.05 v2(52.63,153.77)
HPS_GPIO3: length 76.9
  TOP w0.109: J5.6 52.61,146.27 v2(51.65,145.3)
  ART20 w0.114: v2(85.35,111.6) 73.62,111.6 73.51,111.71 73.51,112.53 73.39,112.65 73.16,112.65 73.05,112.53 73.05,111.71 72.93,111.6 72.65,111.6 72.26,111.99 72.26,112.15 72.59,112.48 72.59,112.64 72.44,112.79 72.26,112.79 71.94,112.47 71.78,112.47 71.35,112.9 71.35,113.79 70.08,115.06 67.92,115.06 64.06,118.92 64.06,125.4 64.04,125.42 64.04,125.47 64.03,125.48 64.03,125.72 59.68,130.07 59.46,130.07 58.57,130.96 58.57,131.68 58.79,131.9 58.79,132.06 58.63,132.22 58.47,132.22 58.25,132.01 57.79,132.01 57.67,132.13 57.67,132.63 57.78,132.74 58.4,132.74 58.52,132.86 58.52,133.09 58.4,133.2 57.87,133.2 57.76,133.32 57.76,133.54 57.87,133.66 58.4,133.66 58.52,133.77 58.52,134 58.4,134.12 57.87,134.12 57.76,134.23 57.76,134.46 57.87,134.57 58.4,134.57 58.52,134.69 58.52,134.92 58.4,135.03 57.87,135.03 57.76,135.14 57.76,136 58.11,136.35 58.11,136.51 57.94,136.67 57.78,136.67 57.41,136.3 57.25,136.3 56.94,136.6 56.94,136.77 57.3,137.12 57.3,137.28 57.13,137.44 56.97,137.44 56.62,137.09 56.46,137.09 56.29,137.25 56.29,137.41 56.65,137.77 56.65,137.93 56.49,138.09 56.33,138.09 55.97,137.74 55.81,137.74 55.65,137.9 55.65,138.06 56,138.41 56,138.58 55.84,138.74 55.68,138.74 55.32,138.38 55.16,138.38 55,138.54 55,138.71 55.36,139.06 55.36,139.22 55.19,139.38 55.03,139.38 54.68,139.03 54.52,139.03 54.35,139.19 54.35,139.35 54.71,139.71 54.71,139.87 54.55,140.03 54.39,140.03 54.03,139.68 53.87,139.68 53.71,139.84 53.71,140 54.06,140.35 54.06,140.51 52.63,141.94 52.63,144.26 52.52,144.37 52.52,144.43 v2(51.65,145.3)
HPS_GPIO4: length 82.4
  TOP w0.109: v2(51.92,153.8) 52.11,154 J5.7
  ART18 w0.114: v2(51.92,153.8) 51.5,154.21 50.6,154.21 50.26,153.87 50.26,152.27 50.39,152.15 50.39,150.24 48.99,148.84 48.99,147.95 47.98,146.94 47.98,146.43 47.22,145.67 47.22,145.01 46.29,144.09 46.29,142.35 45.31,141.37 45.31,137.29 45,136.98 45,133.53 52.47,126.06 61.32,126.06 69.27,118.11 73,118.11 73.97,117.13 73.97,115.86 75.33,114.51 75.33,113.98 75.6,113.71 76,113.71 76.51,113.2 76.51,113.04 76.23,112.75 76.23,112.59 76.39,112.43 76.55,112.43 76.83,112.71 76.99,112.71 79.35,110.36 83.91,110.36 84.6,111.06 85.59,111.06 86,110.64 86.36,110.64 86.84,110.16 87.16,110.16 87.65,109.66 87.65,109.39 v2(87.95,109.1)
HPS_GPIO5: length 81.5
  TOP w0.109: J5.8 52.11,146.4 50.54,144.83 50.54,144.42 v2(50.16,144.04)
  ART20 w0.114: v2(87.08,110.6) 86.61,110.13 86.61,109.94 86.38,109.71 86.06,109.71 85.48,109.13 84.33,109.13 84.22,109.02 84.22,108.57 84.1,108.46 83.87,108.46 83.76,108.57 83.76,109.1 83.65,109.22 83.42,109.22 83.3,109.1 83.3,108.57 83.19,108.46 82.96,108.46 82.85,108.57 82.85,109.1 82.73,109.22 82.5,109.22 82.39,109.1 82.39,108.57 82.27,108.46 82.05,108.46 81.93,108.57 81.93,109.1 81.82,109.22 81.59,109.22 81.47,109.1 81.47,108.57 81.36,108.46 81.13,108.46 81.02,108.57 81.02,109.1 80.9,109.22 80.67,109.22 80.56,109.1 80.56,108.57 80.45,108.46 80.22,108.46 80.1,108.57 80.1,109.1 79.99,109.22 79.76,109.22 79.65,109.1 79.65,108.57 79.53,108.46 79.3,108.46 79.19,108.57 79.19,109.1 79.07,109.22 78.85,109.22 78.73,109.1 78.73,108.57 78.62,108.46 78.39,108.46 78.27,108.57 78.27,109.1 78.16,109.22 77.93,109.22 77.82,109.1 77.82,108.57 77.7,108.46 77.47,108.46 77.36,108.57 77.36,109.1 77.25,109.22 77.02,109.22 76.9,109.1 76.9,108.57 76.79,108.46 76.56,108.46 76.45,108.57 76.45,109.1 76.33,109.22 76.1,109.22 75.99,109.1 75.99,108.57 75.87,108.46 75.65,108.46 75.53,108.57 75.53,109.1 75.42,109.22 75.19,109.22 75.07,109.1 75.07,108.57 74.96,108.46 74.73,108.46 74.62,108.57 74.62,109.1 74.5,109.22 71.24,109.22 68.7,111.76 67.03,111.76 62.24,116.55 62.24,122.36 55.85,128.75 55.85,134.7 51.59,138.96 51.59,139.21 50.77,140.03 50.77,143.43 50.46,143.75 50.46,143.75 v2(50.16,144.04)
HPS_GPIO6: length 83.3
  TOP w0.109: J5.9 51.61,154.23 51.18,153.8 v2(50.77,153.8)
  ART18 w0.114: v2(88.81,109.6) 88.75,109.67 88.75,109.98 88.17,110.55 87.77,110.55 87.16,111.16 86.75,111.16 86.31,111.61 86.02,111.61 85.51,112.12 84.8,112.12 83.93,111.25 79.47,111.25 78.9,111.82 78.9,111.99 79.25,112.33 79.25,112.49 79.09,112.66 78.92,112.66 78.58,112.31 78.42,112.31 77.56,113.16 77.56,113.32 77.78,113.54 77.78,113.71 77.62,113.87 77.46,113.87 77.24,113.65 77.08,113.65 76.92,113.81 76.92,113.97 77.13,114.19 77.13,114.35 76.97,114.51 76.81,114.51 76.59,114.29 76.43,114.29 75.75,114.98 75.6,114.98 74.39,116.18 74.39,117.6 73.33,118.66 69.52,118.66 61.46,126.72 52.45,126.72 45.95,133.21 45.95,141.43 46.71,142.18 46.71,143.91 47.72,144.93 47.72,145.29 48.49,146.05 48.49,146.43 52.11,150.06 52.11,152.45 v2(50.77,153.8)
HPS_GPIO7: length 82.4
  TOP w0.109: v2(50.04,144.8) 50.04,144.93 51.61,146.51 J5.10
  ART20 w0.114: v2(50.04,144.8) 51.29,143.55 51.29,140.32 52.01,139.6 52.01,139.13 56.27,134.87 56.27,134.69 56.27,129.24 56.96,128.55 57.13,128.55 57.41,128.83 57.57,128.83 57.74,128.67 57.74,128.51 57.45,128.22 57.45,128.06 57.61,127.9 57.77,127.9 58.06,128.19 58.22,128.19 58.38,128.03 58.38,127.86 58.1,127.58 58.1,127.42 58.26,127.25 58.42,127.25 58.71,127.54 58.87,127.54 59.03,127.38 59.03,127.22 58.74,126.93 58.74,126.77 58.9,126.61 59.06,126.61 59.35,126.89 59.51,126.89 59.67,126.73 59.67,126.57 59.39,126.28 59.39,126.12 59.55,125.96 59.71,125.96 60,126.25 60.16,126.25 60.32,126.09 60.32,125.92 60.03,125.64 60.03,125.48 60.2,125.31 60.36,125.31 60.64,125.6 60.81,125.6 60.97,125.44 60.97,125.28 60.68,124.99 60.68,124.83 60.84,124.67 61,124.67 61.29,124.95 61.45,124.95 61.61,124.79 61.61,124.63 61.33,124.34 61.33,124.18 61.49,124.02 61.65,124.02 61.94,124.31 62.1,124.31 62.26,124.15 62.26,123.98 61.97,123.7 61.97,123.54 62.7,122.82 62.7,116.98 67.42,112.26 68.92,112.26 71.45,109.73 72.54,109.73 72.66,109.84 72.66,110.07 72.77,110.18 73,110.18 73.12,110.07 73.12,109.84 73.23,109.73 73.46,109.73 73.57,109.84 73.57,110.07 73.69,110.18 73.92,110.18 74.03,110.07 74.03,109.84 74.14,109.73 74.37,109.73 74.49,109.84 74.49,110.07 74.6,110.18 74.83,110.18 74.94,110.07 74.94,109.84 75.06,109.73 75.29,109.73 75.4,109.84 75.4,110.07 75.52,110.18 75.74,110.18 75.86,110.07 75.86,109.84 75.97,109.73 76.2,109.73 76.32,109.84 76.32,110.07 76.43,110.18 76.66,110.18 76.77,110.07 76.77,109.84 76.89,109.73 77.12,109.73 77.23,109.84 77.23,110.07 77.34,110.18 77.57,110.18 77.69,110.07 77.69,109.84 77.8,109.73 78.03,109.73 78.14,109.84 78.14,110.07 78.26,110.18 78.49,110.18 78.6,110.07 78.6,109.84 78.72,109.73 78.95,109.73 79.06,109.84 79.06,110.07 79.17,110.18 79.4,110.18 79.52,110.07 79.52,109.84 79.63,109.73 79.86,109.73 79.97,109.84 79.97,110.07 80.09,110.18 80.32,110.18 80.43,110.07 80.43,109.84 80.55,109.73 80.77,109.73 80.89,109.84 80.89,110.07 81,110.18 81.23,110.18 81.35,110.07 81.35,109.84 81.46,109.73 81.69,109.73 81.8,109.84 81.8,110.07 81.92,110.18 82.15,110.18 82.26,110.07 82.26,109.84 82.37,109.73 82.6,109.73 82.72,109.84 82.72,110.07 82.83,110.18 83.06,110.18 83.17,110.07 83.17,109.84 83.29,109.73 83.52,109.73 83.63,109.84 83.63,110.07 83.75,110.18 83.97,110.18 84.09,110.07 84.09,109.84 84.2,109.73 84.81,109.73 85.28,110.2 85.56,110.2 86.21,110.85 v2(86.21,111.1)
HPS_GPIO8: length 79.1
  TOP w0.109: v2(49.76,153.92) 50.14,154.3 51,154.3 51.11,154.41 J5.11
  ART18 w0.114: v2(49.76,153.92) 49.76,153 49.14,152.38 49.14,149.62 46.96,147.45 46.96,146.68 45.85,145.57 45.6,145.57 45.18,145.16 45.18,142.24 44.89,141.95 44.89,138.01 43.73,136.85 43.73,133.66 44.93,132.46 45.31,132.46 52.37,125.4 61.34,125.4 63.37,123.37 63.37,121.89 68.55,116.71 73,116.71 73.51,116.2 73.51,115.57 74.84,114.24 74.84,113.35 78.59,109.6 v2(85.35,109.6)
HPS_GPIO9: length 81.7
  TOP w0.109: v2(51.11,148.32) J5.12
  ART16 w0.114: v2(87.08,111.6) 87.08,111.9 86.62,112.36 85.35,113.17 85.04,113.17 78.99,113.66 78.33,113.66 76.02,115.97 75.49,115.97 74.54,116.58 73.21,117.92 72.04,118.62 71.7,119.2 71.24,119.68 70.52,120.19 69.7,121.05 69.7,121.56 69.58,121.67 69.05,121.67 68.93,121.79 68.93,122.02 69.05,122.13 69.58,122.13 69.7,122.24 69.7,122.47 69.58,122.59 69.05,122.59 68.93,122.7 68.93,122.93 69.05,123.04 69.58,123.04 69.7,123.16 69.7,123.57 69.37,123.9 69.21,123.9 68.42,123.1 68.26,123.1 68.09,123.27 68.09,123.43 68.88,124.22 68.88,124.38 68.72,124.54 68.56,124.54 67.77,123.75 67.61,123.75 67.45,123.91 67.45,124.07 68.24,124.87 68.24,125.03 68.08,125.19 67.91,125.19 67.12,124.4 66.96,124.4 66.8,124.56 66.8,124.72 67.59,125.51 67.59,125.67 67.43,125.84 67.27,125.84 66.48,125.04 66.32,125.04 66.15,125.21 66.15,125.37 66.94,126.16 66.94,126.32 66.77,126.49 66.18,126.49 66.06,126.38 66.06,125.97 65.95,125.86 65.72,125.86 65.61,125.97 65.61,126.38 65.49,126.49 65.25,126.49 62.89,128.85 62.89,139.93 63.14,140.18 63.14,140.84 61.98,142.01 60.86,142.01 57.84,145.03 57.38,145.03 56.17,146.24 56.01,146.24 55.53,145.77 55.37,145.77 55.21,145.93 55.21,146.09 55.68,146.56 55.68,146.73 55.52,146.89 55.36,146.89 54.89,146.41 54.73,146.41 54.56,146.58 54.56,146.74 55.04,147.21 55.04,147.37 54.88,147.53 54.71,147.53 54.24,147.06 54.08,147.06 53.92,147.22 53.92,147.38 54.39,147.86 54.39,148.02 54.09,148.32 53.39,148.32 53.27,148.2 53.27,147.69 53.16,147.57 52.93,147.57 52.82,147.69 52.82,148.2 52.7,148.32 52.47,148.32 52.36,148.2 52.36,147.69 52.24,147.57 52.02,147.57 51.9,147.69 51.9,148.2 51.79,148.32 v2(51.11,148.32)
HPS_GPIO10: length 83.3
  TOP w0.109: v2(51.92,157.48) 51.36,157.48 50.61,156.74 J5.13
  ART20 w0.114: v2(87.08,109.6) 87.5,110.02 87.5,120.75 87.22,121.03 86.84,121.03 86.21,121.67 86.08,121.67 79.35,128.4 77.32,128.4 68.91,136.8 68.91,145.31 66.56,147.66 66.56,147.82 66.97,148.23 66.97,148.4 66.81,148.56 66.64,148.56 66.23,148.15 66.07,148.15 65.91,148.31 65.91,148.47 66.32,148.88 66.32,149.04 66.16,149.2 66,149.2 65.59,148.79 65.43,148.79 65.26,148.96 65.26,149.12 65.67,149.53 65.67,149.69 65.51,149.85 65.35,149.85 64.94,149.44 64.78,149.44 64.62,149.6 64.62,149.76 65.03,150.17 65.03,150.34 64.87,150.5 64.7,150.5 64.29,150.09 64.13,150.09 63.97,150.25 63.97,150.41 64.38,150.82 64.38,150.98 64.22,151.14 64.06,151.14 63.65,150.73 63.49,150.73 63.32,150.9 63.32,151.06 63.73,151.47 63.73,151.63 63.57,151.79 63.41,151.79 63,151.38 62.84,151.38 62.68,151.54 62.68,151.7 63.09,152.11 63.09,153.29 55.85,160.53 52.75,160.53 51.92,159.69 v2(51.92,157.48)
HPS_GPIO11: length 78
  TOP w0.109: v2(51.05,146.56) 51.05,147.45 50.61,147.89 J5.14
  ART20 w0.114: v2(51.05,146.56) 51.05,146.53 52.94,144.64 52.94,144.54 53.06,144.42 53.06,144.06 53.17,143.94 53.45,143.94 53.57,143.83 53.57,143.6 53.45,143.49 53.17,143.49 53.06,143.37 53.06,143.14 53.17,143.03 53.45,143.03 53.57,142.92 53.57,142.69 53.45,142.57 53.17,142.57 53.06,142.46 53.06,142.11 53.31,141.86 53.47,141.86 54.18,142.57 54.38,142.57 54.52,142.43 54.52,142.27 53.79,141.54 53.79,141.38 53.95,141.22 54.12,141.22 54.54,141.64 54.7,141.64 54.83,141.51 54.83,141.28 54.44,140.89 54.44,140.73 54.6,140.57 54.79,140.57 55.57,141.35 55.91,141.35 56.28,140.97 56.28,140.79 55.42,139.92 55.42,139.75 55.91,139.26 56.07,139.26 56.7,139.89 56.9,139.89 57.36,139.43 57.36,139.22 56.75,138.61 56.75,138.45 57.92,137.28 58.28,137.28 59.21,136.34 59.21,136.1 59.09,135.99 58.38,135.99 58.27,135.87 58.27,135.64 58.38,135.53 58.91,135.53 59.03,135.42 59.03,134.41 59.14,134.3 59.38,134.3 59.5,134.18 59.5,133.96 59.38,133.84 59.14,133.84 59.03,133.73 59.03,133.5 59.14,133.38 59.38,133.38 59.5,133.27 59.5,133.04 59.38,132.93 59.14,132.93 59.03,132.81 59.03,132.51 59.21,132.33 59.21,131.59 65.07,125.73 65.07,125.42 64.69,125.04 64.69,119.18 65.38,118.49 65.54,118.49 65.76,118.71 65.92,118.71 66.08,118.55 66.08,118.38 65.86,118.16 65.86,118 66.03,117.84 66.19,117.84 66.41,118.06 66.57,118.06 66.73,117.9 66.73,117.74 66.51,117.52 66.51,117.36 66.67,117.19 66.83,117.19 67.05,117.41 67.22,117.41 67.38,117.25 67.38,117.09 67.16,116.87 67.16,116.71 67.32,116.55 67.48,116.55 67.7,116.77 67.86,116.77 68.02,116.61 68.02,116.44 67.8,116.22 67.8,116.06 68.3,115.57 70.2,115.57 70.71,115.06 73.12,115.06 73.63,114.55 73.63,113.41 74.94,112.1 v2(86.21,112.1)
HPS_GPIO12: length 84.6
  TOP w0.109: v2(50.77,157.86) 50.77,157.48 50.2,156.91 50.11,156.82 J5.15
  ART03 w0.114: v2(87.95,111.1) 87.94,111.1 86.92,111.1 86.41,111.61 86.03,111.61 85.54,112.09 84.41,112.09 80.84,115.66 78.91,115.95 78.33,115.95 76.03,118.25 74.91,118.25 73.11,120.05 71.88,120.67 71.63,120.93 71.63,121.51 69.5,123.63 69.5,125.7 70.04,126.24 70.04,126.4 69.88,126.56 69.72,126.56 69.18,126.02 69.02,126.02 68.86,126.19 68.86,126.35 69.39,126.88 69.39,127.05 69.23,127.21 69.07,127.21 68.53,126.67 68.37,126.67 68.21,126.83 68.21,126.99 68.75,127.53 68.75,127.69 68.59,127.85 68.42,127.85 67.89,127.32 67.73,127.32 67.56,127.48 67.56,127.64 68.1,128.18 68.1,128.34 67.94,128.5 67.78,128.5 67.24,127.96 67.08,127.96 66.92,128.13 66.92,128.29 67.45,128.82 67.45,128.99 67.29,129.15 67.13,129.15 66.59,128.61 66.43,128.61 66.27,128.77 66.27,128.93 66.81,129.47 66.81,129.63 66.65,129.79 66.48,129.79 65.95,129.26 65.79,129.26 65.62,129.42 65.62,129.58 66.16,130.12 66.16,130.28 66,130.44 65.84,130.44 65.3,129.9 65.14,129.9 64.98,130.07 64.98,130.23 65.51,130.76 65.51,130.93 65.35,131.09 65.19,131.09 64.65,130.55 64.49,130.55 64.11,130.93 64.11,143.25 62.13,145.23 62.13,145.57 61.41,146.29 61.07,146.29 58.61,148.75 56.12,148.75 54.02,150.85 54.02,152.4 53.19,153.24 53.19,154.02 52.33,154.87 52.33,157.85 52.16,158.03 50.94,158.03 v2(50.77,157.86)
HPS_GPIO13: length 75.8
  TOP w0.109: J5.16 50.15,149.92 v2(50.15,147.46)
  ART20 w0.114: v2(85.35,113.6) 84.93,113.6 84.87,113.66 75.06,113.66 74.65,114.07 74.65,115.32 73.38,116.59 73.38,117.52 72.94,117.96 69.85,117.96 66.27,121.54 66.27,125.75 61.13,130.89 61.13,131.05 61.59,131.51 61.59,131.67 61.43,131.83 61.27,131.83 60.81,131.37 60.63,131.37 60.37,131.63 60.37,132.12 60.49,132.24 61.45,132.24 61.57,132.35 61.57,132.58 61.45,132.69 60.46,132.69 60.35,132.81 60.35,133.04 60.46,133.15 61.34,133.15 61.45,133.26 61.45,133.49 61.34,133.61 60.46,133.61 60.35,133.72 60.35,133.95 60.46,134.06 61.4,134.06 61.47,134.14 61.47,134.45 61.4,134.52 60.46,134.52 60.35,134.64 60.35,134.86 60.46,134.98 61.34,134.98 61.45,135.09 61.45,135.32 61.34,135.44 60.46,135.44 60.34,135.57 60.34,136.61 59.46,137.49 59.46,137.65 59.87,138.06 59.87,138.22 59.71,138.38 59.55,138.38 59.14,137.97 58.97,137.97 58.75,138.19 58.75,139.03 58.87,139.14 59.67,139.14 59.79,139.26 59.79,139.49 59.67,139.6 58.47,139.6 58.2,139.87 58.2,140.59 58.89,141.28 58.89,141.52 58.76,141.64 58.6,141.64 58.06,141.1 57.58,141.1 57.37,141.31 57.37,142.2 57.2,142.37 57.2,143.41 56.72,143.89 54.96,143.89 54.29,144.57 54.29,145.1 54.02,145.37 53.63,145.37 53.58,145.32 53.53,145.32 51.43,147.42 50.19,147.42 v2(50.15,147.46)
HPS_GPIO14: length 85.4
  TOP w0.109: v2(49.69,158.39) 50.04,158.04 50.04,157.33 49.79,157.08 49.79,157.08 49.61,156.91 J5.17
  ART03 w0.114: v2(87.95,112.1) 86.88,112.1 86.36,112.62 85.95,112.62 85.52,113.05 84.43,113.05 80.95,116.53 79.41,116.71 78.22,117.22 75.93,119.51 75.11,119.51 74.74,119.87 74.58,119.87 74.31,119.61 74.15,119.61 73.98,119.77 73.98,119.93 74.25,120.2 74.25,120.36 74.09,120.52 73.93,120.52 73.66,120.25 73.5,120.25 73.34,120.41 73.34,120.58 73.61,120.84 73.61,121.01 72.24,122.37 72.08,122.37 71.82,122.12 71.66,122.12 71.49,122.28 71.49,122.44 71.75,122.7 71.75,123.32 70.94,124.13 70.78,124.13 70.41,123.76 70.25,123.76 70.08,123.92 70.08,124.08 70.46,124.45 70.46,124.61 70.15,124.92 70.15,125.35 70.79,125.98 70.79,126.29 65.25,131.83 65.25,144.17 62.05,147.37 61.79,147.37 61.35,146.94 61.19,146.94 61.03,147.1 61.03,147.26 61.53,147.76 61.53,147.92 61.36,148.08 61.2,148.08 60.7,147.58 60.54,147.58 60.38,147.74 60.38,147.91 60.88,148.4 60.88,148.57 60.72,148.73 60.56,148.73 60.06,148.23 59.9,148.23 59.73,148.39 59.73,148.55 60.23,149.05 60.23,149.21 60.07,149.37 59.91,149.37 59.41,148.88 59.25,148.88 59.09,149.04 59.09,149.2 59.59,149.7 59.59,149.86 59.42,150.02 59.26,150.02 58.76,149.52 58.6,149.52 58.44,149.68 58.44,149.84 58.94,150.34 58.94,150.51 58.78,150.67 58.62,150.67 58.12,150.17 57.96,150.17 57.8,150.33 57.8,150.49 58.29,150.99 58.29,151.15 58.13,151.31 57.97,151.31 57.47,150.81 57.31,150.81 54,154.12 53.67,154.12 52.75,155.05 52.75,158.17 52.47,158.44 49.75,158.44 v2(49.69,158.39)
HPS_GPIO15: length 75.6
  TOP w0.109: J5.18 49.61,148.29 v2(49.53,148.21)
  ART20 w0.114: v2(85.35,114.6) 82.03,114.6 81.92,114.71 81.92,115.33 81.78,115.47 81.57,115.47 81.46,115.35 81.46,114.71 81.34,114.6 81.12,114.6 81,114.71 81,116.09 80.89,116.2 80.66,116.2 80.54,116.09 80.54,114.71 80.43,114.6 80.19,114.6 79.49,115.29 79.49,115.46 80.11,116.07 80.11,116.23 79.97,116.37 79.76,116.37 79.17,115.78 79.01,115.78 78.84,115.95 77.83,115.95 77.71,115.84 77.71,115.71 77.6,115.6 77.37,115.6 77.26,115.71 77.26,116.22 77.14,116.33 76.91,116.33 76.8,116.22 76.8,115.71 76.69,115.6 76.46,115.6 76.34,115.71 76.34,115.84 76.23,115.95 75.54,115.95 74.23,117.26 74.23,118.07 72.67,119.63 72.08,119.63 71.97,119.52 71.97,119.11 71.85,119 71.62,119 71.51,119.11 71.51,119.52 71.4,119.63 69.82,119.63 67.28,122.17 67.28,126.01 62.94,130.35 62.94,136.78 62.47,137.26 62.32,137.26 62.2,137.37 62.2,137.6 62.32,137.71 62.6,137.71 62.71,137.83 62.71,138.06 62.6,138.17 62.19,138.17 62.08,138.29 62.08,138.51 62.19,138.63 62.6,138.63 62.71,138.74 62.71,139.13 62.5,139.33 62.34,139.33 61.9,138.89 61.74,138.89 61.58,139.05 61.58,139.21 62.31,139.95 62.31,140.13 62.2,140.24 61.97,140.24 61.65,140.56 61.65,141.02 60.29,142.38 60.29,143.18 60.04,143.43 59.88,143.43 59.65,143.2 59.39,143.2 59.21,143.38 59.21,143.54 59.41,143.73 59.41,143.9 59.19,144.11 59.02,144.11 58.91,144 58.66,144 58.44,144.22 58.44,144.38 58.66,144.6 58.66,144.76 58.5,144.92 58.34,144.92 58.12,144.7 57.96,144.7 57.8,144.87 57.8,145.03 58.02,145.25 58.02,145.41 57.86,145.57 57.69,145.57 57.47,145.35 57.31,145.35 57,145.67 55.67,145.67 54.37,146.98 53.91,146.98 52.12,148.77 50.09,148.77 v2(49.53,148.21)
HPS_GPIO16: length 85.3
  TOP w0.109: v2(49.58,157.58) 49.58,157.46 49.37,157.25 49.37,157.25 49.11,156.99 J5.19
  ART03 w0.114: v2(49.58,157.58) 50.34,157.58 51.38,156.54 51.38,152.51 51.5,152.4 52.75,152.4 53.21,151.94 53.21,151.01 55.85,148.36 55.85,147.96 56.31,147.5 57.85,147.5 62.24,143.11 62.24,142.16 63.35,141.05 63.35,130.56 63.83,130.07 63.83,129.91 63.23,129.31 63.23,129.15 63.39,128.98 63.55,128.98 64.15,129.58 64.32,129.58 64.48,129.42 64.48,129.26 63.88,128.66 63.88,128.5 64.04,128.34 64.2,128.34 64.8,128.94 64.96,128.94 65.12,128.78 65.12,128.61 64.52,128.01 64.52,127.85 64.68,127.69 64.85,127.69 65.45,128.29 65.61,128.29 65.77,128.13 65.77,127.97 65.17,127.37 65.17,127.21 65.33,127.04 65.49,127.04 66.09,127.65 66.25,127.65 66.45,127.45 66.45,127.29 65.87,126.72 65.87,126.56 66.03,126.39 66.2,126.39 66.77,126.97 66.93,126.97 67.09,126.81 67.09,126.65 66.52,126.07 66.52,125.91 66.68,125.75 66.84,125.75 67.42,126.32 67.58,126.32 67.75,126.15 67.75,125.99 67.12,125.36 67.12,125.2 67.28,125.04 67.45,125.04 68.07,125.67 68.23,125.67 68.86,125.04 68.86,122.6 70.72,120.74 70.85,120.58 72.83,119.69 75.28,117.25 75.56,116.98 76.03,116.98 78.2,114.81 80.24,114.81 84.02,111.02 85.57,111.02 85.93,110.67 86.31,110.67 86.76,110.21 87.42,110.21 87.81,110.6 v2(88.81,110.6)
HPS_GPIO17: length 73.6
  TOP w0.109: v2(48.51,148.21) 49.11,148.81 J5.20
  ART20 w0.114: v2(85.35,115.6) 85.19,115.44 83.16,115.44 81.17,117.42 80.34,117.42 80.21,117.55 80.21,118.2 80.07,118.34 79.84,118.34 79.72,118.22 79.72,117.5 79.61,117.39 79.38,117.39 79.27,117.5 79.27,118.12 79.13,118.26 77.88,118.26 77.74,118.12 77.74,117.59 77.63,117.47 77.4,117.47 77.28,117.59 77.28,118.25 77.17,118.36 76.94,118.36 76.83,118.25 76.83,117.59 76.71,117.47 76.48,117.47 76.37,117.59 76.37,118.12 76.25,118.24 75.54,118.24 73.12,120.65 73.12,121.28 72.62,121.79 70.08,121.79 69.6,122.27 69.6,122.43 69.9,122.73 69.9,122.9 69.74,123.06 69.58,123.06 69.28,122.75 69.12,122.75 68.95,122.91 68.95,123.08 69.26,123.38 69.26,123.54 69.1,123.7 68.93,123.7 68.63,123.4 68.47,123.4 68.3,123.57 68.3,126.47 63.86,130.91 63.86,140.74 63.59,141.01 63.59,141.17 63.87,141.46 63.87,141.66 63.73,141.8 63.57,141.8 63.31,141.55 63.15,141.55 61.78,142.91 61.78,143.07 62,143.29 62,143.46 61.5,143.96 61.34,143.96 61.12,143.74 60.91,143.74 60.82,143.83 60.82,143.99 60.95,144.12 60.95,144.28 60.79,144.45 60.62,144.45 60.5,144.32 60.34,144.32 60.13,144.53 60.13,144.69 60.37,144.93 60.37,145.09 60.21,145.25 60.04,145.25 59.82,145.03 59.66,145.03 59.5,145.19 59.5,145.36 59.72,145.58 59.72,145.74 59.56,145.9 59.4,145.9 59.18,145.68 58.97,145.68 58.7,145.95 58.7,146.16 58.88,146.34 58.88,146.5 58.72,146.66 58.56,146.66 58.38,146.48 58.22,146.48 58.04,146.66 56.92,146.66 56.83,146.57 56.32,146.57 56.21,146.68 56.21,146.7 56.09,146.81 55.85,146.81 54.71,147.95 54.2,147.95 52.47,149.68 49.35,149.68 48.51,148.84 v2(48.51,148.21)
HPS_GPIO18: length 90.6
  TOP w0.109: J5.21 v2(48.61,153.92)
  ART03 w0.114: v2(90.54,109.6) 90.52,109.63 89.53,109.63 89.05,110.11 88.6,110.11 88.14,109.65 87.78,109.65 87.26,109.12 86.93,109.12 86.47,109.58 86.09,109.58 85.53,110.13 82.8,110.13 81.08,111.86 75.69,111.86 74.14,113.41 74.14,114.57 73.39,115.32 68.81,115.32 63.5,120.62 63.5,126.66 60.95,129.21 60.95,130.78 61.06,130.9 61.9,130.9 62.01,131.01 62.01,131.24 61.9,131.35 61.06,131.35 60.95,131.47 60.95,131.7 61.06,131.81 61.9,131.81 62.01,131.93 62.01,132.15 61.9,132.27 61.06,132.27 60.95,132.38 60.95,132.61 61.06,132.73 61.9,132.73 62.01,132.84 62.01,133.07 61.9,133.18 61.06,133.18 60.95,133.3 60.95,133.53 61.06,133.64 61.9,133.64 62.01,133.76 62.01,133.98 61.9,134.1 61.06,134.1 60.95,134.21 60.95,134.44 61.06,134.56 61.9,134.56 62.01,134.67 62.01,134.9 61.9,135.01 61.06,135.01 60.95,135.13 60.95,135.36 61.06,135.47 61.78,135.47 61.98,135.66 61.98,135.81 61.86,135.93 61.06,135.93 60.95,136.04 60.95,136.27 61.06,136.38 61.9,136.38 62.01,136.5 62.01,136.73 61.9,136.84 61.06,136.84 60.95,136.96 60.95,137.18 61.06,137.3 61.9,137.3 62.01,137.41 62.01,137.64 61.9,137.76 61.06,137.76 60.66,138.16 60.66,143.66 57.92,146.39 56.39,146.39 51.69,151.09 50.67,151.09 50.39,151.37 50.39,152.14 v2(48.61,153.92)
HPS_GPIO19: length 74.6
  TOP w0.109: J5.22 48.61,151.33 48.92,151.64 v2(49.78,151.64)
  ART20 w0.114: v2(85.35,116.6) 85.06,116.89 83.99,116.89 79.22,121.67 75.54,121.67 72.88,124.32 70.85,124.32 70.08,125.09 70.08,126.87 69.75,127.2 69.75,127.36 70.09,127.71 70.09,127.87 69.93,128.03 69.77,128.03 69.42,127.68 69.26,127.68 69.1,127.85 69.1,128.01 69.45,128.35 69.45,128.52 69.29,128.68 69.12,128.68 68.78,128.33 68.62,128.33 68.45,128.49 68.45,128.65 68.8,129 68.8,129.16 68.64,129.32 68.48,129.32 68.13,128.98 67.97,128.98 67.81,129.14 67.81,129.3 68.15,129.65 68.15,129.81 67.99,129.97 67.83,129.97 67.49,129.62 67.32,129.62 67.16,129.79 67.16,129.95 67.51,130.29 67.51,130.46 67.35,130.62 67.18,130.62 66.84,130.27 66.68,130.27 66.52,130.43 66.52,130.59 66.86,130.94 66.86,131.1 66.7,131.26 66.54,131.26 66.19,130.92 66.03,130.92 65.87,131.08 65.87,131.24 66.21,131.59 66.21,131.75 66.05,131.91 65.89,131.91 65.55,131.56 65.38,131.56 65.13,131.82 65.13,143.63 63.85,144.91 63.33,144.91 63.11,144.69 62.77,144.69 62.53,144.94 62.53,145.08 62.27,145.33 62.27,146.44 62.26,146.46 62.26,146.5 59.66,149.1 59,149.1 58.88,149.21 58.88,149.62 58.77,149.73 58.54,149.73 58.42,149.62 58.42,149.21 58.31,149.1 58.08,149.1 57.97,149.21 57.97,150.51 57.85,150.62 57.62,150.62 57.51,150.51 57.51,149.21 57.4,149.1 55.85,149.1 55.6,149.35 54.71,149.35 54.31,149.75 54.31,149.91 54.59,150.19 54.59,150.36 54.43,150.52 54.27,150.52 53.99,150.24 53.82,150.24 52.93,151.13 50.29,151.13 v2(49.78,151.64)
HPS_GPIO20: length 91.7
  TOP w0.109: J5.23 48.11,154.06 v2(47.72,153.67)
  ART03 w0.114: v2(92.28,109.6) 92.27,109.6 91.34,109.6 90.79,109.05 90.37,109.05 89.93,108.61 89.43,108.61 88.98,109.07 88.58,109.07 88.06,108.55 87.68,108.55 87.35,108.21 86.92,108.21 86.5,108.64 86.44,108.64 86.44,108.64 86,108.64 85.59,109.05 82.45,109.05 80.66,110.85 75.96,110.85 73.06,113.75 68.72,113.75 67.48,114.99 67.32,114.99 66.76,114.44 66.6,114.44 66.44,114.6 66.44,114.76 67,115.31 67,115.47 66.83,115.64 66.67,115.64 66.12,115.08 65.96,115.08 65.79,115.24 65.79,115.41 66.35,115.96 66.35,116.12 66.19,116.28 66.03,116.28 65.47,115.73 65.31,115.73 65.15,115.89 65.15,116.05 65.7,116.61 65.7,116.77 65.54,116.93 65.38,116.93 64.82,116.38 64.66,116.38 64.5,116.54 64.5,116.7 65.06,117.25 65.06,117.41 64.89,117.58 64.73,117.58 64.18,117.02 64.02,117.02 63.85,117.18 63.85,117.35 64.41,117.9 64.41,118.06 64.25,118.22 64.09,118.22 63.53,117.67 63.37,117.67 63.21,117.83 63.21,117.99 63.76,118.55 63.76,118.71 63.6,118.87 63.44,118.87 62.88,118.32 62.72,118.32 62.56,118.48 62.56,118.64 63.12,119.19 63.12,119.35 62.36,120.11 62.36,126.54 60.1,128.8 60.1,131.14 59.61,131.62 59.61,143.97 57.85,145.73 56.36,145.73 51.59,150.51 49.95,150.51 49.12,151.33 49.12,152.27 v2(47.72,153.67)
HPS_GPIO21: length 78.3
  TOP w0.109: J5.24 48.11,147.82 48.64,147.29 49.05,147.29 v2(49.53,146.81)
  ART20 w0.114: v2(49.53,146.81) 50.15,146.81 50.33,146.99 51.23,146.99 53.36,144.86 53.36,144.71 53.63,144.44 53.78,144.44 55.85,142.37 56.61,142.37 56.95,142.03 56.95,140.43 58.27,139.12 58.27,137.92 59.92,136.27 59.92,131.49 65.76,125.65 65.76,120.14 65.63,120.01 65.63,119.76 65.81,119.58 65.97,119.58 66.7,120.31 66.86,120.31 67.02,120.15 67.02,119.99 66.29,119.26 66.29,119.1 66.45,118.94 66.61,118.94 67.34,119.67 67.5,119.67 67.67,119.5 67.67,119.34 66.94,118.61 66.94,118.45 67.1,118.29 67.26,118.29 67.99,119.02 68.15,119.02 68.31,118.86 68.31,118.7 67.58,117.97 67.58,117.81 68.68,116.71 69.82,116.71 70.01,116.52 70.17,116.52 71.03,117.38 71.19,117.38 71.35,117.21 71.35,117.05 70.5,116.2 70.5,116.04 70.97,115.57 73.38,115.57 74.14,114.81 74.14,113.66 75.28,112.52 76.27,112.52 76.38,112.64 76.38,113.13 76.5,113.24 76.73,113.24 76.84,113.13 76.84,112.64 76.96,112.52 77.18,112.52 77.3,112.64 77.3,113.13 77.41,113.24 77.64,113.24 77.76,113.13 77.76,112.64 77.87,112.52 79.2,112.52 79.31,112.64 79.31,113.12 79.43,113.23 79.66,113.23 79.77,113.12 79.77,112.64 79.88,112.52 80.11,112.52 80.23,112.64 80.23,113.12 80.34,113.23 80.57,113.23 80.68,113.12 80.68,112.64 80.8,112.52 81.06,112.52 81.18,112.64 81.18,112.99 81.29,113.1 v2(86.21,113.1)
HPS_GPIO22: length 84.2
  TOP w0.109: J5.25 47.61,156.93 47.8,157.12 48.63,157.12 v2(48.77,157.25)
  ART20 w0.114: v2(88.81,111.6) 88.39,112.02 88.39,121.38 88.11,121.67 87.73,121.67 86.71,122.68 85.7,122.68 79.47,128.9 77.57,128.9 74.69,131.79 74.69,131.95 74.97,132.23 74.97,132.39 74.81,132.55 74.65,132.55 74.36,132.27 74.2,132.27 74.04,132.43 74.04,132.59 74.32,132.88 74.32,133.04 74.16,133.2 74,133.2 73.72,132.92 73.56,132.92 73.39,133.08 73.39,133.24 73.68,133.52 73.68,133.69 73.51,133.85 73.35,133.85 73.07,133.56 72.91,133.56 72.75,133.73 72.75,133.89 73.03,134.17 73.03,134.33 72.87,134.49 72.71,134.49 72.42,134.21 72.26,134.21 72.1,134.37 72.1,134.53 72.38,134.82 72.38,134.98 72.22,135.14 72.06,135.14 71.78,134.86 71.62,134.86 71.45,135.02 71.45,135.18 71.74,135.46 71.74,135.63 71.58,135.79 71.41,135.79 71.13,135.5 70.97,135.5 70.81,135.67 70.81,135.83 71.09,136.11 71.09,136.27 70.93,136.43 70.77,136.43 70.48,136.15 70.32,136.15 69.34,137.13 69.34,147.88 56.16,161.06 52.5,161.06 50.87,159.43 50.87,159.03 50.21,158.37 50.21,157.48 49.88,157.15 48.87,157.15 v2(48.77,157.25)
HPS_GPIO23: length 76.9
  TOP w0.109: v2(47.61,147.24) J5.26
  ART20 w0.114: v2(86.21,114.1) 79.96,114.1 79.12,114.93 75.54,114.93 75.16,115.32 75.16,115.7 73.81,117.04 73.81,117.68 72.97,118.52 70.18,118.52 66.77,121.92 66.77,125.88 62.26,130.4 62.26,132.87 61.89,133.23 61.89,135.67 61.59,135.97 61.59,136.39 62,136.79 62,136.96 61.84,137.11 61.68,137.11 61.15,136.59 60.97,136.59 60.83,136.73 60.83,136.91 61.71,137.79 61.71,137.98 61.56,138.13 61.4,138.13 60.67,137.4 60.51,137.4 60.3,137.62 60.3,138.05 61.08,138.83 61.08,139.07 60.96,139.18 60.36,139.18 60.22,139.32 60.22,139.5 60.36,139.64 60.88,139.64 61,139.75 61,140.01 60.48,140.53 60.48,140.69 60.82,141.03 60.82,141.19 60.65,141.35 60.49,141.35 60.11,140.97 59.94,140.97 59.78,141.13 59.78,141.29 60.18,141.69 60.18,141.85 60.02,142.01 59.86,142.01 59.51,141.66 59.35,141.66 59.05,141.96 59.05,142.21 57.59,143.68 57.59,143.97 57.76,144.14 57.76,144.31 57.6,144.47 57.44,144.47 57.2,144.23 57.04,144.23 56.87,144.4 55.22,144.4 54.71,144.91 54.71,145.27 54.53,145.45 54.83,145.76 54.83,145.92 54.67,146.08 54.51,146.08 54.2,145.77 54.19,145.79 53.7,145.79 53.3,146.18 53.3,146.35 53.52,146.57 53.52,146.73 53.36,146.89 53.2,146.89 52.98,146.67 52.82,146.67 52.66,146.83 52.66,146.99 52.88,147.21 52.88,147.37 52.71,147.54 52.55,147.54 52.33,147.32 52.17,147.32 51.61,147.88 50.33,147.88 50.32,147.88 49.98,147.88 49.97,147.88 49.85,147.88 49.21,147.24 48.75,147.24 48.63,147.13 48.63,146.54 48.52,146.43 48.29,146.43 48.18,146.54 48.18,147.13 48.06,147.24 v2(47.61,147.24)
HPS_GPIO24: length 85.6
  TOP w0.109: v2(49.77,159.27) 48.03,157.53 47.63,157.53 47.11,157.02 J5.27
  ART20 w0.114: v2(89.68,111.1) 90.11,111.53 90.11,123.72 88.24,125.59 88.24,128.4 80.05,136.59 79.88,136.59 79.41,136.11 79.25,136.11 79.09,136.28 79.09,136.44 79.56,136.91 79.56,137.07 79.4,137.23 79.24,137.23 78.76,136.76 78.6,136.76 78.44,136.92 78.44,137.08 78.91,137.56 78.91,137.72 78.71,137.92 71.22,137.92 70.33,138.81 70.33,148.21 56.46,162.08 52.17,162.08 49.77,159.68 v2(49.77,159.27)
HPS_GPIO25: length 73.4
  TOP w0.109: J5.28 47.11,151.41 v2(47.14,151.43)
  ART20 w0.114: v2(85.35,118.6) 84.93,118.6 79.22,124.31 79.22,124.71 78.84,125.09 77.32,125.09 76.3,126.11 74.78,126.11 73.72,127.17 73.72,127.33 74.06,127.68 74.06,127.84 73.9,128 73.74,128 73.39,127.65 73.23,127.65 73.07,127.81 73.07,127.98 73.42,128.32 73.42,128.48 73.26,128.65 73.09,128.65 72.75,128.3 72.59,128.3 72.42,128.46 72.42,128.62 72.77,128.97 72.77,129.13 72.61,129.29 72.45,129.29 72.1,128.95 71.94,128.95 71.78,129.11 71.78,129.27 72.12,129.62 72.12,129.78 71.96,129.94 71.8,129.94 71.45,129.59 71.29,129.59 71.13,129.75 71.13,129.92 71.48,130.26 71.48,130.42 71.32,130.58 71.15,130.58 70.81,130.24 70.65,130.24 70.48,130.4 70.48,130.56 70.83,130.91 70.83,131.07 70.67,131.23 70.51,131.23 70.16,130.89 70,130.89 69.84,131.05 69.84,131.21 70.18,131.55 70.18,131.72 70.02,131.88 69.86,131.88 69.51,131.53 69.35,131.53 69.19,131.69 69.19,131.86 69.54,132.2 69.54,132.36 69.38,132.52 69.21,132.52 68.87,132.18 68.71,132.18 68.54,132.34 68.54,132.5 68.89,132.85 68.89,133.01 68.73,133.17 68.57,133.17 68.22,132.82 68.06,132.82 67.9,132.99 67.9,133.15 68.24,133.49 68.24,133.66 68.08,133.82 67.92,133.82 67.58,133.47 67.41,133.47 67.25,133.63 67.25,133.79 67.6,134.14 67.6,134.3 67.44,134.46 67.27,134.46 66.93,134.12 66.77,134.12 66.6,134.29 66.6,144.19 58.85,151.94 54.04,151.94 53.06,152.92 49.18,152.92 47.7,151.43 v2(47.14,151.43)
HPS_GPIO26: length 85.8
  TOP w0.109: J5.29 46.61,157.21 v2(46.66,157.25)
  ART20 w0.114: v2(89.68,112.1) 89.28,112.5 89.28,121.76 88.36,122.68 88.36,123.57 86.71,125.22 86.71,127.63 85.04,129.31 85.04,129.47 85.39,129.81 85.39,129.98 85.23,130.14 85.06,130.14 84.72,129.79 84.56,129.79 84.39,129.95 84.39,130.11 84.74,130.46 84.74,130.62 84.58,130.78 84.42,130.78 84.07,130.44 83.91,130.44 83.75,130.6 83.75,130.76 84.09,131.11 84.09,131.27 83.93,131.43 83.77,131.43 83.42,131.08 83.26,131.08 83.1,131.25 83.1,131.41 83.45,131.75 83.45,131.92 83.29,132.08 83.12,132.08 82.78,131.73 82.62,131.73 82.45,131.89 82.45,132.05 82.8,132.4 82.8,132.56 79.98,135.38 78.97,135.38 77.19,137.16 70.97,137.16 69.77,138.35 69.77,148.13 56.31,161.59 52.42,161.59 50.35,159.52 50.35,159.14 50.01,158.8 49.08,158.8 48.51,158.23 48.35,158.23 47.51,157.39 46.8,157.39 v2(46.66,157.25)
HPS_GPIO27: length 70.6
  TOP w0.109: v2(46.2,152.02) 46.61,151.6 J5.30
  ART20 w0.114: v2(46.2,152.02) 46.96,152.78 47.47,152.78 48.14,153.45 48.14,154.08 48.61,154.56 52.68,154.56 52.77,154.46 52.79,154.46 53.24,154.01 53.99,154.01 54.66,153.33 54.71,153.33 55.23,153.33 55.34,153.45 55.34,153.94 55.46,154.05 55.69,154.05 55.8,153.94 55.8,153.45 55.91,153.33 56.14,153.33 56.26,153.45 56.26,153.94 56.37,154.05 56.6,154.05 56.71,153.94 56.71,153.45 56.83,153.33 57.06,153.33 57.17,153.45 57.17,153.94 57.29,154.05 57.51,154.05 57.63,153.94 57.63,153.45 57.74,153.33 58.98,153.33 67.46,144.86 67.46,136.35 71.83,131.98 71.83,131.81 71.67,131.66 71.67,131.5 71.84,131.34 72,131.34 72.15,131.49 72.31,131.49 72.48,131.33 72.48,131.17 72.32,131.01 72.32,130.85 72.48,130.69 72.64,130.69 72.8,130.84 72.96,130.84 73.12,130.68 73.12,130.52 72.97,130.37 72.97,130.2 73.13,130.04 73.29,130.04 73.45,130.2 73.61,130.2 73.77,130.04 73.77,129.87 73.61,129.72 73.61,129.56 73.78,129.4 73.94,129.4 74.09,129.55 74.25,129.55 74.42,129.39 74.42,129.23 74.26,129.07 74.26,128.91 74.42,128.75 74.58,128.75 74.74,128.9 74.9,128.9 75.06,128.74 75.06,128.58 74.91,128.43 74.91,128.26 75.07,128.1 75.23,128.1 75.39,128.26 75.55,128.26 75.71,128.1 75.71,127.93 75.55,127.78 75.55,127.62 75.72,127.46 75.88,127.46 76.03,127.61 76.19,127.61 77.19,126.62 78.97,126.62 80.36,125.22 80.36,124.46 84.93,119.89 85.06,119.89 v2(85.35,119.6)
HPS_GPIO28: length 85.1
  TOP w0.109: J5.31 46.11,157.35 46.35,157.59 R76.1 46.95,158.65 v2(47.04,158.65)
  ART20 w0.114: v2(47.04,158.65) 48.08,158.65 52.02,162.58 56.59,162.58 70.97,148.21 70.97,139.32 71.73,138.56 78.84,138.56 90.4,127 90.4,125.86 90.98,125.27 90.98,111.05 v2(90.54,110.61)
HPS_GPIO28_R: length 227.1
  TOP w0.109: R76.2 46.65,158.94 46.78,159.08 47.26,159.08 47.39,158.94 R82.1 47.75,159.59 v2(47.88,159.71)
  ART07 w0.114: v2(171.68,144.91) 163.81,144.91 161.56,147.15 160.31,147.15 160.25,147.22 157.54,147.22 156.24,148.52 156.24,149.29 155.95,149.58 154.89,149.58 154.75,149.72 154.75,150.78 153.39,152.14 153.39,152.4 152.91,152.88 145.13,152.88 144.53,152.27 136.91,152.27 135.51,153.67 133.6,153.67 129.59,157.68 118.09,157.68 117.36,158.41 110.45,158.41 104.39,164.47 101.09,164.47 98.81,162.18 98.81,158.88 97.93,158 64.36,158 64.24,157.89 64.24,156.76 64.13,156.65 63.9,156.65 63.79,156.76 63.79,157.87 63.67,157.99 63.44,157.99 63.33,157.87 63.33,156.76 63.22,156.65 62.99,156.65 62.87,156.76 62.87,157.87 62.76,157.99 62.53,157.99 62.42,157.87 62.42,156.76 62.3,156.65 62.07,156.65 61.96,156.76 61.96,157.87 61.84,157.99 61.62,157.99 61.5,157.87 61.5,156.76 61.39,156.65 61.16,156.65 61.04,156.76 61.04,157.87 60.93,157.99 60.57,157.99 60.45,157.87 60.45,156.65 60.34,156.54 60.11,156.54 60,156.65 60,157.87 59.88,157.99 59.65,157.99 59.54,157.87 59.54,156.65 59.42,156.54 59.2,156.54 59.08,156.65 59.08,157.87 58.97,157.99 58.72,157.99 58.61,157.87 58.61,156.6 58.49,156.49 58.27,156.49 58.15,156.6 58.15,157.87 58.04,157.99 57.8,157.99 57.68,157.87 57.68,157.47 57.57,157.35 57.36,157.35 57.22,157.49 57.22,158.38 57.11,158.5 55.78,158.5 55.12,159.16 51.69,159.16 51.13,159.71 50.27,159.71 50.15,159.83 50.15,161.61 50.04,161.72 49.81,161.72 49.7,161.61 49.7,159.83 49.58,159.71 49.35,159.71 49.24,159.83 49.24,161.61 49.13,161.72 48.9,161.72 48.78,161.61 48.78,159.83 48.67,159.71 v2(47.88,159.71)
  ART20 w0.114: v2(177.07,93.58) 177.14,93.65 179.14,93.65 180.37,94.89 180.37,95.34 180.76,95.73 180.76,104.78 180.38,105.15 180.38,105.63 178.53,107.48 178.53,119.8 176.54,121.8 176.54,125.01 174.26,127.29 174.26,128.11 173.8,128.57 172.03,128.57 171.55,129.05 171.55,133.73 170.91,134.37 170.91,136.4 171.42,136.91 171.42,144.65 v2(171.68,144.91)
HPS_GPIO29: length 74.2
  TOP w0.109: J5.32 46.11,146.9 46.27,146.75 R75.1 46.86,147.18 47.11,147.44 v2(47.11,148.41)
  ART20 w0.114: v2(47.11,148.41) 47.41,148.7 47.71,148.7 49.15,150.14 52.65,150.14 54.33,148.46 55.09,148.46 56,147.55 58.32,147.55 58.44,147.43 58.44,147.21 58.55,147.09 58.78,147.09 58.89,147.21 58.89,147.43 59.01,147.55 59.46,147.55 60.11,146.9 60.11,146.58 59.87,146.34 59.87,146.18 60.03,146.02 60.2,146.02 60.44,146.26 60.6,146.26 60.76,146.09 60.76,145.93 60.52,145.69 60.52,145.53 60.79,145.26 60.79,145.05 61.46,144.38 61.67,144.38 62.44,143.61 62.66,143.61 62.85,143.8 63.21,143.8 63.73,143.28 63.73,143.05 63.16,142.48 63.16,142.34 63.27,142.23 63.46,142.23 64.04,142.8 64.19,142.8 64.29,142.7 64.29,131.3 64.44,131.15 64.44,131.09 68.79,126.73 68.79,124.6 70.97,122.43 72.87,122.43 73.63,121.66 73.63,121.03 75.41,119.25 76.25,119.25 76.37,119.14 76.37,118.83 76.48,118.72 76.69,118.72 76.83,118.86 76.83,119.26 76.97,119.4 77.17,119.4 77.28,119.29 77.28,118.83 77.4,118.72 77.6,118.72 77.74,118.86 77.74,119.14 77.85,119.25 80.11,119.25 83.37,115.99 85.69,115.99 85.8,116.1 v2(86.21,116.1)
HPS_GPIO29_R: length 223.3
  TOP w0.109: R75.2 R83.1 v2(48.26,145.16)
  ART07 w0.114: v2(172.17,144.32) 172.1,144.39 163.73,144.39 162.11,146.01 157.13,146.01 156.86,146.28 156.86,146.62 156.65,146.83 155.25,146.83 154.93,147.15 154.93,148.63 153.23,150.33 153.23,151.08 152.97,151.34 149.78,151.34 149.35,151.76 136.78,151.76 136.14,152.4 134.11,152.4 129.29,157.23 117.35,157.23 116.65,157.93 105.98,157.93 104.65,156.59 101.47,156.59 101.35,156.72 100.84,156.72 100.06,157.49 66.19,157.49 63.54,154.84 63.38,154.84 62.38,155.84 62.22,155.84 62.05,155.68 62.05,155.52 63.75,153.82 63.75,153.66 63.58,153.5 63.42,153.5 61.73,155.19 61.57,155.19 61.41,155.03 61.41,154.87 63.1,153.18 63.1,153.02 62.94,152.85 62.78,152.85 61.08,154.55 60.92,154.55 60.76,154.38 60.76,154.22 62.52,152.47 62.52,152.31 62.36,152.15 62.2,152.15 60.44,153.9 60.28,153.9 60.11,153.74 60.11,153.58 61.49,152.2 61.49,152.04 61.34,151.89 61.18,151.89 59.82,153.25 59.63,153.25 59.47,153.09 59.47,152.93 60.47,151.93 60.47,151.77 60.31,151.61 60.14,151.61 59.14,152.61 58.98,152.61 58.82,152.44 58.82,152.28 59.82,151.28 59.82,151.12 57.19,148.49 54.28,148.49 51.46,145.67 49.91,145.67 49.4,145.16 v2(48.26,145.16)
  ART20 w0.114: v2(172.17,144.32) 172.17,131.49 176.96,126.7 176.96,121.97 178.98,119.95 178.98,109.92 182.14,106.76 182.14,105.08 181.18,104.11 181.18,95.55 180.79,95.17 180.79,94.71 179.29,93.21 177.39,93.21 177.07,92.89 v2(177.07,92.78)
HPS_GPIO30: length 307.9
  TOP w0.089: U29.V8 v2(177.87,92.78)
  TOP w0.109: J5.33 45.61,157.65 v2(45.21,158.05) ; U29.V8 178.19,92.46 R493.2
  ART03 w0.114: v2(137.56,162.81) 137.56,162.79 139.21,161.14 169.29,161.14 v2(170.84,159.59)
  ART16 w0.114: v2(90.54,111.6) 90.14,112 90.14,115.23 89.99,115.38 88.14,116.52 87.98,116.52 85.42,118.11 85.27,118.11 82.88,119.05 78.62,120.52 78.39,120.57 78.25,120.71 77.32,121.96 76.07,123.74 75.54,123.98 75.52,123.98 70.61,128.27 66.55,132.33 66.55,141.96 65.99,142.52 65.99,142.68 66.53,143.21 66.53,143.38 66.36,143.54 66.2,143.54 65.67,143 65.5,143 65.34,143.16 65.34,143.32 65.88,143.86 65.88,144.02 65.72,144.18 65.56,144.18 65.02,143.65 64.86,143.65 64.7,143.81 64.7,143.97 65.23,144.51 65.23,144.67 65.07,144.83 64.91,144.83 64.37,144.29 64.21,144.29 64.05,144.46 64.05,144.62 64.59,145.15 64.59,145.32 64.42,145.48 64.26,145.48 63.73,144.94 63.56,144.94 63.4,145.1 63.4,145.26 63.86,145.72 63.86,145.88 63.41,146.33 62.94,146.33 62.65,146.04 62.47,146.04 59.28,149.22 56.63,149.22 56.52,149.2 56.34,149.2 56.23,149.22 54.71,149.22 53.19,150.75 49.12,150.75 45.21,154.66 v2(45.21,158.05)
  ART18 w0.114: v2(45.21,158.05) 45.21,158.29 48.09,161.16 48.34,161.16 48.46,161.05 48.46,159.07 48.57,158.95 48.8,158.95 48.92,159.07 48.92,161.05 49.03,161.16 49.27,161.16 49.38,161.05 49.38,159.8 49.5,159.69 49.73,159.69 49.84,159.8 49.84,161.05 49.96,161.16 50.19,161.16 50.3,161.05 50.3,159.73 50.41,159.61 50.64,159.61 50.76,159.73 50.76,161.05 50.87,161.16 51.1,161.16 51.21,161.05 51.21,159.73 51.33,159.61 51.56,159.61 51.67,159.73 51.67,161.05 51.79,161.16 55.24,161.16 58.6,157.81 97.69,157.81 99.84,155.65 104.9,155.65 107.45,158.2 131.15,158.2 133.25,160.3 135.41,160.3 137.27,162.16 137.27,162.52 v2(137.56,162.81)
  ART20 w0.114: v2(177.87,92.78) 179.49,92.78 181.07,94.36 181.45,94.36 181.77,94.67 181.77,104.11 182.56,104.9 182.56,105.99 183.23,106.66 183.23,107.26 182.41,108.08 181.83,108.08 179.4,110.51 179.4,120.12 177.44,122.08 177.44,126.82 173.74,130.53 173.74,135.25 172.59,136.4 172.59,148.92 171.68,149.83 171.68,158.75 v2(170.84,159.59)
