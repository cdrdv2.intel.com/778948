# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MEM_DQB21: length 74.5
  TOP w0.109: v2(102.07,52.12) CON1.212
  ART07 w0.114: v2(102.07,52.12) 102.02,52.18 102.02,53.05 102.13,53.16 103.47,53.16 103.59,53.28 103.59,53.5 103.47,53.62 102.13,53.62 102.02,53.73 102.02,53.97 101.9,54.09 101.31,54.09 101.11,54.29 101.11,55.14 101.23,55.25 103.36,55.25 103.47,55.37 103.47,55.59 103.36,55.71 101.23,55.71 101.11,55.82 101.11,56.05 101.23,56.17 104.48,56.17 104.59,56.28 104.59,56.51 104.48,56.62 101.23,56.62 101.11,56.74 101.11,56.97 101.23,57.08 104.2,57.08 104.32,57.19 104.32,57.42 104.2,57.54 101.23,57.54 101.11,57.65 101.11,57.88 101.23,57.99 103.42,57.99 103.54,58.11 103.54,58.34 103.42,58.45 101.23,58.45 101.11,58.57 101.11,58.79 101.23,58.91 102.38,58.91 102.5,59.02 102.5,59.25 102.38,59.37 101.23,59.37 101.11,59.48 101.11,60.03 101.23,60.15 101.23,60.57 101.78,61.11 101.78,61.39 101.66,61.5 101.12,61.5 101.01,61.61 101.01,61.84 101.12,61.96 101.66,61.96 101.78,62.07 101.78,63.01 102,63.23 102,63.46 101.78,63.69 101.78,63.92 102,64.15 102,64.38 101.78,64.6 101.78,64.84 102,65.06 102,65.29 101.78,65.52 101.78,65.75 102,65.98 102,66.21 101.78,66.43 101.78,68.86 101.89,68.97 102.03,68.97 102.15,69.09 102.15,69.32 102.03,69.43 101.89,69.43 101.78,69.54 101.78,69.87 107.79,75.89 113.63,75.89 114.24,76.49 114.24,77.7 115.81,79.28 115.81,80.44 116.09,80.72 116.09,80.85 arc(116.16,81.1) 116.09,81.35 arc(116.02,81.6) 116.09,81.85 116.09,81.85 arc(116.16,82.1) 116.09,82.35 arc(116.02,82.6) 116.09,82.85 116.09,82.85 arc(116.16,83.1) 116.09,83.35 115.97,83.47 arc(115.93,83.51) 115.88,83.53 115.65,83.63 arc(115.48,83.73) 115.34,83.86 115.26,83.99 arc(115.05,84.31) v2(114.79,84.6)
MEM_DQB22: length 74.6
  TOP w0.109: v2(99.07,52.12) CON1.224
  ART07 w0.114: v2(111.33,83.6) 111.24,83.51 106.77,83.51 106.55,83.28 106.55,82.65 101.35,77.45 101.35,75.72 98.79,73.16 97.3,73.16 94.34,70.2 94.34,64.23 94.64,63.93 96.26,63.93 96.38,63.81 96.38,63.68 96.49,63.57 96.72,63.57 96.84,63.68 96.84,63.81 96.95,63.93 97.28,63.93 98.23,62.98 98.23,61.92 98.12,61.8 97.71,61.8 97.59,61.69 97.59,61.46 97.71,61.35 98.12,61.35 98.23,61.23 98.23,60.82 97.91,60.5 97.91,60.44 97.85,60.38 97.85,60.02 97.36,59.52 97.36,55.24 97.47,55.12 97.89,55.12 98.1,54.91 98.1,53.72 99.53,52.28 99.53,50.94 99.9,50.57 99.9,48.92 99.79,48.81 99.44,48.81 99.33,48.92 99.33,50.25 99.21,50.36 98.99,50.36 98.87,50.25 98.87,48.92 98.76,48.81 98.53,48.81 98.41,48.92 98.41,50.25 98.3,50.36 98.07,50.36 97.96,50.25 97.96,48.92 97.84,48.81 97.61,48.81 97.5,48.92 97.5,50.25 97.39,50.36 97.16,50.36 97.04,50.25 97.04,48.92 96.93,48.81 96.7,48.81 96.59,48.92 96.59,50.25 96.47,50.36 96.24,50.36 96.13,50.25 96.13,48.92 96.01,48.81 95.77,48.81 95.66,48.92 95.66,50.67 95.77,50.78 98.54,50.78 98.65,50.9 98.65,51.71 v2(99.07,52.12)
MEM_DQB23: length 75.6
  TOP w0.109: v2(98.65,62.74) 98.82,62.57 CON1.225
  ART07 w0.114: v2(98.65,62.74) 98.65,63.01 97.4,64.26 97.11,64.26 96.99,64.38 96.99,64.46 96.88,64.58 96.58,64.58 96.47,64.46 96.47,64.36 96.35,64.25 96.12,64.25 96.01,64.36 96.01,64.46 95.9,64.58 95.67,64.58 95.55,64.46 95.55,64.36 95.44,64.25 95.21,64.25 95.1,64.36 95.1,64.46 94.98,64.58 94.74,64.58 94.66,64.66 94.66,64.95 94.74,65.03 96.85,65.03 96.99,65.18 96.99,65.38 96.88,65.49 94.74,65.49 94.66,65.57 94.66,65.86 94.74,65.95 96.85,65.95 96.99,66.1 96.99,66.29 96.88,66.41 94.74,66.41 94.66,66.49 94.66,66.78 94.74,66.86 96.85,66.86 96.99,67.01 96.99,67.21 96.88,67.32 94.74,67.32 94.66,67.4 94.66,67.69 94.74,67.78 96.85,67.78 96.99,67.93 96.99,68.12 96.88,68.23 94.74,68.23 94.66,68.32 94.66,68.61 94.74,68.69 96.85,68.69 96.99,68.84 96.99,69.03 96.88,69.15 94.74,69.15 94.66,69.23 94.66,69.52 94.74,69.61 96.85,69.61 96.99,69.76 96.99,69.98 96.88,70.1 95.45,70.1 95.33,70.21 95.33,70.44 95.45,70.56 95.88,70.56 96,70.67 96,71.19 96.11,71.3 96.34,71.3 96.46,71.19 96.46,70.67 96.57,70.56 96.88,70.56 96.99,70.67 96.99,70.91 97.17,71.08 97.17,71.24 96.72,71.69 96.72,71.85 96.88,72.01 97.05,72.01 97.49,71.57 97.65,71.57 97.81,71.73 97.81,71.89 97.37,72.33 97.37,72.5 97.53,72.66 97.69,72.66 98.14,72.21 98.3,72.21 99.58,73.5 100.64,73.5 101.73,74.59 101.73,76.42 102.11,76.79 102.11,76.96 101.83,77.23 101.83,77.4 101.99,77.56 102.15,77.56 102.43,77.28 102.59,77.28 102.75,77.44 102.75,77.6 102.48,77.88 102.48,78.04 102.64,78.2 102.8,78.2 103.08,77.93 103.24,77.93 103.4,78.09 103.4,78.25 103.12,78.53 103.12,78.69 103.28,78.85 103.45,78.85 103.72,78.57 103.88,78.57 104.05,78.73 104.05,78.9 103.77,79.17 103.77,79.34 103.93,79.5 104.09,79.5 104.37,79.22 104.53,79.22 104.69,79.38 104.69,79.54 104.42,79.82 104.42,79.98 104.58,80.14 104.74,80.14 105.02,79.87 105.18,79.87 105.34,80.03 105.34,80.19 105.06,80.47 105.06,80.63 105.22,80.79 105.39,80.79 105.66,80.51 105.82,80.51 105.99,80.67 105.99,80.84 105.71,81.11 105.71,81.28 105.87,81.44 106.03,81.44 106.31,81.16 106.47,81.16 106.63,81.32 106.63,81.48 106.36,81.76 106.36,81.92 106.52,82.08 106.68,82.08 106.9,81.86 107.06,81.86 107.34,82.14 107.34,82.7 107.68,83.04 108.24,83.04 108.57,82.71 108.89,82.71 109.24,83.06 109.86,83.06 110.25,82.68 110.56,82.68 110.6,82.71 110.62,82.71 110.94,83.03 111.66,83.03 111.81,83.18 111.81,83.26 112.19,83.65 v2(112.19,84.1)
MEM_DQB24: length 70.3
  TOP w0.109: v2(95.82,62.68) CON1.237
  ART05 w0.114: v2(95.82,62.68) 95.82,62.39 95.91,62.3 96.28,62.3 96.39,62.41 96.39,63.87 96.54,64.02 97.86,64.02 97.97,63.91 97.97,63.26 98.09,63.15 98.32,63.15 98.43,63.26 98.43,63.91 98.54,64.02 101,64.02 102.49,65.51 102.49,65.67 100.72,67.44 100.72,67.88 107.57,74.73 108.56,74.73 114.31,74.73 114.43,74.84 114.43,75.08 114.3,75.21 109.51,75.21 109.36,75.35 109.36,75.53 109.5,75.67 114.31,75.67 114.43,75.78 114.43,76 114.31,76.11 110.42,76.11 110.3,76.22 110.3,76.45 110.42,76.57 114.31,76.57 114.43,76.68 114.43,76.91 114.31,77.02 111.35,77.02 111.23,77.14 111.23,77.35 111.36,77.48 114.31,77.48 114.43,77.6 114.43,77.82 114.31,77.94 112.22,77.94 112.11,78.05 112.11,78.28 112.23,78.4 114.31,78.4 114.43,78.51 114.43,78.72 114.31,78.84 113.11,78.84 112.97,78.98 112.97,79.14 113.13,79.3 114.19,79.3 114.38,79.48 114.38,82.19 v2(114.79,82.6)
MEM_DQB25: length 68.7
  TOP w0.109: v2(96.07,52.12) CON1.236
  ART05 w0.114: v2(115.66,82.1) 115.66,81.81 115.19,81.34 115.19,74.18 115.07,74.07 112.96,74.07 112.8,73.9 112.8,72.82 112.68,72.71 112.44,72.71 112.33,72.82 112.33,73.95 112.21,74.07 111.98,74.07 111.87,73.95 111.87,72.82 111.75,72.71 111.53,72.71 111.41,72.82 111.41,73.95 111.3,74.07 111.07,74.07 110.95,73.95 110.95,72.82 110.84,72.71 110.61,72.71 110.5,72.82 110.5,73.95 110.38,74.07 110.15,74.07 110.04,73.95 110.04,72.82 109.93,72.71 109.7,72.71 109.58,72.82 109.58,73.95 109.47,74.07 109.24,74.07 109.13,73.95 109.13,72.82 109.01,72.71 108.75,72.71 104.15,68.1 104.15,64.63 103.89,64.37 103.11,64.37 102.73,63.99 102.73,63.21 102.62,63.1 102.38,63.1 102.26,63.21 102.26,63.79 102.15,63.9 101.85,63.9 101.73,63.79 101.73,62.51 101.73,62.51 101.73,61.01 101.23,60.51 101.23,55.07 101.12,54.96 101.12,53.91 101.02,53.8 96.93,53.8 96.82,53.69 96.82,53.46 96.96,53.32 102.46,53.32 102.57,53.21 102.57,52.98 102.46,52.87 96.81,52.87 v2(96.07,52.12)
MEM_DQB26: length 71.7
  TOP w0.109: v2(92.82,62.68) CON1.249
  ART05 w0.114: v2(92.82,62.68) 92.82,63.92 94.67,65.77 95.26,65.77 95.56,66.07 95.56,66.29 94.07,67.78 94.07,67.94 94.26,68.13 94.42,68.13 96.37,66.18 96.53,66.18 96.69,66.34 96.69,66.5 94.74,68.45 94.74,68.62 94.9,68.78 95.06,68.78 97.07,66.78 97.23,66.78 97.39,66.94 97.39,67.1 95.39,69.1 95.39,69.26 95.56,69.43 95.72,69.43 97.69,67.46 97.86,67.46 98.02,67.62 98.02,67.78 96.04,69.76 96.04,69.92 96.2,70.08 96.37,70.08 98.34,68.1 98.5,68.1 98.66,68.27 98.66,68.43 96.69,70.4 96.69,70.56 96.85,70.73 97.01,70.73 98.99,68.75 99.15,68.75 99.31,68.91 99.31,69.07 97.34,71.05 97.34,71.21 97.5,71.37 97.66,71.37 99.63,69.4 99.8,69.4 99.96,69.56 99.96,69.72 97.98,71.7 97.98,71.86 98.14,72.02 98.31,72.02 100.28,70.04 100.44,70.04 100.6,70.21 100.6,70.37 99.55,71.42 99.55,71.58 107.5,79.54 110.65,79.54 111.76,80.64 111.76,81.67 v2(112.19,82.1)
MEM_DQB27: length 72.5
  TOP w0.109: v2(92.57,52.12) CON1.250
  ART05 w0.114: v2(111.33,82.6) 110.87,82.14 110.87,80.8 110.44,80.37 104.19,80.37 97.79,73.96 97.79,73.8 98.29,73.3 98.29,73.14 98.13,72.98 97.97,72.98 97.47,73.48 97.3,73.48 97.14,73.32 97.14,73.16 97.64,72.65 97.64,72.49 97.48,72.33 97.32,72.33 96.82,72.83 96.66,72.83 96.5,72.67 96.5,72.51 97,72.01 97,71.85 96.84,71.68 96.67,71.68 96.17,72.19 96.01,72.19 95.85,72.03 95.85,71.86 96.35,71.36 96.35,71.2 96.19,71.04 96.03,71.04 95.53,71.54 95.36,71.54 95.2,71.38 95.2,71.22 95.7,70.71 95.7,70.55 95.54,70.39 95.38,70.39 94.88,70.89 94.72,70.89 94.56,70.73 94.56,70.57 95.06,70.07 95.06,69.91 94.9,69.74 94.74,69.74 94.23,70.25 94.07,70.25 93.91,70.09 93.91,69.92 94.41,69.42 94.41,69.26 94.25,69.1 94.09,69.1 93.59,69.6 93.42,69.6 93.26,69.44 93.26,69.28 93.77,68.77 93.77,68.61 93.6,68.45 93.44,68.45 92.94,68.95 92.78,68.95 92.62,68.79 92.62,68.63 93.12,68.13 93.12,67.97 92.96,67.8 92.8,67.8 92.29,68.31 92.13,68.31 91.67,67.85 91.67,67.69 93.54,65.82 93.54,65.66 93.37,65.49 93.2,65.49 91.31,67.38 91.15,67.38 90.99,67.22 90.99,67.06 92.88,65.16 92.88,65 92.72,64.84 92.56,64.84 90.67,66.73 90.5,66.73 90.34,66.57 90.34,66.41 92.23,64.52 92.23,64.36 91.79,63.92 91.79,59.5 91.91,59.38 92.48,59.38 92.59,59.27 92.59,58.99 92.47,58.86 91.92,58.86 91.81,58.75 91.81,58.52 91.92,58.41 92.45,58.41 92.57,58.29 v2(92.57,52.12)
MEM_DQB28: length 68.4
  TOP w0.109: v2(97.07,52.12) CON1.232
  ART05 w0.114: v2(97.07,52.12) 97.5,52.55 103.94,52.55 104.05,52.67 104.05,52.89 103.92,53.02 103.14,53.02 103.03,53.14 103.03,53.36 103.14,53.48 103.84,53.48 103.94,53.58 103.94,53.89 103.85,53.98 102.17,53.98 102.05,54.1 102.05,55.12 102.17,55.24 103.94,55.24 104.06,55.36 104.06,55.57 103.94,55.69 101.76,55.69 101.64,55.8 101.64,56.03 101.76,56.14 104.35,56.14 104.46,56.26 104.46,56.5 104.35,56.61 101.75,56.61 101.61,56.75 101.61,56.97 101.72,57.09 104.35,57.09 104.47,57.2 104.47,57.44 104.36,57.55 101.76,57.55 101.61,57.7 101.61,59.53 102.41,60.33 102.41,61.39 102.52,61.5 104.35,61.5 104.47,61.61 104.47,61.84 104.35,61.96 103.16,61.96 103.05,62.07 103.05,63.86 103.24,64.05 104.28,64.05 104.47,64.24 104.47,67.97 108.88,72.39 113,72.39 113.11,72.5 113.11,73.63 113.23,73.75 115.54,73.75 115.66,73.86 v2(115.66,81.1)
MEM_DQB29: length 70.1
  TOP w0.109: v2(96.82,62.68) CON1.233
  ART05 w0.114: v2(114.79,81.6) 114.79,74.5 114.68,74.38 107.67,74.38 107.5,74.21 107.5,74.05 108.49,73.06 108.49,72.9 108.33,72.74 108.17,72.74 107.18,73.73 107.02,73.73 106.86,73.57 106.86,73.4 107.84,72.42 107.84,72.25 107.68,72.09 107.52,72.09 106.53,73.08 106.37,73.08 106.21,72.92 106.21,72.76 107.2,71.77 107.2,71.61 107.04,71.45 106.87,71.45 105.89,72.43 105.72,72.43 105.56,72.27 105.56,72.11 106.55,71.12 106.55,70.96 106.39,70.8 106.23,70.8 105.24,71.79 105.08,71.79 104.92,71.63 104.92,71.46 105.9,70.48 105.9,70.31 105.74,70.15 105.58,70.15 104.59,71.14 104.43,71.14 104.27,70.98 104.27,70.82 105.26,69.83 105.26,69.67 105.1,69.51 104.93,69.51 103.95,70.49 103.78,70.49 103.62,70.33 103.62,70.17 104.61,69.18 104.61,69.02 104.45,68.86 104.29,68.86 103.3,69.85 103.14,69.85 102.98,69.69 102.98,69.52 103.96,68.54 103.96,68.37 103.8,68.21 103.64,68.21 102.65,69.2 102.49,69.2 102.33,69.04 102.33,68.88 103.62,67.59 103.62,67.43 103.47,67.28 103.28,67.28 102.01,68.55 101.84,68.55 101.68,68.39 101.68,68.22 103.83,66.07 103.83,65.91 103.67,65.75 103.5,65.75 101.35,67.9 101.19,67.9 101.04,67.75 101.04,67.57 102.93,65.67 102.93,65.51 101.18,63.76 101.18,63.28 100.9,63 100.9,62.35 100.78,62.24 97.26,62.24 v2(96.82,62.68)
MEM_DQB30: length 71.3
  TOP w0.109: v2(93.7,62.74) 93.82,62.62 CON1.245
  ART05 w0.114: v2(93.7,62.74) 93.79,62.83 93.79,64.26 94.91,65.39 96.29,65.39 101.16,70.26 101.16,70.42 100.08,71.5 100.08,71.67 100.24,71.83 100.4,71.83 101.48,70.74 101.65,70.74 101.81,70.91 101.81,71.07 100.77,72.1 100.77,72.32 100.91,72.45 101.07,72.45 102.13,71.39 102.29,71.39 102.44,71.54 102.44,71.7 101.38,72.75 101.38,72.92 101.55,73.08 101.74,73.08 102.78,72.04 102.94,72.04 103.1,72.2 103.1,72.36 102.49,72.97 102.49,73.13 102.65,73.3 102.81,73.3 103.42,72.68 103.59,72.68 103.75,72.85 103.75,73.01 103.14,73.62 103.14,73.78 103.3,73.94 103.46,73.94 104.07,73.33 104.23,73.33 104.39,73.49 104.39,73.65 103.66,74.39 103.66,74.55 103.8,74.69 104,74.69 104.72,73.98 104.88,73.98 105.04,74.14 105.04,74.3 103.96,75.38 103.96,75.54 104.12,75.69 104.29,75.69 105.36,74.62 105.53,74.62 105.69,74.79 105.69,74.95 104.6,76.03 104.6,76.19 104.8,76.39 104.89,76.39 106.01,75.27 106.17,75.27 106.33,75.43 106.33,75.59 105.26,76.67 105.26,76.83 105.42,77 105.58,77 106.66,75.92 106.82,75.92 106.98,76.08 106.98,76.24 105.89,77.33 105.89,77.48 106.06,77.65 106.24,77.65 107.74,76.15 107.96,76.15 108.13,76.31 108.13,76.47 106.59,78.01 106.59,78.17 106.74,78.32 106.9,78.32 108.42,76.8 108.59,76.8 108.76,76.97 108.76,77.13 107.25,78.64 107.25,78.78 107.42,78.95 107.58,78.95 109.08,77.45 109.24,77.45 109.4,77.61 109.4,77.77 108.3,78.87 108.3,79.03 108.47,79.2 108.65,79.2 109.73,78.12 109.89,78.12 110.06,78.29 110.06,78.45 109.69,78.83 109.69,78.99 109.82,79.12 110.01,79.12 110.41,78.72 110.57,78.72 112.37,80.52 112.37,80.92 v2(112.19,81.1)
MEM_DQB31: length 72
  TOP w0.109: v2(93.57,52.12) CON1.246
  ART05 w0.114: v2(93.57,52.12) 93.57,52.13 93.57,59.4 92.81,60.16 92.81,61.21 92.33,61.69 92.33,63.95 94.01,65.63 94.01,65.86 93.37,66.5 93.37,66.66 93.54,66.82 93.7,66.82 94.37,66.15 94.53,66.15 94.72,66.34 94.72,66.52 93.5,67.74 93.5,67.9 98.46,72.86 98.62,72.86 99.33,72.15 99.5,72.15 99.66,72.31 99.66,72.47 98.95,73.18 98.95,73.34 99.11,73.51 99.27,73.51 99.98,72.8 100.14,72.8 100.3,72.96 100.3,73.12 99.59,73.83 99.59,73.99 100.95,75.35 101.11,75.35 101.89,74.56 102.06,74.56 102.22,74.73 102.22,74.89 101.43,75.67 101.43,75.83 101.82,76.22 101.82,76.38 101.33,76.87 101.33,77.04 101.53,77.23 101.69,77.23 102.58,76.35 102.74,76.35 102.9,76.51 102.9,76.67 102.04,77.53 102.04,77.69 102.25,77.9 102.44,77.9 103.85,76.49 104.01,76.49 104.17,76.65 104.17,76.82 102.73,78.26 102.73,78.42 102.88,78.57 103.06,78.57 104.49,77.14 104.65,77.14 104.82,77.3 104.82,77.46 103.36,78.91 103.36,79.08 103.52,79.23 103.69,79.23 105.14,77.79 105.3,77.79 105.46,77.95 105.46,78.11 104.02,79.55 104.02,79.73 104.18,79.88 104.34,79.88 105.79,78.43 105.95,78.43 106.11,78.59 106.11,78.76 105.31,79.55 105.31,79.71 105.48,79.88 105.67,79.88 106.39,79.16 106.55,79.16 107.27,79.88 110.49,79.88 111.33,80.72 v2(111.33,81.6)
MEM_DQB32: length 68.7
  TOP w0.109: CON1.165 113.82,62.68 v2(113.74,62.76)
  ART07 w0.114: v2(113.74,62.76) 113.74,61.2 113.85,61.09 115.75,61.09 115.87,60.97 115.87,59.71 115.98,59.6 116.21,59.6 116.33,59.71 116.33,60.97 116.44,61.09 117.52,61.09 117.63,60.97 117.63,58.91 117.75,58.8 117.97,58.8 118.09,58.91 118.09,60.97 118.2,61.09 120.32,61.09 120.43,60.97 120.43,58.66 120.55,58.55 120.78,58.55 120.89,58.66 120.89,60.62 121,60.74 123.9,60.74 124.02,60.62 124.02,58.68 124.13,58.56 124.36,58.56 124.48,58.68 124.48,60.56 124.65,60.74 125.36,60.74 125.52,60.9 125.52,61.08 125.41,61.2 121.83,61.2 121.71,61.32 121.71,61.51 121.83,61.62 125.04,61.62 125.16,61.74 125.16,61.94 125.01,62.09 124.14,62.09 124.02,62.21 124.02,64.14 123.91,64.25 123.69,64.25 123.58,64.14 123.58,62.22 123.45,62.09 122.5,62.09 122.39,62.21 122.39,66.48 122.66,66.75 122.66,79.25 122.27,79.64 122.27,80.73 122.15,80.85 arc(122.09,81.1) 122.15,81.35 122.15,81.35 arc(122.22,81.6) 122.15,81.85 122.15,81.85 arc(122.08,82.1) 122.15,82.35 arc(122.22,82.6) 122.15,82.85 122.15,82.85 arc(121.72,83.1) 121.29,82.85 121.29,82.85 arc(121.1,82.67) 120.86,82.6 v2(119.99,82.6)
MEM_DQB33: length 70.2
  TOP w0.109: CON1.162 114.57,52.1 v2(114.98,51.69)
  ART05 w0.114: v2(114.98,51.69) 114.22,50.93 104.81,50.93 104.74,51 104.73,51 104.49,51.24 104.49,51.24 104.48,51.25 104.48,54.07 104.13,54.42 104.13,54.78 104.38,55.03 104.74,55.03 104.9,55.19 104.9,57.85 104.79,57.97 102.23,57.97 102.12,58.08 102.12,58.31 102.23,58.43 104.73,58.43 104.84,58.54 104.84,58.77 104.73,58.88 102.24,58.88 102.12,59 102.12,59.23 102.23,59.34 104.68,59.34 104.8,59.45 104.8,59.68 104.68,59.8 103.45,59.8 103.29,59.95 103.29,60.85 103.41,60.97 104.72,60.97 104.89,61.13 104.89,63.03 104.75,63.17 104.41,63.17 104.29,63.28 104.29,63.53 104.39,63.63 104.8,63.63 104.89,63.72 104.89,67.8 109.06,71.97 113.42,71.97 113.53,72.08 113.53,73.12 113.74,73.33 115.96,73.33 116.18,73.54 116.18,81.14 arc(116.16,81.27) 116.11,81.39 arc(116.04,81.64) 116.11,81.89 arc(116.17,82.1) 116.11,82.31 116.09,82.36 ; v2(113.92,82.1) 113.92,82.42 114.36,82.85 114.36,82.85 arc(114.79,83.1) 115.22,82.85 115.23,82.85 arc(115.41,82.67) 115.66,82.6
  ART05 w0.135: 116.09,82.36 arc(115.9,82.53) 115.66,82.6
MEM_DQS_ADDR_CMDN: length 56.4
  TOP w0.109: 133.47,62.75 133.32,62.6 CON1.95
  ART07 w0.114: 133.47,62.75 133.17,63.04 133.17,64.16 132.34,64.98 132.34,65.26 132.68,65.6 132.68,65.94 132.33,66.29 131.99,66.29 131.29,65.59 131.13,65.59 130.97,65.75 130.97,65.91 132.01,66.96 132.01,67.33 131.75,67.59 131.38,67.59 130.34,66.54 130.18,66.54 130.02,66.7 130.02,66.87 131.06,67.91 131.06,68.25 130.77,68.54 130.43,68.54 129.39,67.5 129.22,67.5 129.06,67.66 129.06,67.82 130.11,68.86 130.11,69.2 129.82,69.49 129.48,69.49 128.43,68.45 128.27,68.45 128.11,68.61 128.11,68.77 129.16,69.81 129.16,70.16 128.87,70.44 128.53,70.44 127.48,69.4 127.32,69.4 127.16,69.56 127.16,69.72 128.2,70.77 128.2,71.11 127.92,71.4 127.55,71.4 126.58,70.43 126.42,70.43 126.26,70.59 126.26,70.75 127.23,71.72 127.23,72.06 126.87,72.41 126.34,72.41 126.2,72.55 126.2,73.77 126.66,74.23 126.66,78.5 126.16,78.99 126.16,79.2 126.66,79.69 126.66,80.21 arc(126.64,80.31) 126.58,80.4 arc(126.52,80.6) 126.58,80.8 126.58,80.8 arc(126.66,81.1) 126.58,81.4 arc(126.52,81.6) 126.58,81.8 126.58,81.8 arc(126.66,82.1) 126.58,82.4 arc(126.52,82.6) 126.58,82.8 arc(126.66,83.1) 126.58,83.4 arc(126.52,83.6) 126.58,83.8 arc(126.66,84.1) 126.58,84.4 arc(126.52,84.6) 126.58,84.8 arc(126.66,85.1) 126.58,85.4 arc(126.36,85.63) 126.05,85.71 126.05,85.71 arc(125.86,85.76) 125.71,85.9 125.71,85.9 arc(125.49,86.13) 125.18,86.21 arc(124.99,86.26) 124.85,86.4 124.84,86.41 arc(124.62,86.63) 124.32,86.71 arc(124.12,86.76) 123.98,86.9 123.97,86.91 arc(123.75,87.13) 123.45,87.21 arc(123.45,87.21) 123.45,87.21 arc(123.25,87.26) 123.11,87.4 123.11,87.4 arc(122.89,87.62) 122.59,87.71 122.58,87.71 arc(122.39,87.76) 122.25,87.9 122.25,87.9 arc(122.02,88.13) 121.72,88.21 arc(121.53,88.26) 121.38,88.4 121.38,88.4 arc(121.38,88.41) 121.38,88.41 arc(121.16,88.63) 120.86,88.71 120.85,88.71 arc(120.66,88.76) 120.52,88.9 120.51,88.91 arc(120.29,89.13) 119.99,89.21 arc(119.83,89.25) 119.71,89.36 119.65,89.47 arc(119.53,89.6) 119.36,89.67 119.23,89.7 119.23,89.7 119.21,89.7 119.12,89.79 U1.CE40
MEM_DQS_ADDR_CMDP: length 56.1
  TOP w0.109: CON1.97 132.82,62.58 132.66,62.75
  ART07 w0.114: 132.66,62.75 132.95,63.04 132.95,64.07 132.13,64.9 132.13,65.35 132.47,65.69 132.47,65.85 132.24,66.08 132.08,66.08 131.38,65.38 131.04,65.38 130.75,65.66 130.75,66 131.8,67.05 131.8,67.24 131.66,67.37 131.47,67.37 130.43,66.33 130.09,66.33 129.8,66.62 129.8,66.96 130.84,68 130.84,68.16 130.68,68.32 130.52,68.32 129.48,67.28 129.14,67.28 128.85,67.57 128.85,67.91 129.89,68.95 129.89,69.11 129.73,69.28 129.57,69.28 128.52,68.23 128.18,68.23 127.9,68.52 127.9,68.86 128.94,69.9 128.94,70.07 128.78,70.23 128.62,70.23 127.57,69.18 127.23,69.18 126.94,69.47 126.94,69.81 127.99,70.86 127.99,71.02 127.83,71.18 127.64,71.18 126.67,70.21 126.33,70.21 126.04,70.5 126.04,70.84 127.01,71.81 127.01,71.97 126.78,72.2 126.25,72.2 125.98,72.47 125.98,73.86 126.44,74.32 126.44,78.41 125.95,78.9 125.95,79.29 126.44,79.78 126.44,80.17 arc(126.43,80.24) 126.39,80.3 arc(126.31,80.6) 126.39,80.9 126.39,80.9 arc(126.44,81.1) 126.39,81.3 arc(126.31,81.6) 126.39,81.9 arc(126.44,82.1) 126.39,82.3 arc(126.31,82.6) 126.39,82.9 126.39,82.9 arc(126.44,83.1) 126.39,83.3 arc(126.31,83.6) 126.39,83.9 arc(126.44,84.1) 126.39,84.3 arc(126.31,84.6) 126.39,84.9 arc(126.44,85.1) 126.39,85.3 arc(126.25,85.44) 126.05,85.49 arc(125.75,85.57) 125.52,85.8 125.52,85.8 arc(125.38,85.94) 125.18,85.99 arc(124.88,86.07) 124.66,86.29 124.65,86.3 arc(124.51,86.44) 124.32,86.49 arc(124.02,86.57) 123.79,86.79 123.79,86.8 arc(123.64,86.94) 123.45,86.99 123.44,86.99 arc(123.14,87.08) 122.92,87.3 122.92,87.3 arc(122.78,87.44) 122.59,87.49 arc(122.59,87.49) 122.58,87.49 arc(122.28,87.57) 122.06,87.8 122.06,87.8 arc(121.91,87.94) 121.72,87.99 121.71,87.99 arc(121.42,88.07) 121.2,88.29 arc(121.19,88.29) 121.19,88.3 121.19,88.3 arc(121.05,88.44) 120.85,88.49 arc(120.55,88.57) 120.33,88.8 120.32,88.8 arc(120.18,88.94) 119.99,88.99 arc(119.72,89.06) 119.53,89.25 119.47,89.36 arc(119.4,89.43) 119.32,89.46 119.19,89.49 119.12,89.41 U1.CG40
MEM_DQSAN0: length 62.1
  TOP w0.109: 154.45,62.73 154.32,62.6 CON1.11
  ART07 w0.114: U1.CR54 131.25,84.82 arc(131.28,84.74) 131.36,84.71 131.47,84.71 arc(131.54,84.72) 131.6,84.76 arc(131.92,85.03) 132.28,85.25 arc(132.49,85.48) 132.45,85.8 arc(132.45,86.4) 132.98,86.71 arc(133.17,86.76) 133.31,86.9 133.32,86.9 arc(133.54,87.13) 133.84,87.21 arc(134.04,87.26) 134.18,87.4 134.18,87.4 arc(134.18,87.41) 134.19,87.41 arc(134.41,87.63) 134.7,87.71 134.71,87.71 arc(135.01,87.63) 135.24,87.4 135.24,87.4 arc(135.38,87.26) 135.57,87.21 135.58,87.21 arc(135.88,87.13) 136.1,86.91 arc(136.1,86.91) 136.1,86.9 136.1,86.9 arc(136.25,86.76) 136.44,86.71 arc(136.74,86.63) 136.97,86.4 136.99,86.36 arc(137.1,86.25) 137.25,86.21 137.33,86.21 arc(137.6,86.13) 137.8,85.95 137.85,85.88 arc(137.99,85.76) 138.17,85.71 138.22,85.71 arc(138.37,85.68) 138.5,85.61 138.54,85.58 arc(138.55,85.58) 138.56,85.57 139.69,84.44 139.69,83.07 139.83,82.93 140.28,82.93 140.52,82.69 140.52,82.28 140.28,82.04 139.8,82.04 139.69,81.93 139.69,81.7 139.8,81.58 141.37,81.58 141.61,81.34 141.61,80.95 141.36,80.7 139.8,80.7 139.69,80.58 139.69,79.65 139.93,79.41 144.92,79.41 145.2,79.13 145.2,78.72 144.99,78.51 144.99,78.35 145.15,78.18 145.31,78.18 145.72,78.59 146.06,78.59 146.3,78.35 146.3,78.16 146.63,77.82 147.48,77.82 147.78,77.53 147.78,77.19 147.04,76.45 147.04,76.29 147.2,76.13 147.37,76.13 148.1,76.86 148.44,76.86 148.73,76.58 148.73,76.24 147.99,75.5 147.99,75.34 148.16,75.18 148.32,75.18 149.05,75.91 149.39,75.91 149.68,75.62 149.68,75.28 148.95,74.55 148.95,74.39 149.11,74.23 149.27,74.23 150,74.96 150.34,74.96 150.63,74.67 150.63,74.33 149.9,73.6 149.9,73.44 150.06,73.27 150.22,73.27 150.96,74.01 151.3,74.01 151.58,73.72 151.58,73.38 150.85,72.65 150.85,72.48 151.01,72.32 151.17,72.32 151.91,73.06 152.25,73.06 154.15,71.15 154.15,63.03 154.45,62.73
MEM_DQSAN1: length 58
  TOP w0.109: CON1.32 149.07,52.27 149.22,52.12
  ART07 w0.114: U1.DA54 131.25,81.79 131.33,81.7 arc(131.35,81.7) 131.37,81.7 arc(131.6,81.59) 131.77,81.4 131.81,81.35 arc(131.89,81.04) 131.81,80.74 131.77,80.69 arc(131.73,80.63) 131.72,80.56 131.72,79.56 133.74,77.54 133.74,73.36 138.78,68.31 138.78,67.97 138.09,67.28 138.09,67.09 140.17,65.01 147.26,65.01 148.55,63.72 148.55,61.7 147.8,60.95 143.9,60.95 143.71,60.76 143.71,59.33 143.46,59.09 142.24,59.09 142.13,58.98 142.13,58.75 142.24,58.64 143.46,58.64 143.71,58.39 143.71,57.99 143.46,57.75 142.24,57.75 142.13,57.63 142.13,57.4 142.24,57.29 143.46,57.29 143.71,57.05 143.71,55.54 143.89,55.36 148.39,55.36 148.92,54.83 148.92,52.42 149.22,52.12
MEM_DQSAN2: length 68.1
  TOP w0.109: 143.97,62.68 143.82,62.53 CON1.53
  ART05 w0.114: 143.97,62.68 143.7,62.95 143.7,64.09 143.46,64.33 142.51,64.33 140.58,66.27 140.15,66.27 137.44,68.98 137.44,71.66 137.2,71.9 136.79,71.9 136.55,71.66 136.55,69.11 136.44,69 136.12,69 136.01,69.11 136.01,73.37 135.77,73.61 133.74,73.61 133.62,73.73 133.62,74.08 133.74,74.2 135.88,74.2 136.13,74.45 136.13,74.91 135.87,75.16 131.92,75.16 131.81,75.28 131.81,75.51 131.92,75.62 135.87,75.62 136.12,75.87 136.12,77.32 135.9,77.53 135.47,77.53 135.37,77.64 135.37,78.35 135.12,78.6 134.45,78.6 134.18,78.33 134.18,76.58 134.06,76.47 133.84,76.47 133.72,76.58 133.72,77.89 133.48,78.14 131.91,78.14 131.79,78.25 131.79,78.48 131.91,78.59 133.61,78.59 134.11,79.1 134.11,79.91 133.86,80.16 133.4,80.16 133.15,79.91 133.15,79.66 133.03,79.54 132.7,79.54 132.58,79.66 132.58,81.1 arc(132.6,81.2) 132.64,81.3 arc(132.72,81.6) 132.64,81.9 arc(132.58,82.1) 132.64,82.3 arc(132.72,82.6) 132.64,82.9 132.64,82.9 arc(132.58,83.1) 132.64,83.3 arc(132.64,83.9) 132.12,84.21 132.11,84.21 arc(131.92,84.26) 131.77,84.4 131.77,84.4 arc(131.55,84.63) 131.25,84.71 arc(131.05,84.76) 130.91,84.9 130.91,84.9 arc(130.9,84.91) 130.9,84.91 arc(130.68,85.13) 130.38,85.21 130.38,85.21 arc(130.19,85.26) 130.04,85.4 130.04,85.4 arc(129.82,85.63) 129.51,85.71 arc(129.32,85.76) 129.18,85.9 129.17,85.9 arc(128.95,86.13) 128.65,86.21 128.64,86.21 arc(128.34,86.13) 128.12,85.9 128.12,85.9 arc(127.98,85.76) 127.79,85.71 127.78,85.71 arc(127.48,85.63) 127.25,85.4 127.25,85.4 arc(127.11,85.26) 126.92,85.21 126.91,85.21 arc(126.61,85.13) 126.39,84.9 arc(126.31,84.6) 126.39,84.3 arc(126.44,84.1) 126.39,83.9 126.39,83.9 arc(126.05,83.71) 125.71,83.9 125.71,83.9 arc(125.53,84.1) 125.3,84.2 arc(125.28,84.2) 125.27,84.2 125.18,84.29 U1.CT47
MEM_DQSAN3: length 66.2
  TOP w0.109: 138.72,52.12 138.57,52.27 CON1.74
  ART05 w0.114: 138.72,52.12 138.42,52.42 138.42,54.85 138.04,55.23 136.17,55.23 136.02,55.38 136.02,59.38 136.29,59.65 137.11,59.65 137.46,60 137.46,60.63 136.75,61.34 136.75,63.75 136.09,64.41 134.95,64.41 134.1,63.56 134.1,61.21 133.92,61.03 133.41,61.03 133.17,60.79 133.17,59.77 133.48,59.46 134.31,59.46 134.62,59.14 134.62,57.72 134.31,57.41 129.89,57.41 129.72,57.58 129.72,59.72 128.23,61.21 125.93,61.21 125.81,61.33 125.81,61.64 125.92,61.76 128.17,61.76 128.62,62.2 128.62,63.56 128.62,63.56 128.62,64.08 128.33,64.36 126.39,64.36 125.88,64.86 125.88,73.6 126.59,74.31 126.59,78.72 125.66,79.65 125.66,80.19 125.66,80.19 125.66,81.13 125.66,81.13 arc(125.67,81.22) 125.71,81.3 arc(125.79,81.6) 125.71,81.9 125.71,81.91 arc(125.52,82.11) 125.27,82.2 125.18,82.29 U1.CY47
MEM_DQSAP0: length 61.8
  TOP w0.109: CON1.13 153.82,62.55 153.64,62.73
  ART07 w0.114: 153.64,62.73 153.93,63.03 153.93,71.07 152.16,72.84 152,72.84 151.26,72.11 150.92,72.11 150.63,72.39 150.63,72.73 151.37,73.47 151.37,73.63 151.21,73.79 151.04,73.79 150.31,73.06 149.97,73.06 149.68,73.35 149.68,73.69 150.42,74.42 150.42,74.58 150.25,74.74 150.09,74.74 149.36,74.01 149.02,74.01 148.73,74.3 148.73,74.64 149.46,75.37 149.46,75.53 149.3,75.7 149.14,75.7 148.41,74.96 148.07,74.96 147.78,75.25 147.78,75.59 148.51,76.32 148.51,76.49 148.35,76.65 148.19,76.65 147.45,75.91 147.11,75.91 146.83,76.2 146.83,76.54 147.56,77.28 147.56,77.44 147.39,77.61 146.54,77.61 146.09,78.07 146.09,78.26 145.97,78.37 145.81,78.37 145.4,77.97 145.06,77.97 144.77,78.26 144.77,78.6 144.99,78.81 144.99,79.04 144.83,79.19 141.22,79.19 141.15,79.12 140.82,79.12 140.74,79.19 139.84,79.19 139.47,79.56 139.47,80.67 139.71,80.91 141.27,80.91 141.4,81.04 141.4,81.25 141.28,81.37 139.71,81.37 139.47,81.61 139.47,82.02 139.71,82.26 140.19,82.26 140.31,82.37 140.31,82.6 140.19,82.72 139.74,82.72 139.47,82.98 139.47,84.35 138.41,85.41 138.37,85.44 arc(138.3,85.48) 138.22,85.49 138.17,85.49 arc(137.88,85.56) 137.67,85.76 137.63,85.83 arc(137.49,85.95) 137.32,85.99 137.25,85.99 arc(136.99,86.06) 136.81,86.25 136.78,86.3 arc(136.63,86.44) 136.44,86.49 136.44,86.49 arc(136.14,86.57) 135.92,86.79 arc(135.92,86.79) 135.91,86.8 135.91,86.8 arc(135.77,86.94) 135.57,86.99 arc(135.27,87.07) 135.05,87.3 135.05,87.3 arc(134.71,87.49) 134.37,87.3 134.37,87.3 arc(134.37,87.29) 134.37,87.29 arc(134.15,87.07) 133.85,86.99 133.84,86.99 arc(133.65,86.94) 133.51,86.8 133.5,86.8 arc(133.28,86.57) 132.98,86.49 arc(132.64,86.3) 132.64,85.9 arc(132.69,85.42) 132.38,85.05 arc(132.04,84.86) 131.75,84.61 arc(131.62,84.52) 131.47,84.49 131.36,84.49 arc(131.28,84.46) 131.25,84.38 U1.CU54
MEM_DQSAP1: length 57.6
  TOP w0.109: CON1.34 148.57,52.29 148.41,52.12
  ART07 w0.114: 148.41,52.12 148.7,52.42 148.7,54.74 148.3,55.14 143.8,55.14 143.49,55.45 143.49,56.96 143.38,57.07 142.15,57.07 141.91,57.31 141.91,57.72 142.15,57.96 143.38,57.96 143.49,58.08 143.49,58.31 143.38,58.42 142.15,58.42 141.91,58.66 141.91,59.07 142.15,59.31 143.38,59.31 143.49,59.42 143.49,60.85 143.81,61.17 147.71,61.17 148.33,61.79 148.33,63.63 147.17,64.8 140.08,64.8 137.88,67 137.88,67.37 138.57,68.06 138.57,68.22 133.53,73.27 133.53,77.45 131.5,79.47 131.5,80.56 arc(131.53,80.71) 131.61,80.83 131.63,80.85 arc(131.67,81.05) 131.62,81.24 131.58,81.3 arc(131.5,81.4) 131.39,81.47 131.34,81.47 arc(131.33,81.46) 131.32,81.46 131.25,81.38 U1.DC54
MEM_DQSAP2: length 67.8
  TOP w0.109: 143.16,62.68 143.32,62.52 CON1.55
  ART05 w0.114: U1.CV47 125.18,83.91 125.26,83.99 arc(125.41,83.92) 125.52,83.8 125.53,83.79 arc(126.05,83.49) 126.57,83.79 arc(126.57,83.79) 126.58,83.8 arc(126.66,84.1) 126.58,84.4 arc(126.57,84.79) 126.91,84.99 126.92,84.99 arc(127.22,85.07) 127.44,85.29 127.44,85.3 arc(127.59,85.44) 127.78,85.49 127.79,85.49 arc(128.09,85.57) 128.3,85.79 128.31,85.8 arc(128.64,85.99) 128.98,85.8 128.99,85.8 arc(129.21,85.57) 129.51,85.49 arc(129.71,85.44) 129.85,85.3 129.85,85.3 arc(130.08,85.07) 130.38,84.99 arc(130.57,84.94) 130.72,84.8 130.72,84.8 arc(130.72,84.79) 130.72,84.79 arc(130.94,84.57) 131.24,84.49 131.25,84.49 arc(131.44,84.44) 131.58,84.3 131.58,84.3 arc(131.81,84.07) 132.11,83.99 132.17,83.99 arc(132.23,83.98) 132.29,83.95 132.33,83.92 arc(132.49,83.69) 132.45,83.41 132.45,83.4 arc(132.37,83.1) 132.45,82.8 arc(132.5,82.6) 132.45,82.4 arc(132.37,82.1) 132.45,81.8 132.45,81.8 arc(132.5,81.6) 132.45,81.4 arc(132.39,81.26) 132.37,81.1 132.37,80.63 132.27,80.53 132.27,80.3 132.37,80.2 132.37,79.57 132.61,79.33 133.12,79.33 133.36,79.57 133.36,79.82 133.49,79.95 133.77,79.95 133.9,79.82 133.9,79.19 133.52,78.81 131.82,78.81 131.58,78.57 131.58,78.16 131.82,77.92 133.39,77.92 133.51,77.81 133.51,76.49 133.75,76.25 134.15,76.25 134.4,76.49 134.4,78.24 134.54,78.38 135.03,78.38 135.15,78.26 135.15,77.55 135.38,77.32 135.81,77.32 135.91,77.23 135.91,75.96 135.78,75.84 131.83,75.84 131.59,75.6 131.59,75.19 131.83,74.95 135.78,74.95 135.91,74.82 135.91,74.54 135.79,74.42 133.65,74.42 133.41,74.17 133.41,73.64 133.65,73.4 135.68,73.4 135.79,73.28 135.79,69.02 136.03,68.78 136.53,68.78 136.77,69.02 136.77,71.57 136.88,71.68 137.11,71.68 137.23,71.57 137.23,68.89 140.06,66.05 140.49,66.05 142.42,64.12 143.37,64.12 143.48,64 143.48,63.01 143.16,62.68
MEM_DQSAP3: length 65.9
  TOP w0.109: 137.91,52.12 138.07,52.29 CON1.76
  ART05 w0.114: 137.91,52.12 138.2,52.42 138.2,54.76 137.95,55.01 136.08,55.01 135.81,55.29 135.81,59.47 136.2,59.86 137.02,59.86 137.25,60.09 137.25,60.54 136.54,61.25 136.54,63.66 136,64.2 135.04,64.2 134.31,63.47 134.31,61.12 134.01,60.82 133.5,60.82 133.39,60.7 133.39,59.85 133.57,59.67 134.4,59.67 134.84,59.23 134.84,57.63 134.4,57.19 129.8,57.19 129.51,57.49 129.51,59.63 128.14,60.99 125.84,60.99 125.59,61.24 125.59,61.73 125.83,61.97 128.09,61.97 128.4,62.29 128.4,63.47 128.4,63.47 128.4,63.99 128.24,64.14 126.3,64.14 125.67,64.77 125.67,73.69 126.38,74.4 126.38,78.63 125.44,79.56 125.44,81.15 arc(125.47,81.28) 125.52,81.4 arc(125.58,81.6) 125.52,81.8 125.52,81.8 arc(125.41,81.92) 125.26,81.99 125.18,81.91 U1.DB47
MEM_DQSBN0: length 74.2
  TOP w0.109: 110.97,62.68 110.82,62.53 CON1.177
  ART05 w0.114: U1.CR40 119.12,84.82 119.24,84.71 119.41,84.71 arc(119.71,84.65) 119.97,84.47 120.42,84.03 arc(120.47,83.97) 120.51,83.9 arc(120.59,83.6) 120.51,83.3 arc(120.46,83.1) 120.51,82.9 120.52,82.9 arc(120.59,82.6) 120.51,82.3 arc(120.46,82.1) 120.51,81.9 arc(120.59,81.6) 120.51,81.3 arc(120.46,81.1) 120.51,80.9 arc(120.59,80.6) 120.51,80.3 arc(120.47,80.23) 120.42,80.17 120.27,80.03 120.27,71.25 120.03,71 116.01,71 115.9,70.89 115.9,70.66 116.01,70.55 120.03,70.55 120.27,70.31 120.27,69.89 120.03,69.65 114.71,69.65 114.59,69.53 114.59,69.3 114.71,69.19 120.03,69.19 120.27,68.95 120.27,68.54 120.03,68.3 114.71,68.3 114.59,68.19 114.59,67.96 114.71,67.84 120.03,67.84 120.27,67.6 120.27,67.19 120.03,66.95 114.71,66.95 114.59,66.84 114.59,66.61 114.71,66.5 119.61,66.5 119.85,66.26 119.85,65.84 119.61,65.59 113.78,65.59 113.13,64.94 110.79,64.94 110.67,64.82 110.67,62.98 110.97,62.68
MEM_DQSBN1: length 69.1
  TOP w0.109: 105.72,52.12 105.57,52.27 CON1.198
  ART07 w0.114: U1.DA40 119.12,81.79 119.21,81.7 arc(119.46,81.6) 119.65,81.4 arc(119.73,81.1) 119.65,80.8 arc(119.6,80.63) 119.62,80.46 119.64,80.44 119.64,80.37 119.64,80.36 119.64,78.82 118.83,78.01 118.83,69.4 118.14,68.71 115.03,68.71 113.24,70.5 110.39,70.5 105.03,65.14 105.03,62.18 104.76,61.91 104.23,61.91 104.12,61.79 104.12,61.57 104.23,61.45 104.79,61.45 105.03,61.21 105.03,60.84 105.41,60.46 105.41,59.61 106.3,58.71 112.68,58.71 113.16,58.23 113.16,57.89 112.7,57.43 112.7,57.27 112.86,57.11 113.02,57.11 113.48,57.57 113.82,57.57 114.42,56.97 114.42,56.55 114.18,56.31 113.85,56.31 113.74,56.19 113.74,55.96 113.85,55.85 114.18,55.85 114.42,55.61 114.42,55.2 114.18,54.96 114.1,54.96 113.99,54.84 113.99,54.62 114.1,54.5 114.18,54.5 114.42,54.26 114.42,53.67 114.18,53.43 113.67,53.43 113.43,53.67 113.43,53.82 113.32,53.93 113.09,53.93 112.97,53.82 112.97,53.67 112.73,53.43 112.33,53.43 112.09,53.67 112.09,53.82 111.97,53.93 111.74,53.93 111.63,53.82 111.63,53.67 111.39,53.43 110.98,53.43 110.74,53.67 110.74,53.82 110.62,53.93 110.4,53.93 110.28,53.82 110.28,53.67 110.04,53.43 109.63,53.43 109.39,53.67 109.39,53.82 109.28,53.93 109.05,53.93 108.94,53.82 108.94,53.67 108.69,53.43 108.29,53.43 108.05,53.67 108.05,53.82 107.93,53.93 107.7,53.93 107.59,53.82 107.59,53.67 107.35,53.43 106.94,53.43 106.7,53.67 106.7,53.82 106.58,53.94 106.36,53.94 106.24,53.82 106.24,53.67 106,53.43 105.68,53.43 105.42,53.17 105.42,52.42 105.72,52.12
MEM_DQSBN2: length 74.5
  TOP w0.109: CON1.219 100.32,62.53 100.47,62.68
  ART07 w0.114: 100.47,62.68 100.17,62.98 100.17,63.67 100.56,64.06 100.56,64.73 100.32,64.97 99.68,64.97 99.44,64.73 99.44,64.41 99.32,64.29 99.09,64.29 98.98,64.41 98.98,64.73 98.74,64.97 98.24,64.97 98.1,65.11 98.1,65.33 98.22,65.45 100.32,65.45 100.56,65.69 100.56,66.07 100.3,66.34 98.22,66.34 98.1,66.45 98.1,66.68 98.22,66.8 100.32,66.8 100.56,67.04 100.56,67.42 100.3,67.68 98.22,67.68 98.1,67.8 98.1,68.03 98.22,68.14 100.32,68.14 100.56,68.38 100.56,68.77 100.3,69.03 98.22,69.03 98.1,69.14 98.1,69.37 98.22,69.49 98.91,69.49 99.15,69.73 99.15,71.03 99.26,71.15 99.49,71.15 99.6,71.03 99.6,69.71 99.85,69.46 100.32,69.46 100.56,69.71 100.56,70.23 100.94,70.6 100.94,70.94 99.74,72.13 99.74,72.3 99.91,72.46 100.07,72.46 101.26,71.27 101.6,71.27 101.89,71.55 101.89,71.89 101.3,72.48 101.3,72.65 101.46,72.81 101.62,72.81 102.21,72.22 102.55,72.22 103.88,73.55 103.88,74.03 104,74.15 104.56,74.15 104.83,74.42 104.83,74.8 104.59,75.04 104,75.04 103.88,75.15 103.88,75.38 104,75.49 104.45,75.49 104.69,75.73 104.69,76.14 104.45,76.38 104,76.38 103.88,76.5 103.88,77.11 104.08,77.31 104.24,77.31 105.81,75.74 106.15,75.74 106.44,76.03 106.44,76.37 104.87,77.93 104.87,78.1 105.29,78.52 105.45,78.52 106.48,77.49 106.82,77.49 107.11,77.77 107.11,78.12 106.08,79.15 106.08,79.31 106.75,79.97 107.5,79.97 107.74,80.21 107.74,80.82 107.86,80.94 108.09,80.94 108.2,80.82 108.2,80.21 108.44,79.97 108.85,79.97 109.09,80.21 109.09,80.39 109.21,80.51 109.43,80.51 109.55,80.39 109.55,80.21 109.79,79.97 113.72,79.97 114.35,80.6 arc(114.53,80.98) 114.45,81.4 arc(114.4,81.6) 114.45,81.8 arc(114.53,82.1) 114.45,82.4 arc(114.4,82.6) 114.45,82.8 arc(114.53,83.1) 114.45,83.4 arc(114.23,83.63) 113.93,83.71 113.92,83.71 arc(113.73,83.76) 113.59,83.9 113.59,83.9 arc(113.4,84.1) 113.14,84.2 113.06,84.29 U1.CT33
MEM_DQSBN3: length 71.4
  TOP w0.109: 95.22,52.12 95.07,52.27 CON1.240
  ART05 w0.114: 95.22,52.12 94.92,52.42 94.92,55.11 95.03,55.22 99.84,55.22 100.08,55.46 100.08,55.87 99.84,56.11 95.03,56.11 94.92,56.23 94.92,56.45 95.03,56.57 99.84,56.57 100.08,56.81 100.08,57.22 99.84,57.46 95.03,57.46 94.92,57.57 94.92,57.8 95.03,57.91 99.84,57.91 100.08,58.16 100.08,58.56 99.84,58.8 95.11,58.8 94.92,58.99 94.92,60.55 94.42,61.05 94.42,64 95.18,64.76 96.56,64.76 107.26,75.46 108.09,75.46 arc(108.22,75.49) 108.33,75.56 113.07,80.3 113.17,80.3 113.37,80.5 113.37,80.6 113.53,80.77 113.53,81.1 arc(113.55,81.2) 113.59,81.3 arc(113.67,81.6) 113.59,81.9 arc(113.58,81.91) 113.58,81.91 arc(113.41,82.1) 113.17,82.2 arc(113.16,82.2) 113.14,82.2 113.06,82.29 U1.CY33
MEM_DQSBP0: length 73.9
  TOP w0.109: 110.16,62.68 110.32,62.52 CON1.179
  ART05 w0.114: 110.16,62.68 110.45,62.98 110.45,64.91 110.7,65.16 113.04,65.16 113.69,65.81 119.52,65.81 119.63,65.92 119.63,66.17 119.52,66.28 114.62,66.28 114.38,66.52 114.38,66.93 114.62,67.17 119.94,67.17 120.06,67.28 120.06,67.51 119.94,67.63 114.62,67.63 114.38,67.87 114.38,68.27 114.62,68.52 119.94,68.52 120.06,68.63 120.06,68.86 119.94,68.97 114.62,68.97 114.38,69.21 114.38,69.62 114.62,69.86 119.94,69.86 120.06,69.98 120.06,70.22 119.94,70.33 115.92,70.33 115.68,70.57 115.68,70.98 115.92,71.22 119.94,71.22 120.06,71.33 120.06,80.12 120.26,80.32 arc(120.3,80.36) 120.33,80.4 arc(120.38,80.6) 120.33,80.8 arc(120.25,81.1) 120.33,81.4 arc(120.38,81.6) 120.33,81.8 120.32,81.8 arc(120.25,82.1) 120.33,82.4 arc(120.38,82.6) 120.33,82.8 arc(120.25,83.1) 120.33,83.4 arc(120.38,83.6) 120.33,83.8 arc(120.3,83.84) 120.26,83.88 119.82,84.32 arc(119.63,84.45) 119.41,84.49 119.24,84.49 119.12,84.38 U1.CU40
MEM_DQSBP1: length 68.7
  TOP w0.109: 104.91,52.12 105.07,52.29 CON1.200
  ART07 w0.114: 104.91,52.12 105.2,52.42 105.2,53.26 105.59,53.65 105.91,53.65 106.03,53.76 106.03,53.91 106.27,54.15 106.67,54.15 106.92,53.91 106.92,53.76 107.03,53.65 107.26,53.65 107.37,53.76 107.37,53.91 107.61,54.15 108.02,54.15 108.26,53.91 108.26,53.76 108.38,53.65 108.61,53.65 108.72,53.76 108.72,53.91 108.96,54.15 109.37,54.15 109.61,53.91 109.61,53.76 109.72,53.65 109.95,53.65 110.07,53.76 110.07,53.91 110.31,54.15 110.71,54.15 110.96,53.91 110.96,53.76 111.07,53.65 111.3,53.65 111.41,53.76 111.41,53.91 111.65,54.15 112.06,54.15 112.3,53.91 112.3,53.76 112.42,53.65 112.64,53.65 112.76,53.76 112.76,53.91 113,54.15 113.41,54.15 113.65,53.91 113.65,53.76 113.76,53.65 114.09,53.65 114.21,53.76 114.21,54.17 114.09,54.29 114.01,54.29 113.77,54.53 113.77,54.93 114.01,55.17 114.09,55.17 114.21,55.29 114.21,55.52 114.09,55.63 113.76,55.63 113.52,55.87 113.52,56.28 113.76,56.52 114.09,56.52 114.21,56.64 114.21,56.88 113.73,57.35 113.57,57.35 113.11,56.89 112.77,56.89 112.48,57.18 112.48,57.52 112.94,57.98 112.94,58.14 112.59,58.5 106.21,58.5 105.19,59.52 105.19,60.38 104.81,60.76 104.81,61.12 104.7,61.24 104.14,61.24 103.9,61.48 103.9,61.88 104.14,62.13 104.67,62.13 104.81,62.26 104.81,65.23 110.3,70.72 113.33,70.72 115.12,68.92 118.05,68.92 118.61,69.49 118.61,78.1 119.43,78.91 119.43,80.36 arc(119.38,80.64) 119.46,80.9 arc(119.51,81.1) 119.46,81.3 119.46,81.3 arc(119.35,81.42) 119.19,81.49 119.12,81.41 U1.DC40
MEM_DQSBP2: length 74.7
  TOP w0.109: CON1.221 99.82,62.52 99.66,62.68
  ART07 w0.114: U1.CV33 113.06,83.91 113.13,83.99 arc(113.28,83.92) 113.4,83.8 113.4,83.8 arc(113.62,83.57) 113.92,83.49 arc(114.12,83.44) 114.26,83.3 114.26,83.3 arc(114.32,83.1) 114.26,82.9 114.26,82.9 arc(114.18,82.6) 114.26,82.3 arc(114.32,82.1) 114.26,81.9 arc(114.18,81.6) 114.26,81.3 arc(114.32,81.01) 114.19,80.75 113.63,80.19 113.17,80.19 113.07,80.29 112.89,80.29 112.8,80.19 112.62,80.19 112.52,80.29 112.34,80.29 112.25,80.19 110.66,80.19 110.57,80.29 110.39,80.29 110.29,80.19 109.88,80.19 109.76,80.3 109.76,80.48 109.52,80.72 109.12,80.72 108.87,80.48 108.87,80.3 108.76,80.19 108.53,80.19 108.42,80.3 108.42,80.91 108.18,81.15 107.77,81.15 107.53,80.91 107.53,80.3 107.41,80.19 106.66,80.19 105.87,79.4 105.87,79.06 106.9,78.03 106.9,77.86 106.74,77.7 106.57,77.7 105.54,78.73 105.2,78.73 104.65,78.19 104.65,77.84 106.22,76.28 106.22,76.12 106.06,75.95 105.9,75.95 104.33,77.52 103.99,77.52 103.66,77.2 103.66,76.41 103.91,76.17 104.36,76.17 104.48,76.05 104.48,75.82 104.36,75.71 103.91,75.71 103.66,75.47 103.66,75.06 103.91,74.82 104.5,74.82 104.61,74.71 104.61,74.51 104.47,74.36 103.91,74.36 103.66,74.12 103.66,73.64 103.11,73.08 102.82,73.08 102.64,72.9 102.64,72.61 102.46,72.43 102.3,72.43 101.71,73.02 101.37,73.02 101.08,72.74 101.08,72.4 101.67,71.81 101.67,71.64 101.51,71.48 101.35,71.48 100.16,72.67 99.82,72.67 99.53,72.39 99.53,72.04 100.72,70.85 100.72,70.69 100.35,70.32 100.35,69.79 100.23,69.68 99.93,69.68 99.82,69.79 99.82,71.12 99.58,71.36 99.17,71.36 98.93,71.12 98.93,69.82 98.82,69.7 98.13,69.7 97.89,69.46 97.89,69.06 98.13,68.81 100.21,68.81 100.35,68.68 100.35,68.47 100.23,68.36 98.13,68.36 97.89,68.12 97.89,67.71 98.13,67.47 100.21,67.47 100.35,67.33 100.35,67.13 100.23,67.01 98.13,67.01 97.89,66.77 97.89,66.36 98.13,66.12 100.21,66.12 100.35,65.98 100.35,65.78 100.23,65.66 98.13,65.66 97.89,65.42 97.89,65.02 98.15,64.75 98.65,64.75 98.76,64.64 98.76,64.32 99,64.08 99.41,64.08 99.65,64.32 99.65,64.64 99.77,64.75 100.23,64.75 100.35,64.64 100.35,64.15 99.95,63.76 99.95,62.8 99.84,62.68 99.66,62.68
MEM_DQSBP3: length 71
  TOP w0.109: 94.41,52.12 94.57,52.29 CON1.242
  ART05 w0.114: 94.41,52.12 94.7,52.42 94.7,55.2 94.94,55.44 99.75,55.44 99.87,55.55 99.87,55.78 99.75,55.9 94.94,55.9 94.7,56.14 94.7,56.54 94.94,56.78 99.75,56.78 99.87,56.9 99.87,57.13 99.75,57.24 94.94,57.24 94.7,57.48 94.7,57.89 94.94,58.13 99.75,58.13 99.87,58.25 99.87,58.47 99.75,58.59 95.02,58.59 94.7,58.9 94.7,60.46 94.21,60.96 94.21,64.09 95.09,64.97 96.47,64.97 107.17,75.68 108.09,75.68 arc(108.14,75.69) 108.17,75.71 113.32,80.86 113.32,81.1 arc(113.34,81.26) 113.4,81.4 arc(113.45,81.6) 113.4,81.8 113.4,81.8 arc(113.28,81.92) 113.13,81.99 113.06,81.91 U1.DB33
MSTR0: length 195.3
  TOP w0.109: U23.L15 v2(40.34,177.52)
  ART03 w0.114: v2(40.34,177.52) 40.74,177.93 42.11,177.93 42.34,178.15 42.34,180.14 42.72,180.52 45.92,180.52 46.61,179.83 48.51,179.83 52.7,184.02 62.23,184.02 64.39,186.18 75.82,186.18 78.61,183.39 78.61,176.15 79.12,175.64 79.12,173.61 80.39,172.34 133.79,172.34 135.33,173.88 135.33,188.74 140.08,193.49 140.08,195.01 142.05,196.98 164.47,196.98 164.97,197.49 169.42,197.49 171.53,195.38 174.89,195.38 178.47,191.8 179.93,191.8 180.54,191.19 180.54,188.26 184.28,184.53 188.75,184.53 v2(190.68,182.6)
MSTR1: length 200.2
  TOP w0.109: U23.K16 v2(39.54,178.32)
  ART03 w0.114: v2(191.95,182.6) 189.26,185.29 184.78,185.29 182.44,187.64 182.44,190.82 180.47,192.79 178.56,192.79 173.61,197.74 171.07,197.74 170.56,198.25 164.47,198.25 163.96,197.74 153.16,197.74 152.53,198.37 152.53,199.39 152.02,199.9 150.5,199.9 149.73,200.66 142.88,200.66 139.32,197.1 139.32,193.8 134.57,189.05 134.57,177.29 130.38,173.1 80.9,173.1 79.88,174.12 79.88,176.02 79.32,176.58 79.32,183.95 76.33,186.94 64.01,186.94 61.85,184.78 52.2,184.78 48.01,180.59 46.86,180.59 46.1,181.36 40.46,181.36 39.93,180.82 39.93,178.71 v2(39.54,178.32)
MSTR2: length 202.5
  TOP w0.109: U23.L16 v2(40.34,178.32)
  ART03 w0.114: v2(40.34,178.32) 40.71,178.7 40.71,180.57 40.99,180.85 46.1,180.85 46.74,180.21 48.26,180.21 52.45,184.4 62.1,184.4 64.26,186.56 76.07,186.56 78.99,183.64 78.99,176.28 79.5,175.77 79.5,173.86 80.64,172.72 133.6,172.72 134.95,174.07 134.95,188.89 139.7,193.64 139.7,196.88 143.1,200.28 149.61,200.28 150.5,199.39 151.76,199.39 152.15,199.01 152.15,197.99 152.78,197.36 164.21,197.36 164.72,197.87 169.62,197.87 171.5,195.99 174.82,195.99 178.48,192.33 180.29,192.33 181.91,190.71 181.91,187.63 184.63,184.91 189.21,184.91 191.26,182.86 191.26,182.37 191.52,182.12 192.74,182.12 v2(193.22,182.6)
MXP_RXN0: length 73.8
  ART07 w0.097: U1.AJ8 91.12,107.93 91.01,107.96 arc(91.01,107.97) 91,107.98 arc(90.8,108.14) 90.55,108.19 90.54,108.19 arc(90.34,108.25) 90.19,108.39 90.19,108.4 arc(89.98,108.61) 89.68,108.69 89.68,108.69 arc(89.48,108.75) 89.33,108.89 89.33,108.9 arc(89.11,109.11) 88.81,109.19 88.81,109.19 arc(88.61,109.25) 88.46,109.39 88.46,109.4 arc(88.24,109.61) 87.95,109.69 87.94,109.69 arc(87.65,109.61) 87.43,109.4 87.43,109.39 arc(87.28,109.25) 87.08,109.19 arc(86.88,109.25) 86.73,109.39 86.73,109.4 arc(86.51,109.61) 86.22,109.69 86.21,109.69 arc(86.01,109.75) 85.86,109.89 85.86,109.9 arc(85.7,110.08) 85.48,110.19 85.02,110.19 85,110.22 84.97,110.22
  ART07 w0.109: 32.51,123.34 32.74,123.57 32.74,124.19 arc(32.94,125.21) 33.53,126.08 33.75,126.31 arc(34.65,126.91) 35.72,127.13 62.79,127.13 arc(63.89,126.91) 64.82,126.29 69.63,121.47 70.19,120.91 arc(71.05,120.34) 72.06,120.14 arc(72.76,120) 73.36,119.6 73.66,119.3 arc(74.14,118.58) 74.31,117.73 74.31,113.61 arc(74.41,113.1) 74.7,112.67 74.7,112.67 arc(75.06,112.43) 75.48,112.35 79.93,112.35 arc(80.18,112.32) 80.43,112.24 arc(80.51,112.19) 80.58,112.13 82.36,110.36 arc(82.51,110.25) 82.69,110.22 84.97,110.22
  ART07 w0.122: J13.8 32.51,123.34
MXP_RXN1: length 66.4
  ART05 w0.097: U1.AM11 93.72,106.77 93.69,106.88 arc(93.69,106.88) 93.7,106.89 arc(93.73,107.15) 93.66,107.4 93.65,107.4 arc(93.44,107.62) 93.14,107.69 arc(92.85,107.62) 92.63,107.4 92.62,107.39 arc(92.48,107.25) 92.28,107.19 92.27,107.19 arc(91.98,107.11) 91.76,106.9 91.76,106.89 arc(91.61,106.75) 91.41,106.69 arc(91.21,106.75) 91.06,106.89 91.06,106.9 arc(90.84,107.12) 90.54,107.19 arc(90.34,107.25) 90.19,107.39 90.19,107.4 arc(89.97,107.62) 89.68,107.69 arc(89.48,107.75) 89.33,107.89 89.32,107.9 arc(89.11,108.12) 88.81,108.19 arc(88.61,108.25) 88.46,108.39 88.46,108.4 arc(88.24,108.61) 87.95,108.69 87.95,108.69 arc(87.74,108.75) 87.6,108.89 87.59,108.9 arc(87.38,109.11) 87.08,109.19 87.08,109.19 arc(86.88,109.25) 86.73,109.39 86.73,109.4 arc(86.51,109.61) 86.22,109.69 86.21,109.69 arc(86.01,109.75) 85.86,109.89 85.86,109.9 arc(85.69,110.09) 85.44,110.19 84.98,110.19 84.95,110.22 84.93,110.22
  ART05 w0.109: 40.51,123.34 40.71,123.54 40.71,123.94 arc(40.8,124.37) 41.04,124.74 41.16,124.85 arc(41.43,125.03) 41.74,125.09 60.14,125.09 arc(62.82,124.56) 65.09,123.05 70.31,117.83 arc(70.89,116.96) 71.09,115.93 71.09,113.81 arc(71.24,113.09) 71.65,112.47 71.68,112.44 arc(72.01,112.22) 72.41,112.14 80.13,112.14 arc(81.12,111.94) 81.96,111.39 82.2,111.14 arc(83.22,110.46) 84.43,110.22 84.93,110.22
  ART05 w0.122: J13.6 40.51,123.34
MXP_RXN2: length 56.7
  ART07 w0.097: U1.AN8 91.12,105.93 91.01,105.96 arc(91.01,105.97) 91,105.98 arc(90.8,106.14) 90.55,106.19 90.54,106.19 arc(90.34,106.25) 90.19,106.39 90.19,106.4 arc(89.98,106.61) 89.68,106.69 89.68,106.69 arc(89.48,106.75) 89.33,106.89 89.33,106.9 arc(89.27,107.1) 89.33,107.3 89.33,107.31 arc(89.4,107.6) 89.33,107.9 89.32,107.9 arc(89.11,108.12) 88.81,108.19 arc(88.61,108.25) 88.46,108.39 88.46,108.4 arc(88.24,108.61) 87.95,108.69 87.94,108.69 arc(87.65,108.61) 87.43,108.4 87.43,108.39 arc(87.28,108.25) 87.08,108.19 arc(86.88,108.25) 86.73,108.39 86.73,108.4 arc(86.51,108.61) 86.22,108.69 86.21,108.69 arc(86.01,108.75) 85.86,108.89 85.86,108.9 arc(85.7,109.08) 85.48,109.19 85.02,109.19 85,109.22 84.97,109.22
  ART07 w0.109: 84.97,109.22 82.29,109.22 arc(82.06,109.26) 81.87,109.39 80.92,110.34 arc(80.05,110.92) 79.02,111.12 74.84,111.12 arc(73.44,111.4) 72.26,112.19 71.2,113.25 arc(70.93,113.65) 70.84,114.12 70.84,116.02 arc(70.52,117.6) 69.63,118.93 64.84,123.73 arc(62.78,125.1) 60.36,125.58 50.02,125.58 arc(49.57,125.49) 49.18,125.23 arc(48.82,124.68) 48.69,124.03 48.69,123.54 48.48,123.34
  ART07 w0.122: J13.4 48.48,123.34
MXP_RXN3: length 48.9
  ART05 w0.097: 85.24,108.98 85.27,109.01 85.35,109.01 arc(85.55,108.95) 85.7,108.81 85.7,108.8 arc(85.92,108.58) 86.21,108.51 86.33,108.51 arc(86.43,108.48) 86.5,108.41 86.57,108.3 arc(86.78,108.08) 87.08,108.01 arc(87.28,107.95) 87.43,107.81 87.43,107.8 arc(87.48,107.6) 87.43,107.4 87.43,107.4 arc(87.35,107.1) 87.43,106.8 87.43,106.8 arc(87.49,106.6) 87.43,106.4 87.41,106.36 arc(87.34,106.1) 87.41,105.84 87.43,105.8 arc(87.65,105.58) 87.95,105.51 arc(88.23,105.58) 88.44,105.79 88.45,105.8 arc(88.6,105.95) 88.8,106.01 88.81,106.01 arc(89,105.96) 89.15,105.82 89.15,105.82 arc(89.16,105.81) 89.16,105.8 89.18,105.78 arc(89.38,105.57) 89.65,105.48 89.75,105.48 arc(89.8,105.47) 89.85,105.46 arc(89.94,105.41) 90,105.33 90.09,105.21 arc(90.25,105.06) 90.46,105.01 90.54,105.01 arc(90.74,104.95) 90.89,104.81 90.9,104.8 arc(91.11,104.58) 91.41,104.51 91.43,104.51 arc(91.72,104.59) 91.94,104.8 91.95,104.82 arc(92.09,104.95) 92.28,105.01 arc(92.48,104.95) 92.63,104.8 92.65,104.76 arc(92.84,104.58) 93.09,104.51 93.14,104.51 arc(93.39,104.56) 93.6,104.72 arc(93.6,104.73) 93.61,104.74 93.72,104.77 U1.AT11
  ART05 w0.109: 56.55,123.34 56.74,123.14 56.74,122.63 arc(56.77,122.47) 56.86,122.34 58.02,121.18 arc(58.15,121.09) 58.32,121.06 58.72,121.06 arc(59.68,120.86) 60.5,120.32 61.52,119.3 68.29,112.53 68.91,111.97 arc(70.49,111) 72.3,110.67 80.4,110.67 arc(80.76,110.6) 81.07,110.39 81.7,109.76 arc(82.56,109.19) 83.58,108.98 85.24,108.98
  ART05 w0.122: J13.2 56.55,123.34
MXP_RXP0: length 73.8
  ART07 w0.097: U1.AK7 90.83,107.77 90.86,107.86 arc(90.72,107.97) 90.54,108.01 arc(90.25,108.08) 90.03,108.3 90.03,108.3 arc(89.88,108.45) 89.68,108.51 89.68,108.51 arc(89.38,108.58) 89.16,108.8 89.16,108.8 arc(89.01,108.95) 88.81,109.01 88.81,109.01 arc(88.52,109.08) 88.3,109.3 88.3,109.3 arc(88.15,109.45) 87.95,109.51 87.94,109.51 arc(87.74,109.45) 87.59,109.3 87.59,109.3 arc(87.37,109.08) 87.08,109.01 arc(86.78,109.08) 86.57,109.3 86.56,109.3 arc(86.42,109.45) 86.22,109.51 86.21,109.51 arc(85.92,109.58) 85.7,109.8 85.7,109.81 arc(85.6,109.93) 85.46,110.01 85.02,110.01 85,109.98 84.97,109.98
  ART07 w0.109: 33.26,123.34 32.97,123.62 32.97,124.19 arc(33.16,125.13) 33.69,125.92 33.92,126.15 arc(34.74,126.7) 35.72,126.89 36.01,126.89 36.14,126.77 36.36,126.77 36.48,126.89 36.7,126.89 36.82,126.77 37.04,126.77 37.16,126.89 37.38,126.89 37.5,126.77 37.72,126.77 37.84,126.89 62.79,126.89 arc(63.8,126.69) 64.65,126.12 70.03,120.75 arc(70.96,120.13) 72.06,119.91 arc(72.67,119.79) 73.19,119.44 73.49,119.14 arc(73.92,118.49) 74.08,117.73 74.08,113.61 arc(74.2,113.01) 74.53,112.51 arc(74.97,112.22) 75.48,112.12 79.93,112.12 arc(80.13,112.09) 80.33,112.03 arc(80.37,112) 80.42,111.96 82.19,110.19 arc(82.42,110.04) 82.69,109.98 82.93,109.98 83.05,109.86 83.27,109.86 83.39,109.98 83.61,109.98 83.73,109.86 83.95,109.86 84.07,109.98 84.29,109.98 84.41,109.86 84.63,109.86 84.75,109.98 84.97,109.98
  ART07 w0.122: J13.7 33.26,123.34
