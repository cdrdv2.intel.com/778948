# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_ETHE:
  vias: v2(7.39,26.14) v2(7.39,24.74) v2(8.41,26.14) v2(8.41,24.74)
GND_QSFP_CAGE: length 6.1
  ART05 w0.508: B1.11 47.29,84.24 B1.10
GNDSENSE: length 44.6
  ART03 w0.254: v2(107,102.1) 105.91,102.1 105.45,101.64 105.12,101.64 104.57,101.09 104.24,101.09 103.73,100.58 103.35,100.58 102.84,100.08 102.46,100.08 101.95,99.57 101.57,99.57 101.06,99.06 100.68,99.06 100.25,98.63 99.88,98.63 99.39,98.14 99.04,98.14 98.49,97.59 98.17,97.59 97.66,97.08 97.28,97.08 96.77,96.57 96.39,96.57 96.2,96.76 96.2,96.79 95.93,97.06 95.9,97.06 95.82,97.14 95.55,97.14 95.05,97.64 94.68,97.64 94.27,98.06 93.82,98.06 93.34,97.58 93.09,97.58 93,97.56 92.91,97.53 92.83,97.47 92.77,97.41 92.71,97.33 92.46,97.08 92.07,97.08 91.62,96.62 91.18,96.62 90.73,97.08 90.35,97.08 89.87,97.56 89.5,97.56 89,98.06 88.62,98.06 88.15,97.58 87.71,97.58 87.27,97.14 86.91,97.14 86.37,96.61 86.01,96.61 85.52,97.1 84.34,97.1 84.22,97.23 81.51,97.23 80.86,96.58 76.64,96.58 76.22,97 71.6,97 70.13,95.53 69.13,95.53 v2(68.64,96.01)
VBUS_5V: length 16.6
  TOP w0.109: CN1.1 11.69,172.08 C668.1 R299.1
  BOTTOM w0.305: U20.4 18.11,177.15 17.1,178.16 14.53,178.16 13.97,177.6 13.97,174.37 CN1.1
VCC_FPGA_TESTI2C: length 27.7
  TOP w0.254: v2(158.15,147.64) 158.09,147.57 U17.B1
  ART05 w0.381: v2(162.72,137.92) 162.57,138.07 162.57,139.36 163.12,139.9 163.12,145.11 160.59,147.64 v2(158.15,147.64) 158.15,148.24 158.62,148.72 158.62,149.8 v2(157.99,150.43) v2(156.72,150.43) v2(155.45,150.43)
  BOTTOM w0.381: C656.1 162.63,137.83 v2(162.72,137.92)
  BOTTOM w0.508: v2(162.72,137.92) 160.94,139.7 J17.3 ; v2(158.15,147.64) 158.15,147.64 C650.1 C651.1
VCC_FPGA_VID: length 45.1
  ART03 w0.254: v2(66.87,94.74) 67.47,94.13 70.68,94.13 71.34,93.47 77.43,93.47 78.41,92.49 84.48,92.49 85.05,93.07 85.53,93.07 86,92.6 86.37,92.6 86.84,93.07 87.21,93.07 87.78,93.64 88.16,93.64 88.62,94.09 89.03,94.09 89.55,93.57 89.85,93.57 90.36,93.07 90.79,93.07 91.22,92.64 91.6,92.64 92.09,93.13 92.46,93.13 92.94,93.61 93.33,93.61 93.79,94.07 94.21,94.07 94.65,93.63 95.05,93.63 95.55,94.13 96.34,94.13 97.28,95.07 97.65,95.07 98.16,95.58 98.49,95.58 99.01,96.1 99.4,96.1 99.94,96.63 100.29,96.63 100.76,97.1 101.12,97.1 101.57,97.56 101.94,97.56 102.48,98.09 102.84,98.09 103.31,98.56 103.67,98.56 104.19,99.09 104.6,99.09 105.11,99.6 v2(106.13,99.6)
  vias: v2(102.67,107.6) v2(102.67,106.6) v2(102.67,105.6) v2(102.67,104.6) v2(102.67,103.6) v2(102.67,102.6) v2(102.67,101.6) v2(102.67,100.6) v2(102.67,99.6) v2(102.67,98.6) v2(102.67,97.6) v2(102.67,96.6) v2(102.67,95.6) v2(102.67,94.6) v2(102.67,93.6) v2(104.4,106.6) v2(104.4,105.6) v2(104.4,104.6) v2(104.4,103.6) v2(104.4,102.6) v2(104.4,101.6) v2(104.4,100.6) v2(104.4,99.6) v2(104.4,98.6) v2(104.4,97.6) v2(104.4,96.6) v2(104.4,95.6) v2(104.4,94.6) v2(104.4,93.6) v2(106.13,107.6) v2(106.13,106.6) v2(106.13,105.6) v2(106.13,104.6) v2(106.13,103.6) v2(106.13,102.6) v2(106.13,100.6) v2(106.13,98.6) v2(106.13,97.6) v2(106.13,96.6) v2(106.13,95.6) v2(107.86,109.6) v2(107.86,108.6) v2(107.86,107.6) v2(107.86,106.6) v2(107.86,96.6) v2(107.86,95.6) v2(107.86,94.6) v2(107.86,93.6) v2(109.6,109.6) v2(109.6,108.6) v2(109.6,107.6) v2(109.6,106.6) v2(109.6,96.6) v2(109.6,95.6) v2(109.6,94.6) v2(109.6,93.6) v2(111.33,109.6) v2(111.33,108.6) v2(111.33,107.6) v2(111.33,106.6) v2(111.33,96.6) v2(111.33,95.6) v2(111.33,94.6) v2(111.33,93.6) v2(113.06,109.6) v2(113.06,108.6) v2(113.06,107.6) v2(113.06,106.6) v2(113.06,96.6) v2(113.06,95.6) v2(113.06,94.6) v2(113.06,93.6) v2(114.79,109.6) v2(114.79,108.6) v2(114.79,107.6) v2(114.79,106.6) v2(114.79,96.6) v2(114.79,95.6) v2(114.79,94.6) v2(114.79,93.6) v2(116.05,125.09) v2(116.05,124.21) v2(116.52,107.6) v2(116.52,106.6) v2(116.52,105.6) v2(116.52,104.6) v2(116.52,103.6) v2(116.52,102.6) v2(116.52,101.6) v2(116.52,100.6) v2(116.52,99.6) v2(116.52,98.6) v2(116.52,97.6) v2(116.52,96.6) v2(116.52,95.6) v2(117.07,125.09) v2(117.07,124.21) v2(118.34,125.09) v2(118.34,124.21) v2(118.26,107.6) v2(118.26,106.6) v2(118.26,105.6) v2(118.26,104.6) v2(118.26,103.6) v2(118.26,102.6) v2(118.26,101.6) v2(118.26,100.6) v2(118.26,99.6) v2(118.26,98.6) v2(118.26,97.6) v2(118.26,96.6) v2(118.26,95.6) v2(119.35,125.09) v2(119.35,124.21) v2(119.99,109.6) v2(119.99,108.6) v2(119.99,107.6) v2(119.99,106.6) v2(119.99,105.6) v2(119.99,104.6) v2(119.99,103.6) v2(119.99,102.6) v2(119.99,101.6) v2(119.99,100.6) v2(119.99,99.6) v2(119.99,98.6) v2(119.99,97.6) v2(119.99,96.6) v2(119.99,95.6) v2(152.63,124.33) v2(152.63,123.32) v2(152.63,119.76) v2(152.63,118.74) v3(71.98,117.35) v3(71.98,116.08) v3(71.98,114.55) v3(71.98,113.28) v3(72.52,125.22) v3(72.52,123.19) v3(72.52,121.16) v3(72.52,119.13) v3(72.87,117.35) v3(72.87,116.08) v3(72.87,114.55) v3(72.87,113.28) v3(75.79,125.6) v3(75.79,124.59) v3(75.79,123.32) v3(75.79,122.3) v3(75.79,121.03) v3(75.79,120.01) v3(75.79,118.74) v3(75.79,117.73) v3(75.79,116.46) v3(75.79,115.44) v3(75.79,114.17) v3(75.79,113.16) v3(84.53,181.86) v3(84.53,181.1) v3(84.96,184.78) v3(84.96,184.02) v3(85.09,125.86) v3(85.17,179.48) v3(85.17,178.71) v3(85.17,175.18) v3(85.17,174.42) v3(85.29,181.86) v3(85.29,181.1) v3(85.72,184.78) v3(85.72,184.02) v3(85.85,179.5) v3(85.85,178.74) v3(86.23,183.39) v3(86.23,182.63) v3(86.23,181.86) v3(86.23,181.1) v3(87,183.39) v3(87,182.63) v3(87,181.86) v3(87,181.1) v3(87.25,125.72) v3(87.63,170.69) v3(87.63,169.93) v3(87.63,169.16) v3(87.76,183.39) v3(87.76,182.63) v3(87.76,181.86) v3(87.76,181.1) v3(88.39,170.69) v3(88.39,169.93) v3(88.39,169.16) v3(89.14,125.49) v3(89.15,170.69) v3(89.15,169.93) v3(89.15,169.16) v3(91.19,125.86) v3(93.22,125.86) v3(93.73,185.17) v3(98.93,170.69) v3(98.93,169.93) v3(98.93,169.16) v3(99.57,183.26) v3(99.57,182.5) v3(99.57,181.74) v3(99.57,180.97) v3(99.69,170.69) v3(99.69,169.93) v3(99.69,169.16) v3(100.33,183.26) v3(100.33,182.5) v3(100.33,181.74) v3(100.33,180.97) v3(100.46,170.69) v3(100.46,169.93) v3(100.46,169.16) v3(101.09,183.26) v3(101.09,182.5) v3(101.09,181.74) v3(101.09,180.97) v3(102.08,131.06) v3(102.08,130.17) v3(102.23,184.78) v3(102.23,184.02) v3(102.23,181.99) v3(102.23,181.23) v3(102.76,179.35) v3(102.76,178.59) v3(103,184.78) v3(103,184.02) v3(103,181.99) v3(103,181.23) v3(103.43,179.37) v3(103.43,178.61) v3(103.35,175.06) v3(103.35,174.29) v3(103.35,131.06) v3(103.35,130.17) v3(104.87,131.06) v3(104.87,130.17) v3(106.14,131.06) v3(106.14,130.17) v3(111.85,179.45) v3(111.85,178.69) v3(112.27,181.99) v3(112.27,181.23) v3(112.39,184.78) v3(112.39,184.02) v3(112.52,179.48) v3(112.52,178.71) v3(112.52,175.16) v3(112.52,174.4) v3(113.03,181.99) v3(113.03,181.23) v3(113.16,184.78) v3(113.16,184.02) v3(114.05,183.26) v3(114.05,182.5) v3(114.05,181.74) v3(114.05,180.97) v3(114.81,183.26) v3(114.81,182.5) v3(114.81,181.74) v3(114.81,180.97) v3(115.06,170.69) v3(115.06,169.93) v3(115.06,169.16) v3(115.57,183.26) v3(115.57,182.5) v3(115.57,181.74) v3(115.57,180.97) v3(115.82,170.69) v3(115.82,169.93) v3(115.82,169.16) v3(116.59,170.69) v3(116.59,169.93) v3(116.59,169.16) v3(125.98,170.69) v3(125.98,169.93) v3(125.98,169.16) v3(126.75,170.69) v3(126.75,169.93) v3(126.75,169.16) v3(127.38,183.39) v3(127.38,182.63) v3(127.38,181.86) v3(127.38,181.1) v3(127.51,170.69) v3(127.51,169.93) v3(127.51,169.16) v3(128.14,183.39) v3(128.14,182.63) v3(128.14,181.86) v3(128.14,181.1) v3(128.91,183.39) v3(128.91,182.63) v3(128.91,181.86) v3(128.91,181.1) v3(129.29,185.04) v3(129.29,184.28) v3(129.77,181.99) v3(129.77,181.23) v3(130.05,185.04) v3(130.05,184.28) v3(130.01,179.32) v3(130.02,178.61) v3(130.53,181.99) v3(130.53,181.23) v3(130.45,175.16) v3(130.45,174.4) v3(130.68,179.35) v3(130.68,178.59) v3(134.08,131.83) v3(134.08,130.94) v3(135.35,131.83) v3(135.35,130.94) v3(136.25,124.59) v3(136.88,131.83) v3(136.88,130.94) v3(138.15,131.83) v3(138.15,130.94) v3(138.15,124.59) v3(141.45,125.35) v3(141.45,124.33) v3(141.45,123.06) v3(141.45,122.05) v3(141.45,120.78) v3(141.45,119.76) v3(141.47,118.5) v3(141.45,117.47) v3(146.4,124.84) v3(146.4,122.55) v3(146.4,120.27) v3(146.4,117.98) v3(154.02,124.33) v3(154.02,123.32) v3(154.02,122.05) v3(154.02,121.03) v3(154.02,119.76) v3(154.02,118.74) v5(84.58,165.74) v5(84.58,163.7) v5(84.58,161.67) v5(86.61,165.74) v5(86.61,163.7) v5(86.61,161.67) v5(88.65,165.74) v5(88.65,163.7) v5(88.65,161.67) v5(90.68,165.74) v5(90.68,163.7) v5(90.68,161.67) v5(92.71,165.74) v5(92.71,163.7) v5(92.71,161.67) v5(94.74,165.74) v5(94.74,163.7) v5(108.97,165.74) v5(111,165.74) v5(111,163.7) v5(113.03,165.74) v5(113.03,163.7) v5(115.06,165.74) v5(115.06,163.7) v5(117.09,165.74) v5(117.09,163.7) v5(119.13,165.74) v5(119.13,163.7) v5(121.16,165.74) v5(121.16,163.7) v5(123.19,165.74) v5(123.19,163.7) v5(125.22,165.74) v5(125.22,163.7) v5(127.25,165.74) v5(127.25,163.7) v5(129.29,165.74) v5(129.29,163.7)
VCC_PWM0: length 11.5
  TOP w0.109: 78.56,207.11 78.43,207.24 77.95,207.24 77.83,207.36 U54.5
  TOP w0.199: v2(83.52,201.32) 83.49,201.29 83.49,201.17 83.44,201.12 R1100.1 ; v2(79.22,206.53) 79.18,206.53 79.05,206.67 79.04,206.67 78.59,207.11 78.56,207.11
  ART07 w0.199: v2(83.52,201.32) 83.11,201.73 82.42,201.73 82.22,201.93 82.22,205.1 80.8,206.53 v2(79.22,206.53)
VCC_PWM2: length 41.2
  TOP w0.199: U54.2 77.49,206.16 77.57,206.08 77.6,206.08 77.74,205.95 77.74,205.91 v2(77.88,205.77) ; v2(110.77,200.69) 111.1,200.36 111.1,200.22 R1111.1
  ART18 w0.199: v2(77.88,205.77) 78.33,206.22 78.33,206.98 78.97,207.62 83.08,207.62 83.35,207.36 89.11,207.36 91.15,209.4 95.81,209.4 98.25,206.96 101.42,206.96 103.35,205.03 103.35,204.29 104.52,203.12 108.81,203.12 110.77,201.17 v2(110.77,200.69)
VCC_PWM3: length 62.1
  TOP w0.199: U54.1 77.24,205.69 v2(77.24,205.31)
  ART16 w0.199: v2(77.24,205.31) 76.94,205.61 76.94,207.85 79.04,209.96 84.63,209.96 85.62,208.97 88.9,208.97 89.89,209.96 97.13,209.96 99.11,207.98 103.45,207.98 104.7,209.22 122.3,209.22 124.43,207.09 v2(124.43,199.57)
VCC_PWM4: length 27.7
  TOP w0.109: v2(96.84,200.78) R1105.1
  TOP w0.199: U54.50 75.61,204.47 v2(75.56,204.43)
  ART07 w0.199: v2(75.56,204.43) 75.56,204.85 77.95,207.24 79.22,207.24 79.59,207.6 81.17,207.6 81.74,207.04 87.98,207.04 91.15,203.86 94.29,203.86 96.95,201.2 96.95,200.89 v2(96.84,200.78)
VCC_TESTI2C_1.2V: length 19.5
  ART03 w0.508: v2(156.18,144.27) 156.18,137.92 151.45,133.19 v2(151.45,132.08)
  BOTTOM w0.508: J17.8 152.11,134.62 C653.1 C654.1 v2(151.45,132.08)
  vias: v2(156.21,147.57)
VCCA_PLL_FPGA_1.2V:
  vias: v2(108.73,112.1) v2(108.73,91.1) v2(110.46,112.1) v2(110.46,91.1) v2(112.19,112.1) v2(112.19,91.1) v2(113.92,112.1) v2(113.92,91.1) v2(140.06,102.08) v2(140.25,99.77) v2(140.23,97.49) v2(140.84,102.08) v2(140.77,97.46) v2(141,99.81) v2(141.66,102.03) v2(141.74,99.78) v2(141.71,97.41) v2(142.27,97.38) v2(142.47,102.11) v2(142.62,99.75) v2(142.98,96.52) v2(143.08,102.03) v2(144.3,103.15) v2(144.58,102.77) v2(144.75,103.2) v2(161.29,110.57) v2(161.32,109.78) v2(162.03,110.54) v2(162.05,109.78) v2(162.84,110.54) v2(162.89,109.78) v2(163.7,110.52) v2(163.7,109.78) v2(164.59,109.7)
VCCA_PWRMAX_3.3V: length 3.4
  TOP w0.254: U23.F4 v2(35.54,167.92) ; U23.M6 v2(41.14,169.52) ; U23.F3 v2(35.54,167.12) ; U23.P13 v2(42.74,175.92) ; U23.F6 v2(35.54,169.52) ; U23.F14 v2(35.54,176.72)
  vias: v2(33.9,162.4) v2(33.88,161.51) v2(34,164.18) v2(34.02,163.3) v2(34.92,162.61) v2(41.89,167.89)
VCCA_SYSMAX_3.3V: length 1.2
  BOTTOM w0.508: C755.2 v2(177.93,102.21) ; C756.1 v2(167.51,102.18)
  vias: v2(168.27,97.58) v2(168.27,91.18) v2(168.27,89.58) v2(168.27,88.78) v2(168.76,86.21) v2(168.78,85.34) v2(169.65,86.21) v2(169.7,85.34) v2(173.07,91.18) v2(174.67,96.78)
VCCBAT: length 2.6
  BOTTOM w0.508: U46.14 R93.2
VCCBAT_FPGA_1.8V: length 11.2
  BOTTOM w0.508: v3(129.9,43.89) 129.9,34.1 R93.1
  vias: v2(126.05,92.1) v2(126.05,91.1)
VCCCLK_GXE_FPGA_2.5V: length 104.8
  TOP w0.127: R728.2 57.2,130.76 57.33,130.63 57.33,129.62 57.17,129.46 54.89,129.46 V19.1
  ART16 w0.254: v2(49.12,51.89) 49.01,52 49.01,53.74 49.56,54.28 52.02,54.28 53.16,55.42 56.97,55.42 60.03,58.48 60.03,62.64 71.88,74.49 71.88,90.72 73.81,92.65 76.85,92.65 78.24,94.04 78.24,105.8 78.63,106.18 80.72,106.18 83.6,109.07 85.52,109.07 86.02,109.56 86.4,109.56 86.88,109.08 87.26,109.08 87.8,109.61 88.14,109.61 88.65,109.11 89.01,109.11 89.5,109.59 89.9,109.59 90.38,109.11 90.74,109.11 91.22,109.6 91.58,109.6 92.08,109.11 92.46,109.11 92.93,108.64 93.26,108.64 93.78,108.12 94.15,108.12 94.67,107.59 95.03,107.59 95.57,107.06 95.95,107.06 96.4,106.61 96.79,106.61 97.29,106.11 97.62,106.11 98.12,105.61 98.48,105.61 98.99,105.1 v2(100.07,105.1)
  BOTTOM w0.254: v2(49.12,51.89) 49.06,51.89 48.49,51.32 U32.17
  vias: v3(54.05,131.98) v3(54.05,131.27) v3(54,130.4) v3(54.94,131.98) v3(54.94,131.27) v3(54.89,130.4)
VCCCLK_GXP_FPGA_1.8V:
  vias: v2(123.45,98.6) v2(125.18,98.6) v2(148.72,130.56) v2(149.35,130.94)
VCCFUSEWR_SDM_FPGA_2.4V: length 6.1
  TOP w0.127: R736.2 50.37,51.1 50.27,51 48.82,51 48.44,50.63 48.44,49.33 V21.1
  BOTTOM w0.254: v2(47.97,50.41) 47.97,50.5 47.66,50.82 U32.18 ; C1319.1 v3(122.15,77.44)
  vias: v2(49.96,53.72) v2(49.98,52.91) v2(49.98,52.27) v2(50.72,53.72) v2(50.75,52.91) v2(50.75,52.27) v2(126.92,92.6) v2(126.92,91.6) v3(122.15,76.58)
VCCFUSEWR_SDM_FPGA_2.4V_SET: length 156.9
  TOP w0.109: U23.C8 v2(33.13,171.12)
  ART03 w0.089: 31.5,165.02 31.5,165.59 31.98,166.06 31.98,167.31 32.69,168.02 32.69,170.67 v2(33.13,171.12)
  ART03 w0.114: 31.5,165.02 31.5,161.59 32.76,160.32 33.07,160.32 33.88,159.51 37.31,159.51 38.12,160.32 39.04,160.32 39.47,159.89 39.47,157.92 39.5,157.92 40.03,157.39 40.03,153.99 40.74,153.29 40.74,147.57 38.96,145.79 38.96,139.98 37.05,138.07 32.25,138.07 28.17,133.98 28.17,130.38 28.75,129.79 28.75,125.12 28.39,124.76 28.39,121.71 26.84,120.16 26.84,84.28 32.76,78.36 32.76,70.96 41.86,61.86 41.86,60.1 43.99,57.96 50.52,57.96 51.31,57.18 51.31,55.63 54.2,52.73 55.17,52.73 55.58,52.32 v2(55.58,52.02)
  BOTTOM w0.254: 58.04,53.35 57.37,53.35 56.1,52.08 R982.2
VCCH_FPGA_0.9V: length 5.5
  BOTTOM w0.254: C156.1 101.04,94.11 101.04,93.36 100.25,92.57 100.25,92 99.79,91.53 C140.2 99.4,91.47 R96.1 ; v3(74.5,95.96) 74.52,95.93 C202.1
  vias: v2(100.94,102.6) v2(100.94,101.6) v2(100.94,100.6) v2(100.94,98.6) v2(100.94,97.6) v2(100.94,95.6) v2(100.94,94.6) v2(101.8,104.1) v2(101.8,103.1) v2(101.8,101.1) v2(101.8,100.1) v2(101.8,98.1) v2(101.8,97.1) v2(101.8,95.1) v2(109.98,98.53) v2(110.08,104.7) v2(110.72,98.53) v2(110.82,104.7) v2(111.68,104.7) v2(111.68,98.53) v2(112.45,104.67) v2(112.42,98.53) v2(113.23,104.7) v2(113.31,98.53) v2(113.97,104.7) v2(114.05,98.53) v2(120.75,125.09) v2(120.75,124.21) v2(121.72,103.6) v2(121.72,102.6) v2(121.72,100.6) v2(121.72,99.6) v2(121.72,98.6) v2(121.72,94.6) v2(121.77,125.09) v2(121.77,124.21) v2(122.58,105.1) v2(122.58,104.1) v2(122.58,103.1) v2(122.58,102.1) v2(122.58,101.1) v2(122.58,100.1) v2(122.58,95.1) v2(123.29,125.09) v2(123.29,124.21) v2(124.31,125.09) v2(124.31,124.21) v2(125.83,125.09) v2(125.83,124.21) v2(126.85,125.09) v2(126.85,124.21) v2(128.37,125.09) v2(128.37,124.21) v2(129.39,125.09) v2(129.39,124.21) v2(130.91,125.09) v2(130.91,124.21) v2(131.93,125.09) v2(131.93,124.21) v2(133.45,125.09) v2(133.45,124.21) v2(134.47,125.09) v2(134.47,124.21) v3(63.85,111.12) v3(63.86,110.26) v3(64.74,111.12) v3(64.74,110.24) v3(64.74,109.35) v3(65.63,111.12) v3(65.63,110.24) v3(65.63,109.35) v3(66.52,111.12) v3(66.52,110.24) v3(66.52,109.35) v3(67.41,111.12) v3(67.41,110.24) v3(67.41,109.35) v3(68.3,111.12) v3(68.3,110.24) v3(68.3,109.35) v3(71.4,94.36) v3(71.98,95.96) v3(71.98,95.12) v3(72.46,94.36) v3(72.82,95.96) v3(72.84,95.12) v3(73.35,94.35) v3(73.66,95.96) v3(73.68,95.12) v3(74.52,95.12) v4(138.07,173) v4(138.1,171.75) v4(138.23,170.59) v4(138.81,172.44) v4(139.5,171.81) v4(139.57,173.05) v4(139.57,170.56) v4(141.48,173.84) v4(141.5,172.09) v4(141.48,170.54) v4(141.58,115.44) v4(141.58,114.43) v4(142.62,173.1) v4(142.62,172.34) v4(142.62,171.58) v4(142.69,115.37) v4(142.72,114.43) v4(143.64,173.1) v4(143.64,172.34) v4(143.61,171.55) v4(145.64,170.76) v4(145.72,169.95) v4(146.74,170.74) v4(146.74,169.95) v4(147.7,172.97) v4(147.67,171.98) v4(148.46,172.97) v4(148.46,171.96) v4(148.51,169.95) v4(148.51,169.19) v4(149.22,172.97) v4(149.22,171.96) v4(149.38,181.25) v4(149.38,179.98) v4(149.38,178.71) v4(149.38,177.44) v4(149.35,170.81) v4(149.53,169.95) v4(149.53,169.19) v4(150.65,181.25) v4(150.65,179.98) v4(150.65,178.71) v4(150.65,177.44) v4(150.65,176.17) v4(150.65,174.9) v4(151.26,170.81) v4(151.31,169.95) v4(151.31,169.19) v4(151.92,181.25) v4(151.92,179.98) v4(151.92,178.71) v4(151.92,177.44) v4(151.92,176.17) v4(152.32,169.95) v4(152.32,169.19) v4(152.78,172.97) v4(152.75,171.98) v4(153.03,170.81) v4(153.54,172.97) v4(153.54,171.96) v4(154.1,169.95) v4(154.1,169.19) v4(154.31,172.97) v4(154.31,171.96) v4(154.94,170.81) v4(155.12,169.95) v4(155.12,169.19) v4(156.84,170.81) v4(156.9,169.95) v4(156.9,169.19) v4(157.83,171.98) v4(157.86,172.97) v4(157.91,169.95) v4(157.91,169.19) v4(158.62,172.97) v4(158.62,171.96) v4(158.62,170.81) v4(159.38,172.97) v4(159.38,171.96) v4(159.54,181.25) v4(159.69,169.95) v4(159.69,169.19) v4(160.53,170.81) v4(160.71,169.95) v4(160.71,169.19) v4(160.81,181.25) v4(160.81,179.98) v4(160.81,178.71) v4(162.08,181.25) v4(162.08,179.98) v4(162.08,178.71) v4(162.08,177.44) v4(162.08,176.17) v4(162.08,174.9) v4(162.43,170.81) v4(162.48,169.95) v4(162.48,169.19) v4(162.94,172.97) v4(162.91,171.98) v4(163.35,181.25) v4(163.35,179.98) v4(163.35,178.71) v4(163.35,177.44) v4(163.5,169.95) v4(163.5,169.19) v4(163.7,172.97) v4(163.7,171.96) v4(164.21,170.81) v4(164.47,172.97) v4(164.47,171.96) v4(165.28,169.95) v4(165.28,169.19) v4(166.12,170.81) v4(166.29,169.95) v4(166.29,169.19) v4(168.02,170.81) v4(168.15,172.97) v4(168.12,171.98) v4(168.91,172.97) v4(168.91,171.96) v4(169.27,174.57) v4(169.44,170.66) v4(169.57,169.27) v4(169.67,172.97) v4(169.67,171.96) v4(170.56,170.05) v4(171.53,170.79) v4(171.53,169.27)
VCCH_GXE_FPGA_1.1V: length 90.5
  ART05 w0.254: v2(99.2,95.6) 99.61,95.19 99.61,94.91 99.66,94.87 99.66,94.79 99.66,94.79 99.66,94.41 99.66,94.41 99.66,94.33 99.61,94.29 99.61,92.91 99.66,92.87 99.66,90.79 99.66,90.79 99.66,90.41 99.66,90.41 99.66,88.33 99.61,88.29 99.61,87.91 99.66,87.87 99.66,85.79 99.66,85.79 99.66,85.41 99.66,85.41 99.66,85.33 99.61,85.29 99.61,81.4 97.38,79.17 94.92,79.17 92.85,77.1 92.85,73.95 87.55,68.66 81.1,68.66 78.51,66.06 69.36,66.06 59.45,56.15 54.63,56.15 54.12,55.64 49.92,55.64 48.92,54.64 48.21,54.64 47.79,54.21 47.79,53.78 v2(48.49,53.09) ; v2(14.48,46.67) 14.48,47.6 12.4,49.68 v4(11.81,49.68)
  BOTTOM w0.254: V13.1 4.49,45.53 2.92,45.53 2.67,45.78 R703.2 ; v2(48.49,53.09) 48.03,53.09 47.76,52.82 U32.14
  vias: v2(99.2,102.6) v2(99.2,101.6) v2(99.2,97.6) v2(99.2,96.6) v3(82.42,88.02) v3(82.5,87.05) v3(82.74,85.77) v3(82.74,84.27) v3(82.73,82.49) v3(82.73,80.16) v3(82.84,77.64) v3(83.64,80.21) v3(83.67,82.52) v3(83.77,77.62) v3(85.82,77.47) v3(85.82,76.63) v3(86.74,76.61) v3(86.76,77.49) v3(89.79,77.52) v3(89.78,76.57) v3(90.7,76.55) v3(90.78,77.52) v4(10.72,49.68) v4(10.74,48.72) v4(10.72,47.9) v4(10.74,47.19) v4(11.61,47.9) v4(11.63,47.19) v4(11.84,48.72) v4(12.4,48.18) v4(12.37,47.37)
VCCH_GXP_FPGA_1.8V:
  vias: v2(124.32,106.1) v2(124.32,104.1) v2(124.32,103.1) v2(124.32,101.1) v2(124.32,100.1) v2(125.18,103.6) v2(125.18,102.6) v3(145.64,108.9) v3(145.72,111.08) v3(145.72,110.13) v3(146.91,111.08) v3(146.94,110.12) v3(146.91,108.9) v3(147.95,110.08) v3(148.05,111.07) v3(148.44,109.37) v3(149.07,111.07) v3(149.71,109.37) v3(150.04,110.26)
VCCH_VDD33: length 3.5
  TOP w0.109: R1139.2 169.34,177.9 v3(169.75,177.5)
  TOP w0.254: R5463.1 172.86,173.78 v2(173.1,174.02)
  BOTTOM w0.254: R5460.2 166.94,180.84 v2(166.78,181)
  BOTTOM w0.305: v2(167.68,178.74) 167.68,178.74 R5459.2
  vias: v3(169.33,176.78) v3(169.35,179.32) v4(158.27,179.98)
VCCIO_FPGA_1.2V: length 165
  TOP w0.254: U6.L9 v2(118.83,149.71) ; U5.D1 v2(114.6,143.32) ; R879.2 v3(163.32,51.69) ; U6.A1 v2(126.03,140.92) ; R896.2 v3(163.33,54.23) ; U3.J8 v2(85.33,147.32) ; U5.J8 v2(108.19,147.32) ; U7.A1 v2(80.31,140.92) ; U3.R1 91.49,152.68 v2(91.74,152.92) ; U3.L1 v2(91.74,149.72) ; U6.J9 v2(118.82,147.32) ; U7.L1 80.27,149.68 v2(80.79,149.68) ; U6.F8 v2(119.62,144.92) ; U4.C1 v2(103.17,142.52) ; U7.J1 v2(80.31,147.32) ; U7.F2 v2(79.51,144.92) ; U6.J2 v2(125.23,147.32) ; v2(80.31,152.92) 80.06,152.68 U7.R1 ; U7.J9 v2(73.1,147.32) ; R895.2 v3(163.33,53.21) ; U7.G9 v2(73.1,145.72) ; U6.T9 v2(118.83,153.71) ; U6.D1 v2(126.03,143.32) ; U5.F2 v2(113.8,144.92) ; U23.P12 v2(42.74,175.12) ; U5.A9 v2(107.39,140.92) ; U4.A1 v2(103.17,140.92) ; U6.A9 v2(118.82,140.92) ; v2(80.31,145.72) U7.G1 ; U7.B3 v2(77.9,141.72) ; U6.D9 v2(118.82,143.32) ; U4.D1 v2(103.17,143.32) ; U3.B3 v2(89.33,141.72) ; U6.J8 v2(119.62,147.32) ; v2(126.03,145.72) U6.G1 ; U5.F8 v2(108.19,144.92) ; R897.2 v3(163.32,55.24) ; R898.2 v3(163.32,56.26) ; U23.P11 v2(42.74,174.32) ; U5.B3 v2(112.19,141.72) ; U3.L9 v2(84.54,149.71) ; U5.A1 v2(114.6,140.92) ; U4.R1 102.92,152.68 v2(103.17,152.92) ; U6.J1 v2(126.03,147.32) ; R138.2 v3(130.4,151.89) ; U5.L9 v2(107.4,149.71) ; U6.L1 v2(126.03,149.72) ; U7.F8 v2(73.9,144.92) ; U3.F2 v2(90.94,144.92) ; U5.D9 v2(107.39,143.32) ; U3.G7 v2(86.94,145.72) ; U6.F2 v2(125.23,144.92) ; U3.A9 v2(84.53,140.92) ; U4.T9 v2(95.97,153.71) ; U6.C1 v2(126.03,142.52) ; R914.2 v3(163.32,49.66) ; U69.2 141.98,145.51 142.37,145.9 ; U7.G7 v2(75.51,145.72) ; U4.J8 v2(96.76,147.32) ; U6.G9 v2(118.82,145.72) ; v2(103.17,145.72) U4.G1 ; U3.J2 v2(90.94,147.32) ; U6.B3 v2(123.62,141.72) ; U4.A9 v2(95.96,140.92) ; U3.T9 v2(84.54,153.71) ; U5.J9 v2(107.39,147.32) ; U3.C1 v2(91.74,142.52) ; v2(91.74,145.72) U3.G1 ; U4.F8 v2(96.76,144.92) ; v2(126.03,152.92) 125.78,152.68 U6.R1 ; U3.D9 v2(84.53,143.32) ; U4.J9 v2(95.96,147.32) ; U7.B9 v2(73.1,141.72) ; U7.J2 v2(79.51,147.32) ; U6.G7 v2(121.23,145.72) ; v2(114.6,152.92) 114.35,152.68 U5.R1 ; U4.G9 v2(95.96,145.72) ; U7.J8 v2(73.9,147.32) ; U4.J1 v2(103.17,147.32) ; U3.A1 v2(91.74,140.92) ; U5.T9 v2(107.4,153.71) ; U4.G7 v2(98.37,145.72) ; U3.B9 v2(84.53,141.72) ; U3.F8 v2(85.33,144.92) ; U5.B9 v2(107.39,141.72) ; v2(73.1,140.92) U7.A9 ; U4.L1 v2(103.17,149.72) ; U3.J1 v2(91.74,147.32) ; U4.D9 v2(95.96,143.32) ; U7.T9 v2(73.11,153.71) ; U3.G9 v2(84.53,145.72) ; U5.J2 v2(113.8,147.32) ; U4.B9 v2(95.96,141.72) ; R999.2 v3(163.32,45.97) ; U4.L9 v2(95.97,149.71) ; U4.B3 v2(100.76,141.72) ; U5.G7 v2(109.8,145.72) ; U6.B9 v2(118.82,141.72) ; U4.F2 v2(102.37,144.92) ; U5.G9 v2(107.39,145.72) ; R878.2 v3(163.32,50.67) ; U4.J2 v2(102.37,147.32) ; R893.2 v3(163.32,43.94) ; U5.L1 v2(114.6,149.72) ; U7.D1 v2(80.31,143.32) ; U7.C1 v2(80.31,142.52) ; v2(114.6,145.72) U5.G1 ; R913.2 v3(163.32,48.64) ; U3.J9 v2(84.53,147.32) ; U3.D1 v2(91.74,143.32) ; U5.C1 v2(114.6,142.52) ; R479.2 v3(163.29,47.12) ; U5.J1 v2(114.6,147.32) ; R894.2 v3(163.32,44.96) ; U7.D9 v2(73.1,143.32) ; U7.L9 v2(73.11,149.71)
  ART05 w0.381: v3(150.34,143.33) 151.64,142.04 151.64,137.9 155.93,133.6 v3(157.45,133.6)
  ART16 w0.508: v2(160.78,208.53) 161.67,209.42 166.5,209.42 v2(167.51,208.41) 168.28,207.65 168.28,205.23 169.67,203.84 169.67,199.26 168.02,197.61 v3(168.02,193.39)
  BOTTOM w0.254: R277.2 v3(145.8,193.45) ; R282.2 v3(163.58,193.45) ; v2(34.67,20.57) 33.41,20.57 C627.1 ; v2(66.04,84.2) 65.78,84.45 C548.1 ; v2(167,44.71) 166.48,44.71 C1330.1 ; C553.1 55.63,84.33 v2(55.5,84.2) ; v2(167,49.92) 166.3,49.92 C941.1 ; R280.2 v3(154.69,193.45) ; C661.1 C662.1 v2(160.78,208.53) ; R133.1 77.12,140.98 77.44,141.3 77.5,141.3 77.9,141.71 v2(77.9,141.72) ; v3(136.91,193.42) R275.2 ; C374.1 79.03,60.01 78.74,60.29 v2(78.74,60.71) ; v3(130.43,150.49) 130.05,150.11 R141.1 ; C938.1 166.43,54.49 v2(167,54.49) ; J16.5 v3(144.37,159.13) ; v2(167.51,208.41) C659.1 C658.1 ; v2(182.5,69.72) 182.5,70.02 C935.1 ; R281.2 v3(159.13,193.45) ; C290.1 113.19,110.79 112.61,111.36 112.6,111.42 112.58,111.43 112.58,111.8 112.67,111.9 112.67,112.31 112.6,112.38 112.6,112.79 112.67,112.86 112.67,113.28 112.38,113.58 112.01,113.58 111.51,114.08 111.18,114.08 110.65,114.62 110.25,114.62 110,114.87 110,115.33 110.09,115.42 110.09,115.78 109.95,115.92 109.95,116.28 110.1,116.43 110.1,116.78 109.98,116.91 109.98,117.27 110.11,117.4 110.11,118.14 C1122.1 109.83,118.43 R666.2 ; v2(55.5,90.67) 54.99,91.19 C578.1 ; R139.1 v3(130.21,154.56) ; v2(121.23,145.72) 122.32,145.72 C1515.2 ; v2(73.1,141.72) v2(73.1,140.92) 72.52,140.92 ; v2(66.04,90.67) 66.04,90.68 C575.1 65.34,89.01 66.39,87.96 v2(66.75,87.96) ; R283.2 v3(168.02,193.39) ; R276.2 v3(141.35,193.45) ; R278.2 v3(150.09,193.47)
  BOTTOM w0.305: v2(73.1,147.32) 72.73,146.94 C1546.2 ; C1547.2 72.31,140.92 72.52,140.92
  BOTTOM w0.381: v2(112.19,141.72) 111.7,141.72 C1517.2 ; v2(84.53,140.92) v2(84.53,141.72) ; v2(89.33,141.72) 88.66,141.72 88.66,141.76 C1488.2 ; C1516.2 123.15,141.72 v2(123.62,141.72) ; v2(109.8,145.72) 110.13,146.05 C1518.2 ; v2(95.96,140.92) v2(95.96,141.72) ; v2(107.39,140.92) v2(107.39,141.72) ; C1484.2 118.82,141 v2(118.82,141.72) ; v2(100.76,141.72) 100.22,141.72 C1487.2
  BOTTOM w0.508: J17.7 158.47,134.62 v3(157.45,133.6)
  vias: v2(34.04,17.21) v2(70.37,107.34) v2(70.37,105.87) v2(77.82,63.94) v2(79.09,63.94) v2(81.51,63.94) v2(105.26,108.1) v2(105.26,95.1) v2(106.13,111.6) v2(106.13,110.6) v2(106.13,92.6) v2(106.13,91.6) v2(107,108.1) v2(107,95.1) v2(107.86,111.6) v2(107.86,110.6) v2(107.86,92.6) v2(107.86,91.6) v2(108.73,108.1) v2(108.73,95.1) v2(109.6,111.6) v2(109.6,110.6) v2(111.33,111.6) v2(111.33,110.6) v2(113.06,111.6) v2(113.06,110.6) v2(113.06,92.6) v2(113.06,91.6) v2(114.79,111.6) v2(114.79,110.6) v2(114.79,92.6) v2(114.79,91.6) v2(116.52,111.6) v2(116.52,110.6) v2(116.52,109.6) v2(116.52,108.6) v2(116.52,94.6) v2(116.52,93.6) v2(116.52,92.6) v2(116.52,91.6) v2(118.26,111.6) v2(118.26,110.6) v2(118.26,92.6) v2(118.26,91.6) v2(121.72,93.6) v2(127.71,48.68) v2(128.9,48.68) v2(160.15,102.69) v2(160.99,101.35) v2(161.04,100.61) v2(162,101.35) v2(162.05,100.61) v2(166.67,95.18) v2(167.47,95.98) v2(167.47,95.18) v2(169.07,102.23) v2(169.07,97.58) v2(169.07,96.78) v2(169.87,96.78) v2(170.67,97.58) v2(170.67,96.78) v2(170.79,102.18) v2(172.11,102.77) v3(37.66,22.61) v3(37.66,21.34) v3(37.66,20.07) v3(37.66,18.8) v3(58.46,91.44) v3(58.46,90.42) v3(58.46,89.41) v3(58.46,85.09) v3(58.46,83.95) v3(58.46,82.93) v3(65.54,81.97) v3(69.5,92.71) v3(69.5,91.69) v3(69.5,90.68) v3(69.5,89.53) v3(69.53,86.11) v3(69.53,85.09) v3(69.53,84.07) v3(69.53,83.06) v3(96.8,75.51) v3(97.43,76.12) v3(98.45,75.54) v3(99.08,76.15) v3(100.18,124.46) v3(100.25,75.54) v3(100.89,76.15) v3(102.08,124.46) v3(103.72,124.49) v3(105.19,124.46) v3(106.78,124.46) v3(112.33,156.53) v3(149.58,144.86) v3(149.58,144.09) v3(149.58,143.33) v3(150.34,144.86) v3(150.34,144.09) v3(159.66,102.51) v3(159.66,101.98) v3(160.17,102.11) v3(180.97,72.96) v3(181.99,72.96) v3(183.01,72.96) v3(184.02,72.96) v4(210.77,173.1) v4(210.77,171.83) v4(210.77,170.56) v4(210.77,169.29) v4(210.77,162.94) v4(210.77,161.67) v4(210.77,160.4) v4(210.77,159.13) v4(211.28,179.11) v4(211.29,178.01) v4(211.28,176.19) v4(211.29,175.09) v4(211.41,157.01) v4(211.42,155.91) v4(211.41,154.22) v4(211.42,153.12) v4(211.41,151.29) v4(211.42,150.19) v4(212.04,173.1) v4(212.04,171.83) v4(212.04,170.56) v4(212.04,169.29) v4(212.04,162.94) v4(212.04,161.67) v4(212.04,160.4) v4(212.04,159.13) v4(212.55,179.11) v4(212.56,178.01) v4(212.55,176.19) v4(212.56,175.09) v4(212.81,151.42) v4(212.81,150.32) v4(212.93,157.01) v4(212.94,155.91) v4(213.06,154.22) v4(213.07,153.12) v4(213.31,173.1) v4(213.31,171.83) v4(213.31,170.56) v4(213.31,169.29) v4(213.31,162.94) v4(213.31,161.67) v4(213.31,160.4) v4(213.31,159.13) v4(214.46,175.93) v4(214.74,176.85) v4(215.56,175.94) v4(215.84,176.86)
VCCIO_FPGA_1.5V: length 50.9
  ART03 w0.254: v3(38.1,46.75) 37.17,46.75 v4(34.29,43.87)
  ART18 w0.254: v4(36.45,42.51) 37.52,43.57 37.52,46.16 v3(38.1,46.75)
  BOTTOM w0.254: R39.2 R45.2 107.22,84.03 106.4,83.21 106.4,79.25 C1389.2 ; v3(100.63,79.22) 101.05,78.8 R27.2 R29.2 ; R40.1 R46.1 100.87,86.35 101.57,85.65 101.57,84.63 101.22,84.28 v3(101.22,79.91) ; v2(111.33,91.6) 111.33,91.32 110.9,90.89 110.87,90.79 110.87,90.72 110.86,90.7 110.86,90.39 110.93,90.32 110.93,89.84 110.66,89.56 109.45,89.56 107.26,87.38 R31.2 R34.2 ; V17.1 34.38,41.34 35.75,41.34 35.94,41.53 R718.1 ; v2(48.36,52.07) 48.11,51.82 U32.16 ; R51.2 R49.2 108.27,89.92 109.13,90.78 109.17,90.91 109.57,91.31 109.57,91.52 C1387.1
  vias: v2(109.6,92.6) v2(109.6,91.6) v2(111.33,92.6) v3(102.51,75.41) v3(103.15,76.02) v4(34.29,43.1) v4(35.13,43.79) v4(35.05,43.13) v4(35.43,42.49) v4(35.79,43.13) v4(35.86,43.84)
VCCIO_FPGA_1.8V: length 141.2
  TOP w0.254: v3(181.46,124.08) 181.77,123.76 R483.1 ; U23.D11 v2(33.94,174.32) ; U43.1 179.15,126.24 179.08,126.17 C942.2 ; U23.E12 v2(34.73,175.12) ; U23.E11 v2(34.73,174.32) ; R485.1 v3(179.52,123.98) ; R1024.1 33.51,139.52 33.84,139.19 34.72,139.19 V25.1
  TOP w0.305: v2(44.88,145.74) 44.99,145.86 R81.2 ; R83.2 48.72,146.75 49.02,146.44 v2(49.02,146.18) ; R80.2 44.48,158.94 v2(44.3,159.13) ; R84.1 v2(40.89,159.77)
  TOP w0.508: v4(178.56,126.92) C942.2 ; R499.2 v4(183.64,124.59)
  ART07 w0.381: v2(47.6,158.18) 47.36,157.94 46.53,157.94 46.07,157.48 46.07,156.59 45.57,156.08 45.57,154.23 47.88,151.92 47.88,147.97 48.82,147.03 48.82,146.78 49.02,146.57 v2(49.02,146.18) 48.59,145.74 v2(44.88,145.74)
  ART18 w0.254: 94,82.73 94,80.42 93.14,79.55 76.5,79.55 75.82,78.87 65.94,78.87 61.94,74.87 61.94,73.14 58.87,70.08 55.57,70.08 53.49,67.99 53.49,61.7 50.04,58.24 50.04,56.44 v2(49.32,55.73)
  ART20 w0.381: v2(116.99,122.6) 117.32,122.94 v3(120.93,122.94)
  BOTTOM w0.254: 137.41,77.6 137.35,77.6 136.11,78.84 134.84,78.84 R61.1 ; v3(128.45,122.81) 125.95,122.81 125.51,122.37 125.51,121.95 125.66,121.8 125.66,121.44 125.58,121.36 125.58,120.85 125.65,120.78 125.65,120.33 125.58,120.26 125.58,119.9 125.67,119.81 125.67,119.41 125.56,119.3 125.56,118.94 125.69,118.81 125.69,118.45 125.55,118.31 125.55,117.88 125.86,117.58 126.29,117.58 126.77,117.09 127.12,117.09 127.38,116.84 127.38,116.33 127.3,116.25 127.3,115.89 127.62,115.57 127.97,115.57 128.62,114.91 R71.1 ; U32.15 47.89,52.32 48.13,52.55 48.92,52.55 49.32,52.96 v2(49.32,55.73) ; v2(116.99,122.6) 116.43,122.05 R948.1 ; R1.2 v2(144.63,87.63) ; v3(120.93,122.94) 121.41,122.94 122.02,122.33 122.02,122 122.21,121.81 122.21,121.37 122.09,121.26 122.09,120.9 122.22,120.77 122.22,120.41 122.1,120.29 122.1,119.88 122.22,119.76 122.22,119.38 122.11,119.26 122.11,118.9 122.2,118.8 122.2,118.39 122.09,118.28 122.09,117.92 122.22,117.78 122.22,117.42 121.87,117.07 121.53,117.07 121.22,116.77 121.22,116.41 121.34,116.29 121.34,115.9 121.05,115.62 119.18,115.62 118.73,116.07 118.08,116.07 117.58,116.57 117.2,116.57 116.71,116.08 116.3,116.08 116.04,115.81 116.04,115.41 116.43,115.01 R69.1 ; C1949.2 v3(24.99,119.35) ; R7.2 v2(144.63,83.82)
  BOTTOM w0.381: R2.2 v2(144.63,82.55)
  BOTTOM w0.508: R183.2 181.6,118 v2(181.33,117.73)
  vias: v2(32.05,156.77) v2(33.86,156.77) v2(37.59,156.84) v2(38.48,156.84) v2(56.64,147.97) v2(57.68,147.98) v2(58.6,147.98) v2(102.67,110.6) v2(102.67,109.6) v2(102.67,108.6) v2(119.99,92.6) v2(119.99,91.6) v2(141.39,80.01) v2(141.39,78.74) v2(141.39,76.2) v2(143.93,79.88) v2(143.93,77.34) v2(146.83,79.53) v2(156.25,80.85) v2(171.47,97.58) v2(172.27,97.58) v2(172.27,96.78) v2(172.27,91.18) v2(172.27,90.38) v2(173.07,96.78) v2(173.07,90.38) v2(173.87,93.58) v2(174.67,95.98) v2(174.67,95.18) v2(174.67,93.58) v2(174.67,92.78) v2(174.67,91.98) v2(178.87,87.91) v2(179.04,105.08) v2(179.04,104.19) v2(179.04,103.35) v2(179.04,102.23) v2(179.73,87.91) v2(183.34,103.61) v2(183.42,104.5) v2(183.42,79.1) v2(183.39,78.21) v2(184.3,78.18) v2(184.48,103.58) v2(191.08,103.66) v2(191.06,78.26) v2(191.99,104.5) v2(191.97,103.66) v2(191.99,79.1) v2(191.97,78.23) v3(29.44,150.75) v3(29.44,149.86) v3(29.44,148.97) v3(29.44,148.08) v3(30.33,150.75) v3(30.33,148.97) v3(30.33,148.08) v3(36.29,162.56) v3(36.29,161.42) v3(38.61,161.97) v3(64.87,96.52) v3(137.84,77.06) v3(137.84,76.2) v4(32.23,141.38) v4(32.23,140.49) v4(32.97,141.38) v4(32.97,140.49) v4(33.99,141.35) v4(33.99,140.46) v4(34.8,141.38) v4(34.8,140.49)
VCCL_HPS_FPGA_0.9V: length 118.2
  ART07 w0.254: v4(19.58,44.63) 20.69,43.52 26.44,43.52 26.86,43.1 v2(29.18,43.1)
  ART16 w0.254: v2(47.24,54.86) 51.76,54.86 52.82,55.93 56.79,55.93 59.41,58.55 59.41,62.74 71.15,74.47 71.15,91.92 72.58,93.36 76.5,93.36 77.72,94.58 77.72,106.43 81.38,110.08 85.52,110.08 86,110.56 86.41,110.56 86.87,110.11 87.3,110.11 87.79,110.6 88.15,110.6 88.64,110.1 89,110.1 89.51,110.6 89.87,110.6 90.36,110.11 90.72,110.11 91.21,110.6 91.59,110.6 92.11,110.08 92.47,110.08 92.94,109.62 93.32,109.62 93.77,110.06 94.19,110.06 94.65,109.6 95.05,109.6 95.52,110.07 95.92,110.07 96.49,110.64 100.24,110.64 100.76,110.12 101.12,110.12 101.61,110.62 101.97,110.62 102.5,110.08 102.86,110.08 103.34,109.6 103.92,109.6 v2(104.4,109.6)
  BOTTOM w0.254: U32.12 47.21,54.86 v2(47.24,54.86) ; V9.1 20.41,40.91 18.84,40.91 18.59,41.16 R681.2
  vias: v2(104.4,108.6) v2(104.4,107.6) v2(106.13,109.6) v2(106.13,108.6) v3(62.58,107.31) v3(62.58,106.43) v3(63.47,107.31) v3(63.47,106.43) v3(68.68,106.43) v3(68.68,105.54) v3(69.57,106.43) v3(69.57,105.54) v4(16.64,44.91) v4(16.66,44.2) v4(17.4,44.91) v4(17.42,44.2) v4(17.65,43.28) v4(17.68,42.27) v4(18.69,43.31) v4(18.72,42.29) v4(18.82,44.63) v4(19.61,43.31) v4(19.63,42.29)
VCCL_SDM_FPGA_0.8V: length 126.7
  TOP w0.381: TP175.1 137.01,29.62 v4(131.6,29.62)
  ART05 w0.254: v2(118.26,93.6) 117.85,93.2 117.85,92.85 117.8,92.79 117.8,92.4 117.85,92.34 117.85,91.85 117.8,91.79 117.8,91.41 117.87,91.34 117.87,90.86 117.8,90.79 117.8,90.41 117.85,90.35 117.85,89.84 117.78,89.77 117.78,89.36 117.85,89.29 117.85,88.91 117.8,88.86 117.8,88.41 117.82,88.39 117.82,88.32 117.85,88.29 117.85,87.91 117.49,87.56 117.2,87.56 116.93,87.29 116.93,86.84 116.98,86.79 116.98,86.41 116.63,86.06 116.33,86.06 115.85,85.57 115.42,85.57 115.02,85.17 115.01,85.17 114.98,85.14 114.6,85.14 114.17,85.57 113.8,85.57 113.37,85.14 112.87,85.14 112.44,85.57 111.95,85.57 111.52,85.14 111.14,85.14 110.71,85.57 110.21,85.57 109.64,85 106.08,85 105.51,85.57 105.02,85.57 104.5,85.06 104.21,85.06 104.17,85.01 104.16,85.01 103.78,84.63 102.31,84.63 100.94,83.26 100.94,81 87.63,67.69 81.28,67.69 78.94,65.35 69.47,65.35 59.82,55.7 54.81,55.7 54.31,55.19 50.19,55.19 49.01,54.01 v2(48.27,54.01) ; v2(143.16,18.82) 143.16,19.45 143.15,19.46 143.15,20.09 144.02,20.96 144.02,22.07 136.47,29.62 v4(131.6,29.62)
  BOTTOM w0.127: V11.1 129.06,26.99 130.4,26.99 130.53,27.11 R690.1
  BOTTOM w0.254: v2(48.27,54.01) 47.57,53.32 U32.13
  vias: v2(118.26,94.6) v2(119.99,94.6) v2(119.99,93.6) v3(124.05,78.36) v3(124.05,77.44) v3(124.05,76.58) v3(125.83,78.28) v3(125.83,77.44) v3(125.83,76.58) v3(127.61,77.44) v3(127.61,76.58) v4(129.62,29.64) v4(129.62,28.88) v4(130.02,28.22) v4(130.58,29.62) v4(130.58,28.88) v4(131.04,28.19) v4(131.55,28.85)
VCCLPLLDIG_HPS_FPGA_0.9V:
  vias: v2(104.4,111.6) v2(104.4,110.6) v3(68.43,99.44) v3(68.43,98.55) v3(69.31,99.44) v3(69.31,98.55)
VCCLPLLDIG_SDM_FPGA_0.8V:
  vias: v2(123.45,92.6) v2(123.45,91.6) v3(131.75,77.34) v3(131.77,76.48) v3(132.84,77.32) v3(132.84,76.48)
VCCLSENSE: length 45.9
  ART03 w0.254: v2(106.13,101.6) 105.79,101.26 105.79,100.91 105.47,100.58 105.16,100.58 105.13,100.56 105.08,100.56 104.59,100.08 104.15,100.08 103.72,99.64 103.72,99.64 103.64,99.57 103.35,99.57 102.84,99.06 102.46,99.06 101.96,98.56 101.61,98.56 101.12,98.07 100.71,98.07 100.23,97.59 99.9,97.59 99.39,97.08 98.96,97.08 98.44,96.56 98.15,96.56 97.7,96.11 97.37,96.11 97.31,96.06 97.28,96.06 96.8,95.58 96.41,95.58 95.93,96.06 95.5,96.06 95.04,95.6 94.71,95.6 94.26,96.06 93.77,96.06 93.34,95.63 92.91,95.63 92.51,96.03 92.49,96.03 92.46,96.06 92.09,96.06 91.82,95.79 91.82,95.41 91.87,95.36 91.87,94.92 91.6,94.64 91.15,94.64 90.73,95.06 90.37,95.06 89.87,95.56 89.52,95.56 89.02,96.06 88.62,96.06 88.2,95.63 87.76,95.63 87.27,95.14 86.9,95.14 86.4,94.64 85.95,94.64 85.54,95.06 84.9,95.06 83.87,94.03 82.4,94.03 80.29,96.14 76.45,96.14 76.04,96.55 71.79,96.55 70.32,95.08 68.99,95.08 v2(68.64,94.74)
VCCPT_FLTR_FPGA_1.8V:
  vias: v2(103.53,112.1) v2(103.53,111.1) v2(121.72,92.6) v2(121.72,91.6) v2(125.18,92.6) v2(125.18,91.6) v3(154.22,76.2) v3(158.5,68.07) v3(159.13,67.44) v3(159.13,65.53) v3(159.77,66.8)
VCCPT_FPGA_1.8V: length 9.6
  TOP w0.254: 198.58,119.13 198.6,119.15 TP172.1
  BOTTOM w0.254: R643.1 121.17,111.96 C1104.1 120.89,111.82 120.16,111.09 119.76,111.09 119.48,110.81 119.48,110.45 119.61,110.32 119.61,109.93 119.25,109.58 118.91,109.58 118.45,109.12 118.08,109.12 117.55,108.58 117.17,108.58 116.68,108.1 v2(115.66,108.1)
  vias: v2(110.46,108.1) v2(110.46,95.1) v2(112.19,108.1) v2(112.19,95.1) v2(113.92,108.1) v2(113.92,95.1) v2(115.66,95.1) v3(145.01,113.44) v3(145.01,112.32) v3(145.16,114.43) v3(146.99,114.43) v3(147.04,112.32) v3(147.06,113.44) v3(148.94,112.32) v3(149.1,114.43) v3(149.07,113.44) v3(151.1,114.43) v3(151.1,113.44) v3(151.1,112.32) v3(156.08,93.09) v3(156.08,92.46) v3(156.72,93.09) v3(156.72,92.46) v3(157.35,92.58) v3(157.86,92.96) v3(158.37,122.56) v3(158.37,121.16) v3(158.37,120.14) v3(158.37,92.58) v3(159,118.87) v3(159,92.46) v3(159.26,92.96) v3(159.51,122.56) v3(173.23,119.76) v3(173.86,119.13) v3(174.37,118.36) v3(175.51,118.75) v3(175.51,117.86) v3(184.78,128.78) v4(188.19,125.47) v4(188.29,127.94) v4(189.46,127.91) v4(191.39,128.22) v4(192.56,128.19) v4(193.04,126.03) v4(193.65,120.09) v4(193.68,123.44) v4(193.68,121.54) v4(194.23,126.95) v4(194.21,126.01) v4(194.17,124.75) v4(196.18,121.26) v4(196.34,129.57) v4(196.34,128.3) v4(196.34,127.03) v4(196.34,125.76) v4(196.42,120.24) v4(197.43,121.34) v4(197.49,120.29) v4(197.61,129.57) v4(197.61,128.3) v4(197.61,127.03) v4(197.61,125.76) v4(197.61,124.49) v4(197.61,123.22) v4(198.88,129.57) v4(198.88,128.3) v4(198.88,127.03) v4(198.88,125.76) v4(198.88,124.49) v4(206.5,129.57) v4(207.77,129.57) v4(207.77,128.3) v4(207.77,127.03) v4(209.04,129.57) v4(209.04,128.3) v4(209.04,127.03) v4(209.04,125.76) v4(209.04,124.49) v4(209.04,123.22) v4(210.31,129.57) v4(210.31,128.3) v4(210.31,127.03) v4(210.31,125.76) v4(211.43,126.06) v4(211.46,127.23) v4(211.51,124.33) v4(211.48,123.16) v4(211.99,119.79) v4(212.09,121.06) v4(213.06,119.84) v4(213.16,121.11) v4(213.64,128.27) v4(213.66,126.79) v4(214.81,128.24) v4(214.83,126.77) v4(214.81,123.29) v4(214.81,122.09) v4(214.86,125.42) v4(214.86,124.23) v4(215.19,120.98) v4(215.24,119.84) v4(216.03,125.4) v4(216.03,124.2) v4(215.98,123.26) v4(215.98,122.07) v4(216.1,127.94) v4(216.08,126.77) v4(216.26,121.03) v4(216.31,119.89)
VCCRT_GXE_FPGA_0.9V:
  vias: v2(96.6,103.1) v2(96.6,102.1) v2(96.6,101.1) v2(96.6,100.1) v2(96.6,99.1) v2(96.6,98.1) v2(96.6,97.1) v2(96.6,96.1) v2(97.47,103.6) v2(97.47,102.6) v2(97.47,101.6) v2(97.47,97.6) v2(97.47,96.6) v2(97.47,95.6) v3(73.08,107.49) v3(74.35,107.49) v3(75.67,107.49) v3(76.78,107.49) v3(77.85,107.49) v3(78.84,105.51) v3(78.99,103.58) v3(79.15,106.91) v3(80.01,107.06) v3(80.01,105.05) v3(80.16,103.5) v3(81.4,97.99) v3(81.63,101.85) v3(81.63,93.22) v3(81.81,103.56) v3(81.84,100.41) v3(81.82,95.88) v3(81.76,91.35) v3(81.76,89.28) v3(82.24,98.02) v3(82.52,96.39) v3(82.52,94.74) v3(82.65,101.85) v3(82.68,103.56) v3(82.8,91.41) v3(82.78,89.28) v3(82.9,93.24) v3(83.11,100.41) v3(83.08,97.94) v3(83.52,103.53) v3(83.67,101.85) v3(83.67,95.38) v3(83.74,91.39) v3(83.67,89.28) v3(83.79,93.24)
VCCRT_GXP_FPGA_0.9V:
  vias: v2(126.05,106.1) v2(126.05,105.1) v2(126.05,101.1) v2(126.92,106.6) v2(126.92,105.6) v2(126.92,104.6) v2(126.92,103.6) v2(126.92,102.6) v2(126.92,101.6) v2(126.92,100.6) v2(140.64,108.68) v2(140.69,105.87) v2(141.15,108.68) v2(141.2,105.87) v2(141.65,108.68) v2(141.7,105.87)
VCCRTPLL_GXE_FPGA_0.9V:
  vias: v2(98.34,100.1) v2(98.34,99.1) v3(76.15,91.57) v3(76.12,90.12) v3(76.12,88.85) v3(77.14,90.12) v3(77.14,88.85) v3(77.19,91.59)
VDD_SODIMM: length 83
  TOP w0.254: v2(124.74,54.69) 124.57,54.52 CON1.130 ; CON1.111 129.31,61.51 129.31,62.38 129.21,62.48 129.21,62.49 129.1,62.6 v2(129.1,62.74) ; v2(116.82,60.3) CON1.153 ; v2(127.9,62.71) 127.86,62.71 127.82,62.67 CON1.117 ; CON1.124 126.07,54.52 v2(125.91,54.69) ; U67.2 79.72,50.38 79.98,50.11 ; v2(114.03,60.1) 114.32,60.38 CON1.163 ; v2(127.25,54.66) 127.25,54.52 127.57,54.2 CON1.118 ; v2(124.51,62.91) 124.82,62.6 CON1.129 ; CON1.160 115.07,54.58 v2(115.02,54.63) ; CON1.141 v2(121.82,62.86) ; v2(123.04,62.89) 123.04,62.89 123.32,62.61 CON1.135 ; CON1.123 v2(126.32,62.74) ; CON1.159 v2(115.32,60.35) ; CON1.147 118.32,60.51 v2(118.63,60.2)
  TOP w0.279: CON1.112 v2(129.07,52.07) ; v2(123.04,51.89) 123.07,51.93 CON1.136 ; CON1.142 121.57,51.93 v2(121.61,51.89) ; CON1.154 v2(116.57,51.48) ; CON1.148 118.07,51.64 v2(118.17,51.54)
  ART03 w0.254: v2(47.77,49.73) 48.28,49.73 50.44,47.57 50.44,44.6 53.97,41.07 72.29,41.07 74.75,43.54 77.11,43.54 77.14,43.56 v3(78.11,43.56)
  ART07 w0.254: v4(116.69,26.19) 116.1,25.6 116.1,17.67 v2(117.14,16.62)
  BOTTOM w0.109: C1427.1 v2(114.03,60.1)
  BOTTOM w0.254: v4(115.19,28.22) 113.47,28.22 113.18,28.51 113.18,30.04 V23.1 ; v2(47.77,49.73) 47.74,49.75 47.74,49.79 U32.19
  BOTTOM w0.279: R109.2 129.07,52.07 v2(129.07,52.07)
  BOTTOM w0.508: R1151.1 117.2,47.69 C1448.1
  vias: v2(103.38,48.18) v2(104.39,48.18) v2(105.66,48.18) v2(106.68,48.18) v2(108.07,48.18) v2(109.09,48.18) v2(110.49,48.18) v2(111.5,48.18) v2(115.67,51.94) v2(116.84,48.39) v2(117.2,56.55) v2(117.96,48.26) v2(118.89,55.45) v2(118.97,48.26) v2(119.1,51.18) v2(119.36,52.56) v2(119.99,48.26) v2(121.13,48.26) v2(122.15,48.26) v2(125.5,48.3) v2(126.52,48.3) v2(128.32,55.57) v3(78.11,42.8) v3(78.82,43.54) v3(78.82,42.82) v3(80.24,43.56) v3(80.24,42.8) v3(100.23,48.01) v3(100.18,46.66) v3(100.53,45.62) v3(101.95,48.01) v3(101.98,46.56) v3(102.11,45.29) v4(114.56,27.27) v4(114.71,29.19) v4(115.74,29.19) v4(115.72,27.25) v4(115.72,26.21) v4(116.74,29.16) v4(116.71,28.19) v4(116.71,27.23) v4(117.6,29.13) v4(117.58,28.17)
24M_XTALIN: length 6.8
  TOP w0.163: U21.5 19.67,177.78 19.46,177.57 17.35,177.57 16.35,178.57 C665.1 16.35,179.84 16.11,180.08 Y1.1
24M_XTALOUT: length 7.1
  TOP w0.163: U21.4 19.58,178.28 19.48,178.18 17.96,178.18 17.36,178.78 C666.1 17.36,179.84 16.84,180.36 16.84,181.71 17.22,182.1 Y1.3
ADI_I2C_ALERTN: length 292.9
  TOP w0.109: v2(159.51,157.86) 155.83,157.86 152.65,154.69 144.15,154.69 143.76,154.31 SW6.3 ; v2(173.56,178.51) 173,179.07 R1131.1 ; R927.2 v2(160.15,92.2)
  ART03 w0.114: v2(173.56,178.51) 177.19,178.51 178.64,179.96 194.56,179.96 195.83,181.23 195.83,181.82 197.2,183.18 200.46,183.18 200.86,182.78 203.4,182.78 204.14,183.51 v2(206.02,183.51)
  ART05 w0.114: v2(202.29,116.31) 202.29,116.81 198.87,120.23 198.87,121.86 198.42,122.31 198.42,123.41 198.69,123.68 199.13,123.68 199.44,123.99 199.44,138.48 200.69,139.73 203.02,139.73 203.94,140.64 203.94,149.15 205.05,150.27 205.05,161.9 204.57,162.38 202.97,162.38 202.49,162.86 202.49,180.54 200,183.03 200,186.54 200.56,187.1 203.84,187.1 206.02,184.91 v2(206.02,183.51)
  ART07 w0.114: v2(188.56,164.66) 185.53,164.66 184.89,165.3 184.89,174.19 182.73,176.35 179.48,176.35 177.32,178.51 v2(173.56,178.51)
  ART18 w0.114: v2(159.51,157.86) 159.51,160.15 163.45,164.08 170.61,164.08 173.99,167.46 173.99,178.08 v2(173.56,178.51) ; v2(160.15,92.2) 160.88,91.47 160.88,81.79 162.45,80.22 171.75,80.22 172.66,79.31 181.65,79.31 183.23,77.72 184.5,77.72 185.14,78.36 185.14,78.87 186.03,79.76 189.71,79.76 190.6,80.64 190.6,81.66 191.49,82.55 192.5,82.55 195.43,85.47 195.43,88.26 196.95,89.79 196.95,95 199.74,97.79 199.74,104.65 201.47,106.38 201.47,113.15 201.66,113.34 201.66,115.68 v2(202.29,116.31)
  BOTTOM w0.109: R676.2 v2(188.56,164.66) ; v2(159.51,157.86) 159.89,157.48 J35.6 ; v2(206.02,183.51) 206.22,183.72 R569.1 ; v2(202.29,116.31) 202.92,116.31 204.83,118.21 R654.1
ADI_I2C_ALERTN_R: length 18.9
  TOP w0.109: R1131.2 v2(170.54,179.07) ; R5458.1 v2(167.59,176.78)
  ART05 w0.114: v4(154.46,176.17) 154.91,176.17 155.52,176.78 v2(167.59,176.78) 167.79,176.78 170.08,179.07 v2(170.54,179.07)
ADI_I2C_SCL: length 253.7
  TOP w0.109: SW6.1 141.22,154.69 142.3,155.76 152.08,155.76 v2(154.31,157.99) ; v2(167.72,178) 167.8,178.08 R1139.1
  ART03 w0.114: v2(200.86,119.86) 200.15,120.57 v1(200.15,123.22) ; v2(167.72,178) 167.72,178.02 167.91,178.21 171.45,178.21 172.26,179.02 175.87,179.02 177.91,181.06 193.93,181.06 196.01,183.14 196.01,183.64 197.94,185.57 201.02,185.57 v2(201.4,185.95) 201.4,188.57 v1(201.55,188.72)
  ART05 w0.114: v2(201.4,185.95) 201.4,184.91 202.22,184.09 202.72,184.09 204.95,181.86 204.95,178.56 206.12,177.39 206.76,177.39 207.52,176.63 207.52,164.77 v1(206.96,164.21) 207.65,163.53 207.65,158.88 206.4,157.63 206.4,138.96 205.92,138.48 205.92,135.61 205.59,135.28 202.23,135.28 201.96,135 201.96,124.33 201.32,123.7 200.63,123.7 v1(200.15,123.22) ; v2(167.72,178) 166.34,179.37 155.37,179.37 155.12,179.12 155.12,178.51 154.57,177.96 152.97,177.96 152.6,177.59 152.6,175.87 153.19,175.29 v4(153.19,174.9) 150.09,171.81 150.09,168.86 149.35,168.12 146.13,168.12 144.73,166.73 144.73,162.66 145.82,161.57 146.25,161.57 148.29,159.54 152.96,159.54 154.31,158.19 v2(154.31,157.99) ; v2(172.88,132.97) 174.37,132.97 175.9,134.49 v2(178.69,134.49)
  ART07 w0.114: v2(188.65,166.88) 188.65,165.81 189.61,164.85 189.61,163.6 191.8,161.42 195.24,161.42 198.25,158.41 202.19,158.41 202.51,158.73 202.51,161.77 202.93,162.19 205.66,162.19 206.27,162.8 206.27,163.53 v1(206.96,164.21)
  ART16 w0.114: v2(200.86,119.86) 200,120.73 200,121.36 198.32,123.04 198.32,127.14 197.85,127.61 196.19,127.61 195.61,128.19 193.29,128.19 192.7,127.61 191.27,127.61 189.84,129.03 186.61,129.03 185.82,128.24 183.8,128.24 182.85,129.18 182.85,131.6 179.96,134.49 v2(178.69,134.49)
  BOTTOM w0.109: R564.1 201.78,185.57 v2(201.4,185.95) ; v2(200.86,119.86) 200.77,119.77 R648.1 ; J35.2 154.81,157.48 v2(154.31,157.99) ; R673.1 v2(188.65,166.88)
ADI_I2C_SDA: length 262.8
  TOP w0.109: SW6.2 142.49,154.69 143,155.19 152.27,155.19 v2(155.07,157.99) ; R926.2 173.74,131.7 v2(174.75,132.72) ; R1138.1 167.87,179.32 v2(167.74,179.45)
  ART03 w0.114: v1(202.82,191.26) 202.23,190.68 201.29,190.68 200.89,190.27 200.89,188.57 200.69,188.37 v2(200.69,186.06) 197.46,186.06 195.2,183.79 195.2,183.26 193.45,181.51 177.55,181.51 175.53,179.5 171.98,179.5 171.12,178.64 168.55,178.64 v2(167.74,179.45) ; v1(201.42,125.76) 200.84,125.17 200,125.17 199.62,124.79 199.62,122.25 199.72,122.15 199.72,120.45 v2(199.64,120.38)
  ART05 w0.114: v2(199.64,120.38) 199.29,120.73 199.29,121.08 199.57,121.36 199.57,123.52 200.07,124.02 200.34,124.02 200.76,124.44 200.76,137.62 201.04,137.9 204.37,137.9 205.77,139.29 205.77,158.27 206.31,158.81 206.31,161.86 206.96,162.51 v1(206.96,162.94) 206.32,163.58 206.32,175.46 203.68,178.1 203.68,180.75 201.27,183.16 201.27,183.97 200.69,184.56 v2(200.69,186.06) ; v2(167.74,179.45) 168.15,179.05 168.15,177.73 167.83,177.42 167,177.42 166.37,178.05 155.47,178.05 154.86,177.44 v4(154.46,177.44) 153.87,176.86 153.87,174.6 153.06,173.79 152.78,173.79 150.57,171.58 150.57,168.63 149.56,167.61 146.29,167.61 145.16,166.49 145.16,163.35 148.54,159.97 153.72,159.97 155.07,158.62 v2(155.07,157.99) ; v2(178.69,133.73) 175.77,133.73 v2(174.75,132.72)
  ART07 w0.114: v1(206.96,162.94) 206.96,162.46 206.44,161.94 206.44,161.28 206.17,161.01 204.01,161.01 203.76,160.76 203.76,158.72 203.05,158.01 197.94,158.01 195,160.96 191.64,160.96 189.18,163.42 189.18,164.67 187.96,165.89 187.96,167.64 v2(188.59,168.28)
  ART16 w0.114: v2(178.69,133.73) 180.09,133.73 182.34,131.47 182.34,128.91 183.49,127.76 186.11,127.76 186.89,128.55 189.61,128.55 191.01,127.15 193.29,127.15 193.8,127.66 194.84,127.66 195.99,126.51 196.58,126.51 196.81,126.28 196.81,126.02 196.86,125.97 196.86,125.54 196.81,125.49 196.81,123.03 197.86,121.98 198.62,121.98 199.29,121.31 199.29,120.73 199.64,120.37 v2(199.64,120.38)
  BOTTOM w0.109: R647.1 199.56,120.38 v2(199.64,120.38) ; R672.1 v2(188.59,168.28) ; v2(155.07,157.99) 156.97,157.99 157.35,157.61 J35.4
  BOTTOM w0.305: v2(200.69,186.06) 200.51,185.88 R566.1
AVST_CLK: length 70.4
  ART18 w0.114: v2(172.21,102.06) 172.54,102.39 172.54,103.2 172.24,103.5 172.24,107.65 169.59,110.3 169.01,111.53 168.61,114.66 167.34,115.93 161.06,115.93 158.26,118.73 157.4,120.98 157.4,122.17 156.9,122.68 156.77,122.68 156.29,123.16 156.29,124.13 154.01,126.4 142.51,126.4 139.16,126.52 136.76,126.61 135.98,126.61 135.05,125.68 135.05,124.16 134.39,123.49 v3(133.88,122.58)
  BOTTOM w0.114: R981.2 172.69,99.35 172.69,101.57 v2(172.21,102.06)
  BOTTOM w0.127: v3(133.88,122.58) 132.38,122.58 130.96,121.16 130.27,121.16 129.77,120.65 129.46,120.65 127.43,118.62 126.93,118.62 v2(126.92,118.6)
AVST_D0: length 76
  ART16 w0.114: v2(165.87,99.98) 165.87,100.13 165.73,100.27 165.73,100.28 165.49,100.52 165.49,101.4 165.38,101.52 165.38,103.02 164.81,103.59 163.82,103.59 161.22,106.2 155.17,106.2 151.28,110.08 151.28,111.35 150.59,112.04 150.59,114.54 149.79,115.34 149.79,116.67 149.22,117.25 145.84,117.25 145.69,117.09 145.69,115.8 145.51,115.61 144.68,115.61 144.5,115.8 144.5,116.03 144.4,116.13 143.98,116.13 143.87,116.01 143.87,115.76 143.75,115.65 143.53,115.65 143.41,115.76 143.41,116.01 143.3,116.13 141.03,116.13 140.92,116.01 140.92,114.53 140.74,114.35 140.58,114.35 140.46,114.46 140.46,115.87 140.28,116.05 140.12,116.05 140.01,115.94 140.01,114.48 139.82,114.3 139.66,114.3 139.55,114.41 139.55,115.96 139.4,116.12 139.14,116.12 139.03,116 139.03,114.3 137.71,112.99 137.15,112.99 136.78,112.62 136.39,112.62 135.92,112.15 135.38,112.15 135.01,112.52 134.44,112.52 134,112.08 133.05,112.08 132.65,111.68 132.38,111.68 131.41,110.71 131.08,110.71 130.66,111.14 130.24,111.14 129.25,112.13 128.42,112.13 126.99,113.56 125.82,113.56 125.58,113.8 125.58,118.81 125.4,118.99 124.85,118.99 124.52,118.66 124.14,118.66 123.9,118.9 123.9,120.23 124.27,120.6 124.5,120.6 125.18,121.28 v2(125.18,121.6)
