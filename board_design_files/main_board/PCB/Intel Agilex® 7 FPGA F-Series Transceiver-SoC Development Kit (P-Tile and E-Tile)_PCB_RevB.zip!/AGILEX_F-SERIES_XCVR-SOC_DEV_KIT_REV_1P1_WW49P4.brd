# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AVST_D1: length 77.2
  ART16 w0.114: v2(125.18,120.6) 124.71,120.13 124.71,119.37 124.88,119.2 125.38,119.2 125.69,119.51 126.21,119.51 126.49,119.22 126.49,114.12 126.7,113.92 127.22,113.92 128.14,112.99 129.37,112.99 130.24,112.13 130.64,112.13 131.15,111.62 131.53,111.62 131.99,112.08 132.33,112.08 132.79,112.53 133.2,112.53 133.72,113.06 134,113.06 134.52,113.58 134.9,113.58 135.36,113.12 135.8,113.12 136.17,113.49 137.52,113.49 138.67,114.64 138.67,116.27 138.97,116.57 144.85,116.57 145.25,116.97 145.25,117.39 145.72,117.86 145.72,118.45 146.11,118.84 146.11,119.14 146.23,119.25 146.8,119.25 146.92,119.14 146.92,117.87 147.03,117.76 147.26,117.76 147.37,117.87 147.37,119.14 147.49,119.25 147.72,119.25 147.83,119.14 147.83,118.56 147.94,118.45 148.17,118.45 148.29,118.56 148.29,119.14 148.4,119.25 148.97,119.25 149.11,119.11 149.11,117.96 150.21,116.86 150.21,115.52 150.62,115.11 151.97,115.11 152.27,114.82 152.27,114.04 152.16,113.93 151.88,113.93 151.76,113.82 151.76,113.59 151.88,113.47 152.16,113.47 152.27,113.36 152.27,113.13 152.16,113.02 151.88,113.02 151.76,112.9 151.76,112.67 151.88,112.56 152.16,112.56 152.27,112.44 152.27,109.75 155.37,106.65 161.35,106.65 164,104.01 165.79,104.01 166.31,103.48 166.31,100.93 166.27,100.89 166.27,99.07 166.52,98.82 166.79,98.82 167.22,98.38 v2(167.47,98.38)
AVST_D2: length 70.4
  ART18 w0.114: v2(166.67,98.38) 166.27,97.98 163.31,97.98 161.09,100.2 160.73,100.2 160.57,100.36 160.57,101.8 160.69,101.92 161.34,101.92 161.47,102.04 161.47,102.26 161.35,102.37 160.69,102.37 160.57,102.49 160.57,102.78 160.69,102.89 161.53,102.89 161.64,103 161.64,103.23 161.53,103.35 160.69,103.35 160.57,103.46 160.57,103.69 160.69,103.8 161.53,103.8 161.64,103.92 161.64,104.15 161.53,104.26 159.72,104.26 159.61,104.37 159.61,104.67 159.71,104.77 160.42,104.77 160.57,104.93 160.57,105.26 160.46,105.37 159.82,105.37 158.26,106.93 153.54,106.93 151.03,109.45 151.03,111.19 150.91,111.3 150.49,111.3 150.17,111.62 150.17,113.37 150.02,113.52 149.79,113.52 149.65,113.38 149.65,112.93 149.55,112.83 148.61,112.83 148.49,112.94 148.49,113.4 148.38,113.51 148.15,113.51 148.03,113.4 148.03,112.32 147.89,112.18 147.71,112.18 147.57,112.32 147.57,112.67 147.42,112.83 146.6,112.83 146.49,112.94 146.49,113.35 146.37,113.46 146.14,113.46 146.03,113.35 146.03,112.3 145.92,112.19 145.62,112.19 145.51,112.29 145.51,112.71 145.4,112.83 144.83,112.83 144.63,113.03 140.51,113.03 139.57,113.97 137.73,113.97 137.55,114.15 137.45,114.15 136.89,114.71 136.28,114.71 135.78,115.21 135.41,115.21 135.19,115.44 135.19,115.55 135.03,115.71 134.25,115.71 133.14,116.81 132.84,116.81 132.44,117.21 131.95,117.21 131.48,117.68 131.12,117.68 130.61,118.19 129.79,118.19 128.93,119.05 128.02,119.05 127.78,119.29 127.78,119.29 127.2,119.86 127.2,119.86 127.1,119.97 127.1,120.24 127.3,120.44 127.3,120.76 127.08,120.99 126.68,120.99 126.3,120.61 125.88,120.61 125.57,120.92 125.57,121.62 v2(126.05,122.1)
AVST_D3: length 70.1
  ART18 w0.114: v2(165.87,100.78) 165.87,101.01 164.98,101.9 164.98,102.6 164.87,102.72 164.32,102.72 164.21,102.83 164.21,103.13 164.32,103.25 165.34,103.25 165.45,103.36 165.45,106.13 164.52,107.06 160.62,107.06 158.93,108.75 154.15,108.75 152.87,110.04 152.87,115.73 152.03,116.57 151.4,116.57 151.29,116.69 151.29,117.31 151.15,117.45 150.94,117.45 150.83,117.33 150.83,116.51 150.71,116.39 150.48,116.39 150.34,116.53 150.34,117.6 150.23,117.72 150,117.72 149.88,117.6 149.88,116.48 149.74,116.34 149.54,116.34 149.43,116.46 149.43,117.6 149.31,117.72 149.08,117.72 148.97,117.6 148.97,116.69 148.85,116.57 136.92,116.57 136.81,116.68 136.31,116.68 136.28,116.71 136.28,116.71 135.78,117.21 135.41,117.21 135.41,117.22 135.35,117.22 134.22,118.35 133.89,118.35 133.53,118.71 132.82,118.71 132.35,119.18 132.34,119.18 132.33,119.18 131.98,119.18 131.48,119.68 131.13,119.68 131.09,119.71 131.08,119.71 130.82,119.97 130.82,121.78 130.12,122.49 129.35,122.49 129.07,122.2 129.07,122 129.42,121.64 129.51,121.64 129.67,121.49 129.67,121.49 129.9,121.26 129.9,120.94 129.45,120.49 129.1,120.49 128.82,120.21 128.49,120.21 128.26,120.44 128.26,120.76 128.36,120.86 128.36,121.34 128.23,121.47 128.23,122.24 127.98,122.49 126.99,122.49 126.05,121.55 v2(126.05,121.1)
AVST_D4: length 69.1
  ART18 w0.114: v2(126.92,121.6) 127.83,121.6 128.17,121.26 128.17,120.94 128.03,120.8 128.03,120.42 128.07,120.38 128.07,120.36 128.72,119.71 129.72,119.71 130.22,119.21 130.58,119.21 131.08,118.71 131.45,118.71 131.95,118.21 131.95,118.21 131.99,118.18 132.35,118.18 132.89,117.64 133.18,117.64 133.81,117 134.59,117 134.61,116.98 134.65,116.98 135.19,116.44 135.41,116.21 135.42,116.21 135.45,116.18 135.79,116.18 135.79,116.18 135.81,116.18 136.28,115.71 138.86,115.71 139.01,115.56 139.01,114.95 139.13,114.83 139.35,114.83 139.47,114.95 139.47,115.56 139.58,115.67 139.81,115.67 139.93,115.56 139.93,114.95 140.04,114.83 140.27,114.83 140.38,114.95 140.38,115.56 140.5,115.67 140.83,115.67 140.94,115.56 140.94,114.1 141.15,113.89 144.07,113.89 144.52,114.35 144.52,114.92 144.64,115.04 145.52,115.04 145.64,114.92 145.64,114.48 145.75,114.36 145.98,114.36 146.1,114.48 146.1,114.92 146.21,115.04 147.67,115.04 147.78,114.92 147.78,114.48 147.9,114.36 148.13,114.36 148.24,114.48 148.24,114.92 148.35,115.04 149.63,115.04 149.74,114.92 149.74,114.48 149.86,114.36 150.09,114.36 150.2,114.48 150.2,114.92 150.31,115.04 151.79,115.04 152.02,114.81 152.02,114.37 151.9,114.25 151.68,114.25 151.57,114.14 151.57,113.91 151.68,113.79 151.9,113.79 152.02,113.68 152.02,113.45 151.9,113.34 151.68,113.34 151.57,113.22 151.57,112.99 151.68,112.88 151.9,112.88 152.02,112.77 152.02,109.68 153.85,107.85 158.62,107.85 160.25,106.22 164.17,106.22 164.61,105.78 164.61,105.49 163.88,104.75 162.72,104.75 162.61,104.64 162.61,104.41 162.72,104.3 163.73,104.3 163.85,104.18 163.85,103.99 163.7,103.84 162.72,103.84 162.61,103.72 162.61,100.52 162.72,100.41 164.84,100.41 165.07,100.63 v2(165.07,100.78)
AVST_D5: length 69.3
  ART18 w0.114: v2(169.07,95.18) 168.9,95.18 168.5,95.58 168.1,95.58 167.89,95.78 167.89,96.2 167.7,96.39 163.58,96.39 161.82,98.14 161.25,98.14 161.13,98.26 161.13,98.86 161.02,98.98 160.79,98.98 160.68,98.86 160.68,98.26 160.56,98.14 158.34,98.14 158.05,98.44 158.05,99.42 157.94,99.53 157.66,99.53 157.54,99.64 157.54,99.87 157.66,99.99 157.94,99.99 158.05,100.1 158.05,100.33 157.94,100.44 157.66,100.44 157.54,100.56 157.54,100.79 157.66,100.9 157.94,100.9 158.05,101.02 158.05,101.24 157.94,101.36 157.66,101.36 157.54,101.47 157.54,101.7 157.66,101.82 157.94,101.82 158.05,101.93 158.05,102.17 158.32,102.44 158.65,102.44 158.76,102.55 158.76,103.32 158.65,103.43 157.66,103.43 157.54,103.55 157.54,103.77 157.66,103.89 158.65,103.89 158.76,104 158.76,104.23 158.65,104.35 157.66,104.35 157.54,104.46 157.54,104.7 157.66,104.82 158.61,104.82 158.72,104.93 158.72,105.16 158.61,105.27 157.66,105.27 157.54,105.39 157.54,105.89 157.34,106.09 153.19,106.09 152.25,107.04 149.4,107.04 149.1,107.34 149.1,110.24 148.74,110.59 145.45,110.59 143.85,112.19 140.05,112.19 139.01,113.23 137.16,113.23 136.68,113.71 136.28,113.71 135.78,114.21 135.41,114.21 134.97,114.66 134.97,114.66 134.95,114.68 134.58,114.68 133.15,116.12 133.11,116.12 133.07,116.15 132.01,116.15 131.48,116.68 131.12,116.68 130.62,117.18 130.25,117.18 129.7,117.74 129.45,117.74 128.74,118.45 127.89,118.45 127.12,119.21 126.67,119.21 126.44,119.45 126.44,120.12 v2(126.92,120.6)
AVST_D6: length 67.7
  ART18 w0.114: v2(169.07,95.98) 169.47,96.38 169.47,97.07 169.31,97.22 169.22,97.22 169.22,97.22 168.92,97.22 168.71,97.43 168.71,97.43 168.69,97.45 168.69,98.61 168.53,98.78 163.24,98.78 161.51,100.51 161.51,101.5 161.82,101.8 162.06,101.8 162.18,101.92 162.18,104.7 162.08,104.79 161.37,104.79 161.24,104.93 161.24,105.14 161.35,105.26 162.94,105.26 163.09,105.41 163.09,105.64 162.94,105.79 159.99,105.79 158.35,107.43 153.67,107.43 151.6,109.5 151.6,111.74 151.48,111.85 150.73,111.85 150.59,111.99 150.59,113.83 150.48,113.94 144.78,113.94 144.31,113.47 140.93,113.47 139.98,114.42 138.05,114.42 137.53,114.94 137.52,114.94 137.5,114.95 137.24,114.95 136.71,115.49 136.24,115.49 135.74,115.99 135.37,115.99 134.57,116.79 133.7,116.79 133.07,117.43 132.83,117.43 132.27,117.99 131.91,117.99 131.87,118.02 131.87,118.02 131.4,118.49 131.06,118.49 131.03,118.52 131.01,118.52 130.53,119 130.16,119 129.67,119.49 127.85,119.49 127.39,119.94 127.39,120.26 127.57,120.44 127.57,120.76 127.12,121.21 126.71,121.21 126.53,121.4 126.53,121.76 126.87,122.1 v2(127.78,122.1)
AVST_D7: length 73.4
  ART16 w0.114: v2(166.67,100.78) 167.1,100.35 167.1,98.98 167.28,98.81 168.5,98.81 168.65,98.96 168.65,101.27 168.17,101.75 168.17,103.43 167.66,103.94 167.63,103.94 167.62,103.93 167.2,103.93 166.87,104.26 166.87,105.44 164.82,107.49 160,107.49 159.8,107.7 155.51,107.7 153.2,110.01 153.2,115.07 150.54,117.73 150.54,120.67 150.04,121.17 145.83,121.17 145.56,120.9 145.56,120.06 145.27,119.77 145.27,119.19 144.88,118.79 144.88,118.21 144.65,117.98 139.27,117.98 137.26,115.98 137.26,115.01 136.82,114.57 136.41,114.57 135.93,115.05 135.31,115.05 134.87,115.49 133.99,115.49 133.17,114.67 132.73,114.67 132.18,114.12 131.94,114.12 131.48,113.67 130.9,113.67 130.35,114.21 130.15,114.21 129.67,114.69 128.7,114.69 128.19,115.2 128.19,120.69 v2(127.78,121.1)
AVST_D8: length 67.5
  ART18 w0.114: v2(167.47,99.18) 167.1,99.54 167.1,100.13 166.85,100.38 166.37,100.38 166.26,100.49 166.26,101.2 165.83,101.63 165.83,101.65 165.4,102.07 165.4,102.62 165.87,103.08 165.87,106.3 164.7,107.48 160.79,107.48 159.1,109.17 154.33,109.17 153.29,110.21 153.29,115.92 151.08,118.13 148.55,118.13 148.44,118.02 148.44,117.11 148.32,116.99 148.08,116.99 147.97,117.11 147.97,117.39 147.85,117.5 147.62,117.5 147.51,117.39 147.51,117.11 147.39,116.99 147.17,116.99 147.05,117.11 147.05,117.39 146.94,117.5 146.71,117.5 146.59,117.39 146.59,117.11 146.48,116.99 145.93,116.99 145.81,117.11 145.81,118.1 145.7,118.21 145.47,118.21 145.36,118.1 145.36,117.11 145.24,116.99 143.48,116.99 143.37,117.11 143.37,117.47 143.25,117.59 143.02,117.59 142.91,117.47 142.91,117.11 142.8,116.99 142.57,116.99 142.45,117.11 142.45,117.47 142.34,117.59 142.11,117.59 141.99,117.47 141.99,117.11 141.88,116.99 141.04,116.99 140.93,117.11 140.93,117.59 140.81,117.7 140.59,117.7 140.47,117.59 140.47,117.11 140.26,116.89 137.2,116.89 136.6,117.49 136.26,117.49 136.22,117.52 136.2,117.52 134.95,118.77 133.86,118.77 133.13,119.49 132.76,119.49 132.27,119.99 131.91,119.99 131.34,120.55 131.34,121.65 131.63,121.94 131.63,122.37 131.18,122.82 129.35,122.82 128.88,122.35 128.88,121.92 129.07,121.73 129.07,121.02 v2(128.65,120.6)
AVST_D9: length 65.2
  ART18 w0.114: v2(166.67,99.18) 166.28,99.57 165.71,99.57 165.45,99.82 165.45,100.96 165.22,101.2 163.13,101.2 163.03,101.31 163.03,101.59 163.12,101.68 163.7,101.68 163.78,101.75 163.78,102.67 163.66,102.78 163.14,102.78 163.03,102.89 163.03,103.12 163.14,103.24 163.71,103.24 164.16,103.68 164.92,103.68 165.03,103.8 165.03,105.95 164.35,106.64 160.44,106.64 158.76,108.33 153.98,108.33 152.45,109.86 152.45,115.14 152.09,115.49 150.27,115.49 150.16,115.61 150.16,115.81 150.04,115.92 149.81,115.92 149.7,115.81 149.7,115.61 149.59,115.49 148.28,115.49 148.17,115.61 148.17,116.04 148.05,116.15 147.82,116.15 147.71,116.04 147.71,115.61 147.59,115.49 146.16,115.49 146.05,115.61 146.05,116.04 145.94,116.15 145.71,116.15 145.59,116.04 145.59,115.61 145.48,115.49 144.68,115.49 144.52,115.65 144.52,116.08 144.45,116.15 144.1,116.15 143.99,116.04 143.99,114.43 143.88,114.31 143.65,114.31 143.53,114.43 143.53,116.04 143.42,116.15 136.94,116.15 136.6,116.49 136.27,116.49 136.26,116.49 136.23,116.49 136.21,116.52 136.2,116.52 135.74,116.99 135.28,116.99 134.15,118.12 133.82,118.12 133.44,118.5 132.76,118.5 132.27,118.99 132.26,118.99 132.25,118.99 131.9,118.99 131.41,119.49 131.04,119.49 130.31,120.21 130.22,120.21 129.99,120.44 129.99,120.76 130.09,120.86 130.09,121.34 129.99,121.44 129.99,121.68 129.58,122.1 v2(129.51,122.1)
AVST_D10: length 70.9
  ART16 w0.114: v2(129.51,121.1) 129.94,120.67 129.94,118.31 129.11,117.48 129.11,115.79 129.35,115.54 129.67,115.54 130.04,115.18 130.54,115.18 131.01,114.71 131.44,114.71 131.98,115.25 132.52,115.25 132.78,115.51 133.57,115.51 134.55,116.49 134.87,116.49 135.23,116.13 135.8,116.13 136.33,115.6 136.72,115.6 136.94,115.82 136.94,116.09 139.58,118.73 139.58,121.03 139.68,121.13 139.95,121.13 140.07,121.02 140.07,119.41 140.18,119.3 144.74,119.3 144.85,119.41 144.85,119.94 145.15,120.23 145.15,121.1 145.63,121.59 150.21,121.59 150.96,120.85 150.96,117.91 152.27,116.6 153.5,116.6 155.25,114.85 156.32,114.85 159.26,111.91 159.26,108.83 160.17,107.91 165.25,107.91 165.59,107.57 166.02,107.57 168.63,104.96 168.63,101.95 169.47,101.11 169.47,99.58 v2(169.07,99.18)
AVST_D11: length 78.5
  ART16 w0.114: v2(125.18,119.6) 125.18,119.91 125.76,120.49 126.21,120.49 126.58,120.12 127.04,120.12 127.33,119.82 127.33,114.82 128.83,113.32 129.87,113.32 130.07,113.12 130.49,113.12 130.98,112.64 131.57,112.64 131.99,113.06 132.17,113.06 132.78,113.67 133.22,113.67 133.67,114.11 134.07,114.11 134.56,114.59 134.89,114.59 135.34,114.13 135.86,114.13 136.28,113.71 136.74,113.71 137.71,114.68 137.71,115.33 138.16,115.79 138.16,116.32 138.71,116.87 139.44,116.87 139.56,116.98 139.56,117.49 139.67,117.6 139.9,117.6 140.01,117.49 140.01,117.11 140.13,116.99 140.36,116.99 140.47,117.11 140.47,117.49 140.59,117.6 140.81,117.6 140.93,117.49 140.93,117.11 141.04,116.99 142.05,116.99 142.16,117.11 142.16,117.45 142.27,117.56 142.5,117.56 142.62,117.45 142.62,117.11 142.73,116.99 142.96,116.99 143.07,117.11 143.07,117.45 143.19,117.56 143.42,117.56 143.53,117.45 143.53,117.11 143.65,116.99 144.67,116.99 144.83,117.15 144.83,117.57 145.3,118.04 145.3,118.62 145.69,119.01 145.69,119.57 145.81,119.68 146.79,119.68 146.91,119.8 146.91,120.66 146.99,120.75 147.27,120.75 147.36,120.66 147.36,119.8 147.48,119.68 148.33,119.68 148.44,119.79 148.44,120.65 148.54,120.75 149.4,120.75 149.53,120.62 149.53,118.13 150.64,117.02 150.64,115.88 150.98,115.54 151.22,115.54 151.57,115.88 151.79,115.88 152.78,114.9 152.78,109.84 155.54,107.07 161.52,107.07 161.97,106.63 165.09,106.63 166.45,105.26 166.45,104.08 166.95,103.58 166.95,101.85 167.89,100.91 167.89,99.56 v2(168.27,99.18)
AVST_D12: length 81.2
  ART16 w0.114: v2(168.27,98.38) 167.88,97.99 165.71,97.99 165.47,98.23 165.47,100.1 165.15,100.42 164.92,100.42 164.71,100.63 164.71,103.01 164.54,103.17 163.65,103.17 161.09,105.73 154.98,105.73 150.87,109.83 150.87,109.9 150.86,109.91 150.86,111.06 150.11,111.81 150.11,114.43 149.35,115.19 148.82,115.19 148.59,115.42 148.59,116.66 148.44,116.81 146.28,116.81 146.12,116.66 146.12,115.71 146.24,115.59 147.97,115.59 148.08,115.48 148.08,113.82 147.98,113.71 147.69,113.71 147.57,113.83 147.57,114.88 147.37,115.09 146.29,115.09 146.18,114.97 146.18,113.6 146.06,113.49 145.84,113.49 145.72,113.6 145.72,114.97 145.61,115.09 144.35,115.09 144.23,114.97 144.23,113.93 144.12,113.82 143.89,113.82 143.77,113.93 143.77,114.97 143.66,115.09 143.42,115.09 143.3,114.97 143.3,113.96 143.19,113.84 139.51,113.84 137.34,111.67 136.44,111.67 135.97,111.2 135.41,111.2 135.03,111.58 134.45,111.58 133.99,111.11 133.18,111.11 132.22,110.15 131.86,110.15 131.36,109.64 130.97,109.64 130.54,109.21 130.54,109.21 130.51,109.18 130.07,109.18 129.77,109.49 129.67,109.49 129.67,109.49 129.31,109.49 128.81,109.99 128.8,109.99 128.79,109.99 128.6,109.99 128.17,110.43 128.17,111.48 127.99,111.66 127.6,111.66 127.13,112.13 126.33,112.13 125.43,113.03 124.97,113.03 124.75,113.25 124.75,118.17 v2(125.18,118.6)
AVST_D13: length 74.2
  ART18 w0.114: v2(169.07,98.38) 169.48,97.97 170.07,97.97 170.28,97.76 170.28,95.87 169.96,95.55 169.72,95.55 169.47,95.3 169.47,95.05 169.19,94.77 168.07,94.77 167.87,94.97 167.87,95.37 167.66,95.58 163.8,95.58 162.45,96.93 158.72,96.93 157.12,98.53 157.12,105.45 156.89,105.68 153.02,105.68 152.19,106.5 148.65,106.5 148.54,106.62 148.54,107.2 148.42,107.31 148.19,107.31 148.08,107.2 148.08,106.62 147.96,106.5 147.74,106.5 147.62,106.62 147.62,107.58 147.51,107.7 147.3,107.7 147.16,107.56 147.16,106.62 147.05,106.5 146.82,106.5 146.71,106.62 146.71,107.53 146.59,107.64 146.39,107.64 146.25,107.5 146.25,106.62 146.14,106.5 145.91,106.5 145.79,106.62 145.79,107.48 145.68,107.59 145.47,107.59 145.34,107.45 145.34,106.62 145.22,106.5 144.97,106.5 144.85,106.62 144.85,110.6 144.3,111.15 143.63,111.15 143.51,111.26 143.51,111.66 143.4,111.77 143.17,111.77 143.06,111.66 143.06,111.26 142.94,111.15 142.71,111.15 142.6,111.26 142.6,111.66 142.49,111.77 142.26,111.77 142.14,111.66 142.14,111.26 142.03,111.15 139.62,111.15 138.23,112.54 138.05,112.54 137.56,113.02 137.07,113.02 136.61,113.48 136.61,113.48 136.6,113.49 136.26,113.49 136.22,113.52 136.2,113.52 135.71,114.01 135.34,114.01 134.87,114.49 134.5,114.49 133.07,115.92 133.03,115.92 132.99,115.96 131.93,115.96 131.63,116.26 131.63,116.26 131.41,116.49 131.04,116.49 130.54,116.99 130.17,116.99 129.67,117.49 129.66,117.49 129.63,117.52 129.36,117.52 128.65,118.24 127.83,118.24 127.08,118.99 126.16,118.99 v2(126.05,119.1)
AVST_D14: length 73.1
  ART18 w0.114: v2(169.87,95.18) 169.87,94.91 169.49,94.53 169.49,94.18 169.31,94 168.09,94 167.87,94.23 167.87,94.54 167.65,94.75 164.19,94.75 164.12,94.82 164.12,94.82 163.43,95.51 163.28,95.51 162.79,95.99 161.12,95.99 160.61,96.49 158.56,96.49 156.7,98.35 156.7,102.39 156.59,102.5 154.65,102.5 154.53,102.62 154.53,102.84 154.65,102.96 156.59,102.96 156.7,103.07 156.7,103.3 156.59,103.42 154.65,103.42 154.53,103.53 154.53,103.76 154.65,103.87 156.59,103.87 156.7,103.99 156.7,104.22 156.59,104.33 154.65,104.33 154.53,104.44 154.53,104.67 154.65,104.79 156.59,104.79 156.7,104.9 156.7,105.14 156.59,105.26 152.85,105.26 152.08,106.02 144.69,106.02 144.43,106.27 144.43,109.75 144.1,110.08 139.9,110.08 137.99,111.99 137.36,111.99 136.75,112.6 136.4,112.6 135.95,113.04 135.59,113.04 135.42,113.21 135.41,113.21 135.04,113.59 134.62,113.59 134.03,114.17 133.65,114.17 133.2,114.63 132.8,114.63 131.92,115.52 131.24,115.52 130.6,116.15 130.22,116.15 129.69,116.69 129.31,116.69 128.88,117.12 128.39,117.12 127.4,118.1 v2(126.05,118.1)
AVST_D15: length 70.8
  ART18 w0.114: v2(169.87,95.98) 169.64,95.98 169.24,95.58 168.93,95.58 168.68,95.83 168.68,96.92 168.45,97.15 163.45,97.15 161.16,99.44 159.26,99.44 159.05,99.24 159.05,98.7 158.93,98.58 158.65,98.58 158.52,98.7 158.52,99.95 158.66,100.09 159.5,100.09 159.61,100.21 159.61,100.44 159.5,100.55 158.61,100.55 158.49,100.66 158.49,100.88 158.63,101.02 160,101.02 160.12,101.14 160.12,101.36 160,101.48 159.29,101.48 159.18,101.59 159.18,103.16 159.29,103.27 159.98,103.27 160.09,103.39 160.09,103.61 159.98,103.73 159.29,103.73 159.18,103.84 159.18,105.33 158,106.51 153.37,106.51 152.19,107.69 152.01,107.69 151.78,107.46 151.62,107.46 151.47,107.61 151.47,107.79 151.69,108.01 151.69,108.18 151.53,108.34 151.37,108.34 150.75,107.72 150.59,107.72 150.44,107.87 150.44,108.06 151.04,108.66 151.04,108.82 150.88,108.98 150.72,108.98 150.04,108.31 149.88,108.31 149.72,108.47 149.72,108.63 150.59,109.51 150.59,110.59 149.43,111.76 144.88,111.76 144.03,112.61 140.27,112.61 139.33,113.55 137.85,113.55 137.46,113.94 137.35,113.94 136.79,114.49 136.24,114.49 135.74,114.99 135.37,114.99 134.87,115.49 134.17,115.49 133.15,116.51 132.75,116.51 132.25,117.01 131.9,117.01 131.89,117.02 131.87,117.02 131.41,117.49 131.04,117.49 130.54,117.99 129.69,117.99 128.84,118.84 127.87,118.84 127.11,119.6 v2(126.92,119.6)
AVST_D16: length 67.3
  ART18 w0.114: v2(170.67,99.18) 170.28,99.57 170.28,100.99 171.23,101.94 171.23,106.64 170.87,107 169.68,107 169.45,107.23 169.45,109.02 167.65,110.82 167.65,114.33 167.04,114.93 160.42,114.93 157.81,117.55 156.21,117.55 155.39,118.36 155.39,123.73 153.72,125.4 145.29,125.4 144.73,124.84 143.15,124.84 143.03,124.73 143.03,124.4 142.92,124.28 142.69,124.28 142.58,124.4 142.58,124.73 142.46,124.84 141.04,124.84 140.66,125.22 140.19,125.22 140.08,125.11 140.08,124.35 139.96,124.23 139.74,124.23 139.62,124.35 139.62,125.11 139.51,125.22 136.14,125.22 135.74,124.82 135.74,123.75 135.35,123.37 135.35,122.2 134.87,121.71 134.5,121.71 133.98,121.18 133.55,121.18 133.15,121.59 132.53,121.59 132.52,121.6 v2(132.11,121.6)
AVST_D17: length 66.2
  ART18 w0.114: v2(132.11,120.6) 133.12,120.6 133.68,120.04 133.98,120.04 134.46,119.56 135.18,119.56 136.25,118.49 136.55,118.49 136.55,118.49 136.6,118.49 137.1,117.99 137.81,117.99 137.94,117.86 139.27,117.86 139.49,118.08 139.49,119.61 139.65,119.76 140.89,119.76 140.99,119.66 140.99,119.4 141.15,119.25 141.93,119.25 142.04,119.37 142.04,119.73 142.16,119.85 142.38,119.85 142.5,119.73 142.5,119.37 142.61,119.25 142.84,119.25 142.96,119.37 142.96,119.73 143.07,119.85 143.3,119.85 143.41,119.73 143.41,119.37 143.53,119.25 144.8,119.25 144.91,119.37 144.91,120.02 145.03,120.13 145.23,120.13 145.37,119.99 145.37,119.37 145.48,119.25 145.71,119.25 145.83,119.37 145.83,119.69 145.94,119.8 146.17,119.8 146.28,119.69 146.28,119.37 146.4,119.25 146.83,119.25 146.96,119.38 146.96,120.86 146.85,120.98 146.38,120.98 146.25,121.11 146.25,121.35 146.36,121.46 151.97,121.46 152.14,121.28 152.14,118.44 155.19,115.39 156.94,115.39 160.37,111.96 160.37,109.08 161.14,108.32 165.07,108.32 165.59,107.8 166.61,107.8 166.72,107.68 166.72,104.04 166.88,103.89 167.61,103.89 167.82,103.68 167.82,102.73 167.68,102.6 167.31,102.6 167.1,102.38 167.1,102.01 167.34,101.77 167.68,101.77 167.82,101.64 167.82,100.62 168.08,100.36 168.5,100.36 168.67,100.19 168.67,99.77 168.86,99.58 169.47,99.58 v2(169.87,99.18)
AVST_D18: length 72.7
  ART16 w0.114: v2(132.98,122.1) 132.62,122.46 132.62,125.89 133.3,126.58 135.36,126.58 135.91,127.13 147.27,127.13 147.83,127.69 150.6,127.69 153.36,124.93 154.08,124.93 155.71,123.3 155.71,120.68 156.28,120.11 156.28,119.63 156.69,119.23 157.33,119.23 161.1,115.45 165.08,115.45 165.69,116.06 167.41,116.06 169.09,114.39 169.09,110.67 169.52,110.24 171.88,110.24 175.46,106.65 175.46,101.14 174.47,100.15 174.47,99.24 174.39,99.16 174.39,99.16 174.01,98.78 172.79,98.78 172.39,98.38 v2(170.67,98.38)
AVST_D19: length 72
  ART16 w0.114: v2(169.87,98.38) 169.87,98.62 170.28,99.04 170.28,100.91 169.51,101.68 169.51,105.45 168.34,106.62 167.76,106.62 166.39,107.98 165.77,107.98 165.42,108.33 160.35,108.33 159.67,109 159.67,112.08 156.5,115.26 155.42,115.26 153.67,117.02 152.44,117.02 151.38,118.08 151.38,121.02 150.32,122.07 145.52,122.07 144.73,121.28 144.73,120.41 144.61,120.29 141.25,120.29 140.15,121.39 140.15,121.96 140.04,122.07 139.27,122.07 139.15,121.96 139.15,118.82 137.01,116.67 136.23,116.67 135.7,117.21 134.81,117.21 133.93,116.33 133.07,116.33 132.41,115.67 130.89,115.67 130.57,115.99 130.43,115.99 129.96,116.46 129.96,117.86 130.19,118.08 130.56,118.08 130.8,118.33 130.8,120.36 131.54,121.1 v2(132.98,121.1)
AVST_D20: length 66.1
  ART18 w0.114: v2(170.67,95.18) 171.07,95.58 171.07,101.07 171.65,101.65 171.65,107.42 168.07,111 168.07,114.5 167.22,115.35 160.61,115.35 157.99,117.98 156.51,117.98 155.83,118.67 155.83,123.93 153.9,125.86 139.52,125.86 139.19,125.53 135.94,125.53 135.46,125.04 135.46,123.93 134.95,123.42 134.95,122.94 133.84,121.83 v2(133.84,121.6)
AVST_D21: length 74.7
  ART16 w0.114: v2(133.84,120.6) 134.3,121.06 134.3,121.89 134.11,122.09 133.59,122.09 132.98,122.7 132.98,125.31 133.2,125.53 134.9,125.53 135.95,126.58 135.96,126.58 136.09,126.71 150.95,126.71 153.85,123.8 154.3,123.8 155.29,122.81 155.29,120.5 155.85,119.95 155.85,118.99 156.64,118.2 157.71,118.2 160.87,115.04 165.26,115.04 165.87,115.65 167.24,115.65 168.67,114.22 168.67,110.45 169.39,109.73 171.59,109.73 174.52,106.79 174.52,101.14 173.51,100.13 173.51,99.79 173.3,99.58 172.86,99.58 172.06,98.78 170.53,98.78 170.25,98.5 170.25,96.4 v2(170.67,95.98)
AVST_D22: length 63.8
  ART18 w0.114: v2(169.87,99.98) 169.47,100.38 169.47,102.08 169.54,102.15 169.54,105.95 168.62,106.88 168.62,108.67 166.47,110.82 165.96,110.82 165.83,110.95 165.83,112.54 165.42,112.95 165.42,113.92 165.25,114.1 160.08,114.1 157.46,116.71 155.86,116.71 154.56,118.02 154.56,122.69 154.44,122.81 149.63,122.81 149.43,123.01 149.43,123.39 148.99,123.82 145.29,123.82 144.9,123.44 144.9,122.81 144.67,122.57 140.53,122.57 140.42,122.69 140.42,123.38 140.3,123.49 140.07,123.49 139.96,123.38 139.96,122.69 139.85,122.57 139.62,122.57 139.5,122.69 139.5,123.38 139.39,123.49 139.16,123.49 139.05,123.38 139.05,122.69 138.93,122.57 138.7,122.57 138.59,122.69 138.59,123.38 138.47,123.49 138.25,123.49 138.13,123.38 138.13,122.69 138.02,122.57 137.79,122.57 137.67,122.69 137.67,123.38 137.56,123.49 137.33,123.49 137.22,123.38 137.22,122.69 137.1,122.57 136.87,122.57 136.76,122.69 136.76,123.38 136.65,123.49 136.42,123.49 136.3,123.38 136.3,122.69 136.01,122.41 136.01,121.49 135.63,121.1 v2(134.71,121.1)
AVST_D23: length 62.5
  ART18 w0.114: v2(135.57,120.6) 136.62,120.6 137.03,120.19 137.49,120.19 137.89,119.79 137.89,119.32 137.78,119.2 137.13,119.2 136.88,118.95 136.88,118.48 137.15,118.21 138.84,118.21 138.99,118.36 138.99,120.88 139.14,121.03 139.41,121.03 139.52,120.92 139.52,120.31 139.63,120.19 139.86,120.19 139.98,120.31 139.98,120.92 140.09,121.03 140.74,121.03 140.87,120.9 140.87,120.42 141.02,120.27 142.06,120.27 142.17,120.38 142.17,120.92 142.28,121.03 142.51,121.03 142.63,120.92 142.63,120.38 142.74,120.27 142.97,120.27 143.08,120.38 143.08,120.92 143.2,121.03 143.43,121.03 143.54,120.92 143.54,120.38 143.66,120.27 144.55,120.27 144.73,120.45 144.73,120.98 144.84,121.09 145.65,121.09 145.77,121.21 145.77,121.8 145.88,121.92 153.02,121.92 153.13,121.8 153.13,118.13 155.39,115.87 157.11,115.87 160.79,112.19 160.79,109.26 161.31,108.74 165.24,108.74 165.76,108.22 167.52,108.22 167.78,107.96 167.78,106.53 168.23,106.07 168.23,101.38 168.65,100.96 168.65,100.66 169.07,100.24 v2(169.07,99.98)
AVST_D24: length 63.5
  ART18 w0.114: v2(169.87,100.78) 169.87,101.21 169.96,101.3 169.96,103.27 170.07,103.38 170.65,103.38 170.76,103.5 170.76,103.73 170.65,103.84 170.07,103.84 169.96,103.95 169.96,106.13 169.03,107.05 169.03,108.85 167.23,110.65 167.23,113.88 167.12,113.99 166.89,113.99 166.77,113.88 166.77,113 166.66,112.89 166.08,112.89 165.84,113.12 165.84,114.4 165.73,114.51 160.25,114.51 157.63,117.13 156.03,117.13 154.98,118.19 154.98,123.03 154.2,123.8 149.65,123.8 149.2,124.26 145.01,124.26 144.55,123.8 136.24,123.8 135.71,123.26 135.71,122.28 134.93,121.5 134.57,121.5 134.56,121.49 134.55,121.49 134.29,121.23 134.29,120.95 134.57,120.67 134.85,120.67 135.92,119.6 v2(137.31,119.6)
AVST_D25: length 60.1
  ART18 w0.114: v2(137.31,118.6) 138.52,118.6 138.63,118.71 138.63,122.02 138.76,122.15 139.02,122.15 139.14,122.03 139.14,121.58 139.25,121.46 139.48,121.46 139.6,121.58 139.6,122.03 139.71,122.15 139.94,122.15 140.05,122.03 140.05,121.58 140.17,121.46 140.4,121.46 140.51,121.58 140.51,122.03 140.62,122.15 140.87,122.15 140.99,122.02 140.99,121.64 141.12,121.51 141.86,121.51 141.97,121.63 141.97,122.03 142.09,122.15 142.31,122.15 142.43,122.03 142.43,121.63 142.54,121.51 142.77,121.51 142.89,121.63 142.89,122.03 143,122.15 143.23,122.15 143.34,122.03 143.34,121.63 143.46,121.51 145.13,121.51 145.32,121.71 145.32,123.23 145.5,123.4 148.82,123.4 149.01,123.22 149.01,122.54 149.16,122.39 153.22,122.39 153.56,122.05 153.56,118.55 153.57,118.55 153.57,118.29 155.56,116.29 157.29,116.29 159.9,113.68 164.86,113.68 164.97,113.56 164.97,112.75 165.33,112.39 165.33,109.24 165.94,108.63 168.06,108.63 168.2,108.5 168.2,106.7 168.96,105.94 168.96,103.17 168.65,102.86 168.65,101.55 169.07,101.13 v2(169.07,100.78)
AVST_D26: length 71.9
  ART16 w0.114: v2(171.47,100.78) 171.47,100.92 170.38,102.01 170.38,102.89 171.58,104.1 171.58,106.45 171.45,106.58 169.56,106.58 168.69,107.45 168.11,107.45 166.74,108.82 166.11,108.82 165.77,109.17 160.83,109.17 160.51,109.49 160.51,112.43 156.84,116.1 155.77,116.1 154.02,117.86 152.8,117.86 152.21,118.45 152.21,121.37 150.96,122.62 150.96,123.05 150.54,123.47 150.54,123.75 150.37,123.92 145.08,123.92 144.71,123.55 144.71,122.69 144.59,122.57 143.9,122.57 143.79,122.69 143.79,122.84 143.78,122.84 143.78,123.38 143.67,123.49 143.14,123.49 143.02,123.61 143.02,124.19 142.91,124.31 142.68,124.31 142.57,124.19 142.57,123.61 142.45,123.49 142.09,123.49 141.93,123.33 141.93,122.69 141.82,122.57 141.07,122.57 140.89,122.75 140.89,123.6 140.64,123.85 140.44,123.85 140.32,123.96 140.32,124.32 140.21,124.43 139.98,124.43 139.86,124.32 139.86,123.96 139.75,123.85 139.52,123.85 139.41,123.96 139.41,124.32 139.29,124.43 139.06,124.43 138.95,124.32 138.95,123.96 138.56,123.57 138.56,119.31 137.47,118.21 137.15,118.21 137.13,118.22 136.86,118.22 136.6,118.49 136.28,118.49 136.02,118.22 135.02,118.22 133.91,117.12 131.99,117.12 131.72,117.39 131.72,117.44 131.72,117.44 131.72,118.3 131.25,118.78 v2(131.25,119.1)
AVST_D27: length 72.3
  ART16 w0.114: v2(131.25,118.1) 131.25,117.86 130.73,117.35 130.73,116.89 131,116.62 131.38,116.62 131.9,116.1 132.41,116.1 132.94,116.63 133.8,116.63 134.74,117.58 134.87,117.58 135.28,117.99 136.01,117.99 136.28,117.71 136.6,117.71 136.88,117.99 137.72,117.99 138.86,119.13 138.86,123.04 138.98,123.15 139.18,123.15 139.29,123.04 139.29,122.54 139.41,122.43 139.6,122.43 139.71,122.54 139.71,123.28 139.82,123.39 140.42,123.39 140.54,123.28 140.54,121.76 140.71,121.58 142.09,121.58 142.21,121.7 142.21,122.29 142.35,122.43 142.55,122.43 142.66,122.31 142.66,121.7 142.78,121.58 143.01,121.58 143.12,121.7 143.12,122.29 143.26,122.43 143.45,122.43 143.58,122.3 143.58,121.7 143.69,121.58 144.44,121.58 145.13,122.27 145.13,123.37 145.25,123.5 149.32,123.5 149.43,123.39 149.43,122.9 149.54,122.78 150.2,122.78 151.79,121.19 151.79,118.26 152.61,117.44 153.84,117.44 155.6,115.68 156.67,115.68 160.09,112.26 160.09,109.31 160.66,108.75 165.59,108.75 165.94,108.4 166.56,108.4 167.93,107.03 168.51,107.03 169.38,106.16 171,106.16 171.14,106.02 171.14,104.29 170.79,103.94 170.1,103.94 169.93,103.76 169.93,101.87 170.44,101.35 170.45,101.35 170.67,101.13 v2(170.67,100.78)
AVST_D28: length 67.7
  ART16 w0.114: v2(172.27,99.98) 172.92,100.63 172.92,106.98 171.18,108.71 168.63,108.71 167.74,109.6 167.74,113.92 166.85,114.81 166.22,114.81 165.61,114.2 160.53,114.2 157.36,117.36 156.29,117.36 155.01,118.64 155.01,119.6 154.05,120.57 153.83,120.57 153.56,120.84 153.56,122.41 153.06,122.9 152.46,122.9 152.21,123.15 152.21,123.57 151.79,123.99 151.79,124.58 150.51,125.87 139.05,125.87 138.53,125.35 135.99,125.35 135.84,125.2 135.84,124.8 135.81,124.77 135.81,124.41 135.83,124.38 135.83,121.89 136.02,121.71 136.02,120.38 135.52,119.88 135.33,119.88 134.09,118.64 132.73,118.64 132.11,119.26 v2(132.11,119.6)
AVST_D29: length 69.2
  ART16 w0.114: v2(171.47,99.98) 171.88,100.39 171.88,101.11 171.25,101.74 171.25,103.13 172,103.88 172,106.63 171.63,107 169.73,107 169.46,107.27 169.46,107.73 169.31,107.87 168.28,107.87 166.9,109.25 166.9,110.53 166.79,110.64 165.66,110.64 165.42,110.88 165.42,113.11 165.19,113.34 160.2,113.34 157.02,116.52 155.94,116.52 154.19,118.28 153.52,118.28 153.14,118.66 153.14,120.07 152.72,120.49 152.72,121.87 152.53,122.07 152.11,122.07 151.38,122.8 151.38,123.22 150.96,123.64 150.96,124.23 150.16,125.03 148.5,125.03 148.39,124.92 148.39,124.57 148.2,124.38 145.71,124.38 145.6,124.49 145.6,124.65 145.48,124.77 144.91,124.77 144.71,124.56 144.71,124.14 144.44,123.87 144.05,123.87 143.78,124.14 143.78,124.56 143.58,124.77 142.15,124.77 142.03,124.65 142.03,124.03 141.88,123.87 141.23,123.87 140.99,124.11 140.99,124.56 140.79,124.75 138.76,124.75 138.65,124.64 138.65,124.37 137.76,123.48 137.76,119.44 137.45,119.14 136.98,119.14 136.63,119.49 136.28,119.49 135.91,119.11 135.47,119.11 134.42,118.06 133.67,118.06 133.3,117.69 132.58,117.69 132.11,118.16 v2(132.11,118.6)
AVST_D30: length 69.7
  ART16 w0.114: v2(173.07,99.98) 173.08,99.99 173.08,100.26 174.05,101.23 174.05,106.44 171.27,109.22 169.14,109.22 168.25,110.11 168.25,114.05 167.07,115.23 166.04,115.23 165.43,114.62 160.7,114.62 157.54,117.78 156.47,117.78 155.43,118.81 155.43,119.77 154.87,120.33 154.87,122.31 154.33,122.85 153.75,122.85 152.68,123.92 152.46,123.92 152.21,124.16 152.21,124.85 150.77,126.29 139.01,126.29 138.38,125.65 135.81,125.65 134.85,124.69 134.07,124.69 133.88,124.5 133.88,123.82 133.75,123.7 133.42,123.7 133.32,123.6 133.32,123.37 133.45,123.24 134.27,123.24 135.15,122.35 135.15,120.79 134.92,120.56 134.62,120.56 134.32,120.26 134.32,119.53 133.76,118.97 133.1,118.97 v2(132.98,119.1)
AVST_D31: length 68.3
  ART16 w0.114: v2(172.27,100.78) 172.27,101.36 171.67,101.96 171.67,102.94 172.42,103.69 172.42,106.88 171.01,108.29 168.45,108.29 167.32,109.43 167.32,111.06 167.21,111.18 166.89,111.18 166.77,111.29 166.77,111.52 166.89,111.64 167.21,111.64 167.32,111.75 167.32,111.98 167.21,112.09 166.89,112.09 166.77,112.21 166.77,112.44 166.89,112.55 167.21,112.55 167.32,112.66 167.32,113.74 167.17,113.9 166.93,113.9 166.77,113.73 166.77,113 166.65,112.89 166.03,112.89 165.84,113.07 165.84,113.63 165.71,113.76 160.37,113.76 157.19,116.94 156.12,116.94 154.59,118.46 154.59,119.14 154.48,119.25 153.72,119.25 153.56,119.41 153.56,120.25 153.14,120.66 153.14,122.05 152.7,122.48 152.28,122.48 151.79,122.97 151.79,123.39 151.38,123.81 151.38,124.41 150.33,125.45 145,125.45 144.44,124.88 144.05,124.88 143.61,125.32 142.08,125.32 141.64,124.88 141.26,124.88 140.69,125.45 139.14,125.45 138.76,125.07 137.57,125.07 136.88,124.38 136.88,119.99 136.6,119.71 136.01,119.71 135.73,119.44 135.3,119.44 134.19,118.33 133.2,118.33 v2(132.98,118.1)
AVST_DATA_VALID: length 70
  ART18 w0.114: v2(128.65,121.6) 128.65,122.39 128.88,122.63 128.88,122.85 129.25,123.22 131.27,123.22 131.82,122.66 131.82,121.86 131.61,121.65 131.61,120.55 131.98,120.18 132.35,120.18 132.37,120.15 132.82,119.71 133.18,119.71 133.79,119.1 135.1,119.1 136.05,118.15 136.05,117.94 136.28,117.71 136.65,117.71 137.18,117.18 137.66,117.18 137.92,117.45 139.47,117.45 140.03,118.01 144.45,118.01 145.23,118.79 147.19,118.79 147.44,119.05 147.44,120.86 147.56,120.98 148.58,120.98 148.69,120.86 148.69,118.91 148.81,118.79 149.04,118.79 149.15,118.91 149.15,120.86 149.27,120.98 150.55,120.98 150.66,120.86 150.66,118.91 150.78,118.79 151.01,118.79 151.12,118.91 151.12,120.86 151.23,120.98 151.57,120.98 151.69,120.86 151.69,118.29 155.01,114.96 156.66,114.96 159.87,111.76 159.87,109 160.97,107.9 164.87,107.9 166.3,106.46 166.3,103.86 166.68,103.49 166.68,101.84 167.11,101.41 167.11,100.58 167.47,100.22 v2(167.47,99.98)
AVST_READY: length 78.5
  ART16 w0.114: v2(133.84,119.6) 133.4,120.04 133.4,121.34 133.17,121.56 132.94,121.56 131.43,123.07 131.43,126.28 131.67,126.52 132.18,126.52 133.21,127.55 146.93,127.55 147.5,128.12 150.77,128.12 153.39,125.5 154.1,125.5 156.13,123.47 156.13,120.85 156.66,120.32 156.91,120.32 157.28,119.95 157.28,119.86 161.27,115.87 164.91,115.87 165.52,116.48 167.59,116.48 169.12,114.95 171.76,113.75 172.68,112.84 173.58,109.13 175.88,106.83 175.88,101.13 174.77,100.02 174.77,99.11 174.7,99.03 174.7,99.03 174.27,98.6 174.27,98.15 174.07,97.94 173.72,97.94 173.72,97.94 173.66,97.94 173.43,97.71 173.43,97.43 173.17,97.17 172.9,97.17 172.68,96.95 172.68,96.58 172.45,96.35 171.84,96.35 v2(171.47,95.98)
BLASTER_DISN: length 84
  TOP w0.109: U23.U18 v2(45.13,179.92)
  ART18 w0.114: J19.2 5.33,147.88 5.33,160.21 11.43,166.31 11.43,168.92 13.9,171.38 13.9,177.81 13.48,178.22 13.48,182.7 15.62,184.83 26.99,184.83 29.75,187.59 30.21,187.59 30.99,188.37 40.59,188.37 44.58,184.37 44.72,184.37 44.96,184.13 44.96,183.99 45.57,183.39 45.57,180.35 v2(45.13,179.92)
  BOTTOM w0.127: v2(45.13,179.92) 45.75,180.53 R341.1
CLEANER_GPIO0: length 56.1
  TOP w0.109: R453.1 185.76,50.36 U38.45 ; U79.C4 168.39,45.71 v2(168.63,45.95)
  ART03 w0.114: v2(186.28,49.81) 185.88,50.22 184.33,50.22 183.92,49.81 174.73,49.81 173.23,48.31 171.48,48.31 169.11,45.95 v2(168.63,45.95) 167.49,44.81 167.49,42.55 167.06,42.11 157.51,42.11 155.19,44.42 140.97,44.42 v2(139.78,43.23)
CLEANER_GPIO1: length 55
  TOP w0.109: U38.24 178.22,56.38 v2(177.2,57.4) ; U40.C1 168.36,49.41 v2(168.63,49.15)
  ART03 w0.114: v2(168.63,49.15) 168.17,49.6 168.17,52.23 169.48,53.54 177.34,53.54 178.76,54.96 178.76,56.08 178.28,56.56 178.04,56.56 v2(177.2,57.4)
  ART07 w0.114: v2(143.36,44.96) 149.28,44.96 151,43.23 163.32,43.23 165.56,45.47 165.56,47.04 165.91,47.4 167.51,47.4 168.63,48.51 v2(168.63,49.15)
  BOTTOM w0.109: v2(143.36,44.96) 142.21,46.1 J26.9
CLEANER_GPIO2: length 49.7
  TOP w0.109: v2(168.63,49.92) U40.C2 ; v2(189.48,57.76) 189.33,57.76 189.2,57.88 U38.60
  ART03 w0.114: v2(168.63,49.92) 171.53,49.92 173.69,52.07 187.66,52.07 187.96,52.37 187.96,55.82 189.48,57.35 v2(189.48,57.76)
  ART07 w0.114: v2(168.63,49.92) 168.02,49.31 168.02,49 167.41,48.39 165.89,48.39 165.1,47.6 165.1,46.66 163.89,45.45 161.73,45.45 160.17,43.89 v2(152.4,43.89)
  BOTTOM w0.109: R873.1 190.42,58.04 190.14,57.76 v2(189.48,57.76)
CLEANER_GPIO3: length 59.5
  TOP w0.109: U40.C3 168.37,50.41 v2(168.63,50.67) ; v2(181.46,47.31) 182.09,47.94 182.09,48.58 R470.2 182.06,49.82 182.43,49.82 183.27,50.65 U38.40
  ART07 w0.114: v2(134.59,43.38) 137.34,43.38 139.52,45.57 161.07,45.57 162.04,46.54 164.22,46.54 164.59,46.91 164.59,48.18 165.84,49.43 167.38,49.43 v2(168.63,50.67)
  ART16 w0.114: v2(168.63,50.67) 171.52,47.78 175.21,47.78 175.62,48.18 180.67,48.18 181.46,47.4 v2(181.46,47.31)
CLEANER_GPIO4: length 57.2
  TOP w0.109: v2(168.63,51.43) 168.11,50.92 U40.C4 ; v2(182.98,47.31) 183.61,47.94 183.61,48.58 R471.2 183.76,50 U38.41
  ART07 w0.114: v2(137.11,43.92) 139.32,46.13 160.55,46.13 162.26,47.83 163.55,47.83 166.85,51.13 168.32,51.13 v2(168.63,51.43)
  ART16 w0.114: v2(182.98,47.31) 181.49,48.79 171.27,48.79 v2(168.63,51.43)
CLEANER_GPIO5: length 85.9
  TOP w0.109: U38.12 181.74,60.63 181.74,61.69 v2(181.2,62.23) ; U41.C1 182,68.62 v2(181.96,68.58)
  ART03 w0.114: v2(181.2,62.23) 183.31,62.23 183.51,62.43 183.51,62.8 183.4,62.91 182.18,62.91 182.06,63.03 182.06,63.26 182.18,63.37 183.63,63.37 183.74,63.49 183.74,63.73 183.63,63.84 182.23,63.84 182.12,63.96 182.12,64.18 182.23,64.3 183.7,64.3 184,64.59 184,66.29 183.88,66.41 182.23,66.41 182.12,66.52 182.12,66.75 182.23,66.86 184.19,66.86 184.3,66.98 184.3,67.22 184.19,67.33 182.53,67.33 182.42,67.45 182.42,68.12 v2(181.96,68.58)
  ART16 w0.114: v2(134.7,47.22) 137.57,47.22 138.23,46.56 143.69,46.56 145.11,45.14 154.69,45.14 156.85,42.98 164.1,42.98 164.74,43.62 164.74,48.18 166.17,49.61 166.17,50.65 166.45,50.93 167.03,50.93 167.51,51.41 167.51,51.99 169.98,54.46 169.98,55.42 171.27,56.72 177.19,56.72 177.93,57.45 178.51,57.45 179.07,58.01 179.07,61.29 180.01,62.23 v2(181.2,62.23)
  BOTTOM w0.109: R874.1 181.76,62.79 v2(181.2,62.23)
CLEANER_GPIO6: length 83
  TOP w0.109: U41.C2 182.5,68.38 v2(181.94,67.82) ; U38.13 181.27,61.4 v2(181.2,61.47)
  ART03 w0.114: v2(181.2,61.47) 181.2,60.57 181.09,60.45 180.87,60.45 180.69,60.63 180.69,62.65 180.58,62.76 179.47,62.76 179.36,62.88 179.36,63.11 179.47,63.22 181.46,63.22 181.66,63.43 181.66,64.52 181.91,64.76 182.88,64.76 183,64.88 183,65.11 182.88,65.22 181.73,65.22 181.62,65.34 181.62,65.9 181.51,66.01 180.25,66.01 180.11,66.15 180.11,66.36 180.22,66.47 181.51,66.47 181.62,66.59 181.62,66.81 181.51,66.93 180.45,66.93 180.34,67.04 180.34,67.27 180.45,67.39 181.51,67.39 v2(181.94,67.82)
  ART16 w0.114: v2(137.19,46.69) 137.85,46.02 143.46,46.02 144.89,44.6 154.46,44.6 156.62,42.44 164.32,42.44 165.28,43.4 165.28,45.22 168.12,48.06 168.12,51.89 170.46,54.23 170.46,55.14 171.5,56.18 177.39,56.18 177.67,56.46 178.44,56.46 178.7,56.73 178.7,56.93 179.53,57.76 179.53,60.48 180.52,61.47 v2(181.2,61.47)
  BOTTOM w0.109: v2(181.2,61.47) 180.24,62.43 180.24,62.79 R875.1
CLEANER_HW_CTRL: length 71.9
  TOP w0.109: v2(189.28,61.47) 189.59,61.16 R910.1 R455.1 190.31,59.88 U38.64
  ART16 w0.114: v2(144.68,43) 147.37,40.31 185.42,40.31 186.74,41.63 186.74,46.05 185.9,46.89 185.9,48.01 186.25,48.35 187.52,48.35 190.2,51.03 190.2,57.68 189.28,58.6 v2(189.28,61.47)
CLEANER_IN0_N: length 3.6
  TOP w0.089: C860.2 186.67,63.29 186.67,62.79 R457.1 186.63,62.22 186.63,61.88 186.89,61.62 186.89,61.18 186.77,61.06 186.77,60.65 186.76,60.65 U38.2
CLEANER_IN0_P: length 3.6
  TOP w0.089: U38.1 187.27,60.99 187.17,61.09 187.17,61.74 186.92,62 186.92,62.14 R457.2 186.96,62.79 186.96,63.29 C859.2
CLEANER_IN1_N: length 3.7
  TOP w0.089: U38.15 180.27,61.04 180.36,61.14 180.36,61.39 179.9,61.86 179.9,62.22 R456.1 179.94,62.79 179.94,63.29 C863.2
CLEANER_IN1_P: length 3.7
  TOP w0.089: C862.2 180.23,63.29 180.23,62.79 R456.2 180.19,62.14 180.19,61.98 180.65,61.51 180.65,61.13 180.76,61.01 U38.14
CLEANER_IN2_N: length 3.5
  TOP w0.089: U38.11 182.27,60.98 182.42,61.14 182.42,62.24 R460.1 182.48,62.79 182.48,63.29 C868.2
CLEANER_IN2_P: length 3.5
  TOP w0.089: C865.2 182.77,63.29 182.77,62.79 R460.2 182.71,62.12 182.71,60.66 U38.10
CLEANER_IN3: length 5
  TOP w0.109: v2(185.75,62.13) 185.2,61.58 185.2,61.15 185.27,61.09 U38.5
  BOTTOM w0.109: v2(185.75,62.13) 187.41,62.13 R464.1 R468.2
CLEANER_INSEL00: length 57
  TOP w0.109: U42.C1 168.36,53.99 v2(168.63,53.72) ; v2(177.2,58.93) 177.74,58.38 U38.20
  ART03 w0.114: v2(177.2,58.93) 177.2,59.47 177.06,59.61 175.23,59.61 175.11,59.5 175.11,58.76 175,58.65 174.77,58.65 174.66,58.76 174.66,59.6 174.54,59.71 174.31,59.71 174.2,59.6 174.2,58.76 174.09,58.65 173.86,58.65 173.74,58.76 173.74,59.6 173.63,59.71 169.01,59.71 167.61,58.32 167.61,54.74 v2(168.63,53.72)
  ART16 w0.114: v2(168.63,53.72) 167.77,52.86 165.99,52.86 165.35,52.22 165.35,49.76 163.45,47.85 160.86,47.85 159.08,46.08 147.19,46.08 145.62,47.65 v2(139.62,47.65)
CLEANER_INSEL01: length 67.2
  TOP w0.109: U38.17 178.21,59.88 v2(178.03,60.07) R888.1 ; U42.C2 v2(168.63,54.49)
  ART03 w0.114: v2(178.03,60.07) 177.65,59.69 177.65,58.55 177.26,58.17 175.87,58.17 175.75,58.05 175.75,57.28 175.64,57.16 175.18,57.16 175.07,57.28 175.07,58.03 174.95,58.14 174.72,58.14 174.61,58.03 174.61,57.28 174.5,57.16 174.27,57.16 174.15,57.28 174.15,58.03 174.04,58.14 173.81,58.14 173.7,58.03 173.7,57.28 173.58,57.16 173.34,57.16 173.21,57.29 173.21,59.07 173,59.28 169.24,59.28 168.09,58.14 168.09,55.02 v2(168.63,54.49)
  ART16 w0.114: v2(132.05,48.18) 132.46,48.59 145.49,48.59 147.24,46.84 158.91,46.84 161.21,49.15 163.68,49.15 164.87,50.34 164.87,53.19 165.66,53.98 168.12,53.98 v2(168.63,54.49)
CLEANER_INSEL10: length 49.4
  TOP w0.109: U38.28 178.44,54.38 v2(177.2,55.63) ; U42.C3 168.37,54.99 v2(168.63,55.24)
  ART03 w0.114: v2(177.2,55.63) 177.2,55.89 176.78,56.31 172.72,56.31 172.6,56.2 172.6,54.6 172.49,54.48 172.26,54.48 172.14,54.6 172.14,56.2 172.03,56.31 171.8,56.31 171.69,56.2 171.69,54.6 171.57,54.48 171.34,54.48 171.23,54.6 171.23,56.2 171.11,56.31 170.89,56.31 170.77,56.2 170.77,54.6 170.66,54.48 170.43,54.48 170.31,54.6 170.31,55.92 170.15,56.08 169.16,56.08 168.63,55.55 v2(168.63,55.24)
  ART16 w0.114: v2(147.35,48.03) 147.85,47.52 158.56,47.52 161.17,50.14 163.55,50.14 164.39,50.98 164.39,53.36 166.57,55.54 168.34,55.54 v2(168.63,55.24)
CLEANER_INSEL11: length 48.3
  TOP w0.109: U42.C4 167.8,55.49 168.5,56.18 v2(168.63,56.18) ; U38.29 177.99,53.88 v2(177.26,54.61)
  ART03 w0.114: v2(168.63,56.18) 168.63,57.99 168.83,58.19 169.85,58.19 170.03,58.01 170.03,56.86 170.14,56.74 170.39,56.74 170.5,56.86 170.5,58 170.62,58.11 170.85,58.11 170.96,58 170.96,56.86 171.08,56.74 171.3,56.74 171.42,56.86 171.42,58 171.53,58.11 171.76,58.11 171.88,58 171.88,56.86 171.99,56.74 172.22,56.74 172.33,56.86 172.33,58 172.45,58.11 172.68,58.11 172.79,58 172.79,56.86 172.9,56.74 177.04,56.74 177.65,56.13 177.65,54.99 v2(177.26,54.61)
  ART16 w0.114: v2(149.86,48.11) 157.81,48.11 162.2,52.5 163.32,52.5 163.88,53.06 163.88,54.18 166.45,56.74 168.07,56.74 v2(168.63,56.18)
CLEANER_OSC_EN: length 4.3
  TOP w0.508: U39.1 182.37,42.92 181.56,42.11 181.48,42.11 181.22,41.85 R476.2 179.74,41.78 R920.1
CLEANER_SCL: length 75.5
  TOP w0.109: v2(180.57,50.27) 180.82,50.27 181.27,50.71 U38.36 ; v2(182.96,68.58) 183,68.62 U41.C3
  ART03 w0.114: v2(152.45,48.59) 158.39,42.65 164.19,42.65 166.47,44.93 166.47,45.57 166.62,45.72 167.54,45.72 168.22,46.41 168.91,46.41 171.32,48.82 173.13,48.82 175.41,51.1 179.73,51.1 v2(180.57,50.27)
  ART20 w0.114: v2(180.57,50.27) 180.77,50.27 181.69,49.35 182.83,49.35 186.16,46.02 187.17,46.02 187.96,46.81 187.96,48.23 189.64,49.91 189.64,54.13 190.86,55.35 190.86,61.52 189.46,62.92 189.46,65.15 187.93,66.67 185.65,66.67 183.74,68.58 v2(182.96,68.58)
  BOTTOM w0.109: R883.1 179.89,50.27 v2(180.57,50.27)
CLEANER_SDA: length 71.7
  TOP w0.109: v2(180.79,50.95) 180.76,50.97 U38.35 ; v2(182.94,67.82) 183.5,68.38 U41.C4
  ART03 w0.114: v2(180.79,50.95) 180.1,51.64 175.29,51.64 172.91,49.26 171.08,49.26 168.68,46.86 166.85,46.86 165.96,45.97 165.96,45.16 164.11,43.31 160.15,43.31 v2(154.86,48.59)
  ART20 w0.114: v2(182.94,67.82) 183.74,67.82 185.39,66.17 187.85,66.17 189.04,64.98 189.04,62.63 190.42,61.24 190.42,55.55 189.2,54.33 189.2,50.11 187.45,48.36 187.45,46.96 186.94,46.46 186.33,46.46 183.01,49.78 181.94,49.78 180.79,50.93 v2(180.79,50.95)
  BOTTOM w0.109: v2(180.79,50.95) 180.79,50.95 180.54,50.95 179.93,51.56 R884.1
CLEANER_STATUS0: length 53.1
  TOP w0.109: U79.C1 168.36,44.21 v2(168.65,43.92) ; U38.55 188.66,55.38 188.9,55.14 v2(188.9,55.03)
  ART03 w0.114: v2(188.9,55.03) 189.9,54.03 189.9,50.13 188.29,48.51 176.4,48.51 175.21,47.32 172.06,47.32 v2(168.65,43.92) 168.65,42.42 167.44,41.2 156.51,41.2 154.89,42.82 v2(149.78,42.82)
  BOTTOM w0.109: R885.2 188.88,55.02 v2(188.9,55.03)
CLEANER_STATUS1: length 55.4
  TOP w0.109: U79.C2 v2(168.62,44.71) ; U38.56 188.64,55.88 v2(188.88,56.13)
  ART03 w0.114: v2(147.19,43.23) 147.61,43.23 147.78,43.41 155.12,43.41 156.9,41.63 167.21,41.63 167.92,42.34 167.92,44 v2(168.62,44.71) 171.72,47.8 173.51,47.8 174.52,48.82 175.82,48.82 176.17,49.17 184.38,49.17 184.86,49.66 185.47,49.66 185.75,49.38 186.94,49.38 189.38,51.82 189.38,53.9 188.47,54.81 188.47,55.72 v2(188.88,56.13)
CLEANER_VDDAPLL1: length 7.1
  TOP w0.279: v2(181.71,50.8) 181.76,50.85 U38.37
  BOTTOM w0.381: v2(181.71,50.8) C914.2
  BOTTOM w0.508: v2(181.71,50.8) 181.53,50.62 181.53,50.06 180.49,49.02 L29.2 178.65,49.02 178.39,48.77 C910.1
CLEANER_VDDAPLL2: length 10.3
  TOP w0.279: v2(188.63,52.07) 188.32,52.38 U38.49
  BOTTOM w0.508: L32.2 197.3,50.61 C922.1 192.69,50.61 191.23,52.07 v2(188.63,52.07)
CLEANER_VDDDIG: length 13.4
  TOP w0.279: U38.8 v2(183.76,61.59)
  ART03 w0.508: v2(183.76,61.59) 183.87,61.59 185.27,62.99 186.92,62.99 188.86,64.93 v3(188.86,67.92)
  BOTTOM w0.381: C917.2 183.87,61.49 v2(183.76,61.59)
  BOTTOM w0.508: L30.2 188.86,69.76 v3(188.86,67.92)
CLEANER_VDDIN0: length 15.7
  TOP w0.279: v2(186.41,61.37) 186.27,61.22 U38.3
  BOTTOM w0.381: v2(186.41,61.37) 186.92,60.86 C888.2
  BOTTOM w0.508: C888.2 189.62,60.77 192.5,63.65 192.5,65.28 193.96,66.74 C887.1 197.3,66.74 L21.2
CLEANER_VDDIN1: length 11.2
  TOP w0.279: U38.16 v2(179.76,61.34)
  BOTTOM w0.508: v2(179.76,61.34) 179.76,61.76 179.42,62.1 179.42,63.63 178.92,64.13 178.92,65.53 178.41,66.04 177.77,66.04 176.97,66.84 C893.1 176.97,68.36 176.25,69.09 L23.2
CLEANER_VDDIN2: length 12.1
  TOP w0.279: v2(183.1,61.35) 183.27,61.18 U38.9
  BOTTOM w0.381: v2(183.1,61.35) 183.11,61.34 183.11,61.15 C902.2
  BOTTOM w0.508: C902.2 182.47,61.02 182.47,64.48 180.88,66.08 C901.1 180.88,67.76 179.42,69.21 L25.2
CLEANER_VDDIN3: length 14.8
  TOP w0.279: U38.4 185.76,61.22 v2(185.65,61.34)
  ART03 w0.508: v2(185.65,61.34) 185.65,61.14 186.15,60.63 186.92,60.63 187.53,61.24 187.53,62.43 188.06,62.97 189.05,62.97 190.04,63.96 190.04,66.94 v3(191.02,67.92)
  BOTTOM w0.381: C908.2 185.76,60.78 185.76,61.22 v2(185.65,61.34)
  BOTTOM w0.508: v3(191.02,67.92) 191.21,68.11 L27.2
CLEANER_VDDO0: length 7.5
  TOP w0.279: U38.21 v2(178.31,57.88)
  BOTTOM w0.508: C889.2 178.09,58.17 174.98,58.17 174.66,58.49 C890.1 173.01,58.49 L22.2
CLEANER_VDDO1: length 6.2
  TOP w0.279: U38.25 v2(178.29,55.88)
  BOTTOM w0.508: L24.2 172.5,56.45 C898.1 177.71,56.45
CLEANER_VDDO6: length 11.8
  TOP w0.279: U38.59 v2(188.8,57.38)
  ART05 w0.508: v2(193.84,58.74) 192.38,60.2 190.85,60.2 188.8,58.15 v2(188.8,57.38)
  BOTTOM w0.508: v2(193.84,58.74) C920.1 197.3,58.74 L31.2
CLEANER_VDDO7: length 11.8
  TOP w0.279: U38.63 v2(188.67,59.38)
  BOTTOM w0.508: C927.2 189.32,59.87 189.79,59.87 193.77,63.85 193.77,63.98 194.5,64.7 C928.1 197.3,64.7 L33.2
CLEANER_VDDO23: length 6.7
  TOP w0.279: U38.30 v2(178.32,53.38)
  BOTTOM w0.508: v2(178.32,53.38) 177.27,53.38 C904.1 176.11,53.31 173.91,53.31 173.35,52.76 L26.2
CLEANER_VDDO45: length 10.6
  TOP w0.279: v2(188.69,52.96) 188.62,52.88 U38.50
  BOTTOM w0.381: C911.2 188.63,53.02 v2(188.69,52.96)
  BOTTOM w0.508: L28.2 197.3,54.68 C912.1 193.59,54.68 192.12,53.21 C911.2
CLEANER_VDDTCXO: length 33.6
  TOP w0.279: U38.19 v2(178.32,58.88)
  TOP w0.508: L40.1 178.79,73.21 v2(178.34,72.77)
  ART18 w0.508: v2(178.32,58.88) 178.69,59.25 178.69,60.5 178.1,61.09 178.1,64.34 180.62,66.85 183.06,66.85 184.76,68.55 184.76,70.76 184.25,71.27 179.84,71.27 v2(178.34,72.77)
  BOTTOM w0.508: v2(178.32,58.88) 178.66,59.22 178.66,61.66 C925.1 176.69,62.48 L34.2
CLEANER_VDDXO: length 28.9
  TOP w0.279: U38.42 v2(184.27,50.82)
  TOP w0.508: v2(172.21,44.66) 173.56,44.66 L20.1
  ART03 w0.508: v2(172.21,44.66) 173.29,45.74 178.86,45.74 178.97,45.85 186.54,45.85 v2(187.42,44.96)
  BOTTOM w0.508: C932.2 184.25,50.83 v2(184.27,50.82) 184.27,47.99 186.28,45.97 187.36,45.97 187.87,45.47 C931.1 187.87,43.12 L35.2
CLEANER_XO_N: length 1.6
  TOP w0.109: v2(185.27,50.8) U38.44
  BOTTOM w0.109: C1331.1 185.39,50.93 v2(185.27,50.8)
CLEARNER_0_1HZ: length 138.3
  TOP w0.109: v2(178.28,57.02) 178.64,57.38 U38.22
  ART18 w0.114: v2(178.28,57.02) 179.35,58.09 179.35,60.68 178.77,61.26 178.77,64.16 180.7,66.09 183.54,66.09 185.37,67.92 185.37,73.02 184.53,73.86 183.16,73.86 179.58,77.44 171.56,77.44 170.81,78.19 164.27,78.19 161.64,75.56 146.53,75.56 145.57,76.53 145.57,95.81 143.51,97.87 141.5,97.87 138.71,100.66 138.71,105.32 138.4,105.64 138.03,105.64 137.53,106.14 137.14,106.14 136.67,106.6 136.41,106.6 136.3,106.71 136.28,106.71 135.81,107.19 135.3,107.19 134.97,107.52 134.49,107.52 134.29,107.72 134.29,107.76 133.83,108.21 133.41,108.21 133.13,108.5 132.76,108.5 132.22,109.04 131.89,109.04 131.53,109.4 131.53,109.8 131.64,109.91 131.64,110.34 131.37,110.62 131.13,110.62 130.55,111.19 130.18,111.19 129.31,112.06 128.56,112.06 128.11,112.52 127.56,112.52 127.23,112.19 124.86,112.19 124.53,112.52 124.08,112.52 123.61,112.99 123.61,112.99 123.53,113.07 123.38,113.07 122.86,113.59 122.45,113.59 122.02,114.02 121.56,114.02 120.95,114.63 120.62,114.63 120.22,115.04 119.81,115.04 119.43,114.65 118.82,114.65 118.47,115.01 118.05,115.01 117.44,115.62 117.09,115.62 116.66,116.05 116.25,116.05 115.69,116.61 115.36,116.61 114.93,117.04 114.58,117.04 114.07,117.55 113.89,117.55 113.43,118.01 113.43,121.72 v3(112.22,122.94)
  BOTTOM w0.109: R947.1 112.76,122.39 v3(112.22,122.94)
