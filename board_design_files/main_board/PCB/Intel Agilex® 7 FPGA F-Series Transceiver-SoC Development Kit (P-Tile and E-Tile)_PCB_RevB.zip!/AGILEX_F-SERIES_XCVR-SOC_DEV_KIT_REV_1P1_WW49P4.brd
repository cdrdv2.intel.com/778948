# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
FBGA96
  round 0.406 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
FDMC8878_VER2
  rect 0.406x0.914 smd: 1(-0.975,-1.643) 2(-0.325,-1.643) 3(0.325,-1.643) 4(0.975,-1.643)
  custom 0.589x0.589 smd: 5(0,0.85)
HC_BGA144C127P12X12_1600X1600X626
  round 0.61 smd: A1(-6.985,6.985) A2(-5.715,6.985) A3(-4.445,6.985) A4(-3.175,6.985) A5(-1.905,6.985) A6(-0.635,6.985) A7(0.635,6.985) A8(1.905,6.985) A9(3.175,6.985) A10(4.445,6.985) A11(5.715,6.985) A12(6.985,6.985) B1(-6.985,5.715) B2(-5.715,5.715) B3(-4.445,5.715) B4(-3.175,5.715) B5(-1.905,5.715) B6(-0.635,5.715) B7(0.635,5.715) B8(1.905,5.715) B9(3.175,5.715) B10(4.445,5.715) B11(5.715,5.715) B12(6.985,5.715) C1(-6.985,4.445) C2(-5.715,4.445) C3(-4.445,4.445) C4(-3.175,4.445) C5(-1.905,4.445) C6(-0.635,4.445) C7(0.635,4.445) C8(1.905,4.445) C9(3.175,4.445) C10(4.445,4.445) C11(5.715,4.445) C12(6.985,4.445) D1(-6.985,3.175) D2(-5.715,3.175) D3(-4.445,3.175) D4(-3.175,3.175) D5(-1.905,3.175) D6(-0.635,3.175) D7(0.635,3.175) D8(1.905,3.175) D9(3.175,3.175) D10(4.445,3.175) D11(5.715,3.175) D12(6.985,3.175) E1(-6.985,1.905) E2(-5.715,1.905) E3(-4.445,1.905) E4(-3.175,1.905) E5(-1.905,1.905) E6(-0.635,1.905) E7(0.635,1.905) E8(1.905,1.905) E9(3.175,1.905) E10(4.445,1.905) E11(5.715,1.905) E12(6.985,1.905) F1(-6.985,0.635) F2(-5.715,0.635) F3(-4.445,0.635) F4(-3.175,0.635) F5(-1.905,0.635) F6(-0.635,0.635) F7(0.635,0.635) F8(1.905,0.635) F9(3.175,0.635) F10(4.445,0.635) F11(5.715,0.635) F12(6.985,0.635) G1(-6.985,-0.635) G2(-5.715,-0.635) G3(-4.445,-0.635) G4(-3.175,-0.635) G5(-1.905,-0.635) G6(-0.635,-0.635) G7(0.635,-0.635) G8(1.905,-0.635) G9(3.175,-0.635) G10(4.445,-0.635) G11(5.715,-0.635) G12(6.985,-0.635) H1(-6.985,-1.905) H2(-5.715,-1.905) H3(-4.445,-1.905) H4(-3.175,-1.905) H5(-1.905,-1.905) H6(-0.635,-1.905) H7(0.635,-1.905) H8(1.905,-1.905) H9(3.175,-1.905) H10(4.445,-1.905) H11(5.715,-1.905) H12(6.985,-1.905) J1(-6.985,-3.175) J2(-5.715,-3.175) J3(-4.445,-3.175) J4(-3.175,-3.175) J5(-1.905,-3.175) J6(-0.635,-3.175) J7(0.635,-3.175) J8(1.905,-3.175) J9(3.175,-3.175) J10(4.445,-3.175) J11(5.715,-3.175) J12(6.985,-3.175) K1(-6.985,-4.445) K2(-5.715,-4.445) K3(-4.445,-4.445) K4(-3.175,-4.445) K5(-1.905,-4.445) K6(-0.635,-4.445) K7(0.635,-4.445) K8(1.905,-4.445) K9(3.175,-4.445) K10(4.445,-4.445) K11(5.715,-4.445) K12(6.985,-4.445) L1(-6.985,-5.715) L2(-5.715,-5.715) L3(-4.445,-5.715) L4(-3.175,-5.715) L5(-1.905,-5.715) L6(-0.635,-5.715) L7(0.635,-5.715) L8(1.905,-5.715) L9(3.175,-5.715) L10(4.445,-5.715) L11(5.715,-5.715) L12(6.985,-5.715) M1(-6.985,-6.985) M2(-5.715,-6.985) M3(-4.445,-6.985) M4(-3.175,-6.985) M5(-1.905,-6.985) M6(-0.635,-6.985) M7(0.635,-6.985) M8(1.905,-6.985) M9(3.175,-6.985) M10(4.445,-6.985) M11(5.715,-6.985) M12(6.985,-6.985)
HC_TK0_BGA25_S6325_1_1270_MA
  round 0.6 smd: A1(-2.54,2.54) A2(-1.27,2.54) A3(0,2.54) A4(1.27,2.54) A5(2.54,2.54) B1(-2.54,1.27) B2(-1.27,1.27) B3(0,1.27) B4(1.27,1.27) B5(2.54,1.27) C1(-2.54,0) C2(-1.27,0) C3(0,0) C4(1.27,0) C5(2.54,0) D1(-2.54,-1.27) D2(-1.27,-1.27) D3(0,-1.27) D4(1.27,-1.27) D5(2.54,-1.27) E1(-2.54,-2.54) E2(-1.27,-2.54) E3(0,-2.54) E4(1.27,-2.54) E5(2.54,-2.54)
HC_TK0_BGA144_S16075_1_1270_MA
  round 0.6 smd: A1(-6.985,6.985) A2(-5.715,6.985) A3(-4.445,6.985) A4(-3.175,6.985) A5(-1.905,6.985) A6(-0.635,6.985) A7(0.635,6.985) A8(1.905,6.985) A9(3.175,6.985) A10(4.445,6.985) A11(5.715,6.985) A12(6.985,6.985) B1(-6.985,5.715) B2(-5.715,5.715) B3(-4.445,5.715) B4(-3.175,5.715) B5(-1.905,5.715) B6(-0.635,5.715) B7(0.635,5.715) B8(1.905,5.715) B9(3.175,5.715) B10(4.445,5.715) B11(5.715,5.715) B12(6.985,5.715) C1(-6.985,4.445) C2(-5.715,4.445) C3(-4.445,4.445) C4(-3.175,4.445) C5(-1.905,4.445) C6(-0.635,4.445) C7(0.635,4.445) C8(1.905,4.445) C9(3.175,4.445) C10(4.445,4.445) C11(5.715,4.445) C12(6.985,4.445) D1(-6.985,3.175) D2(-5.715,3.175) D3(-4.445,3.175) D4(-3.175,3.175) D5(-1.905,3.175) D6(-0.635,3.175) D7(0.635,3.175) D8(1.905,3.175) D9(3.175,3.175) D10(4.445,3.175) D11(5.715,3.175) D12(6.985,3.175) E1(-6.985,1.905) E2(-5.715,1.905) E3(-4.445,1.905) E4(-3.175,1.905) E5(-1.905,1.905) E6(-0.635,1.905) E7(0.635,1.905) E8(1.905,1.905) E9(3.175,1.905) E10(4.445,1.905) E11(5.715,1.905) E12(6.985,1.905) F1(-6.985,0.635) F2(-5.715,0.635) F3(-4.445,0.635) F4(-3.175,0.635) F5(-1.905,0.635) F6(-0.635,0.635) F7(0.635,0.635) F8(1.905,0.635) F9(3.175,0.635) F10(4.445,0.635) F11(5.715,0.635) F12(6.985,0.635) G1(-6.985,-0.635) G2(-5.715,-0.635) G3(-4.445,-0.635) G4(-3.175,-0.635) G5(-1.905,-0.635) G6(-0.635,-0.635) G7(0.635,-0.635) G8(1.905,-0.635) G9(3.175,-0.635) G10(4.445,-0.635) G11(5.715,-0.635) G12(6.985,-0.635) H1(-6.985,-1.905) H2(-5.715,-1.905) H3(-4.445,-1.905) H4(-3.175,-1.905) H5(-1.905,-1.905) H6(-0.635,-1.905) H7(0.635,-1.905) H8(1.905,-1.905) H9(3.175,-1.905) H10(4.445,-1.905) H11(5.715,-1.905) H12(6.985,-1.905) J1(-6.985,-3.175) J2(-5.715,-3.175) J3(-4.445,-3.175) J4(-3.175,-3.175) J5(-1.905,-3.175) J6(-0.635,-3.175) J7(0.635,-3.175) J8(1.905,-3.175) J9(3.175,-3.175) J10(4.445,-3.175) J11(5.715,-3.175) J12(6.985,-3.175) K1(-6.985,-4.445) K2(-5.715,-4.445) K3(-4.445,-4.445) K4(-3.175,-4.445) K5(-1.905,-4.445) K6(-0.635,-4.445) K7(0.635,-4.445) K8(1.905,-4.445) K9(3.175,-4.445) K10(4.445,-4.445) K11(5.715,-4.445) K12(6.985,-4.445) L1(-6.985,-5.715) L2(-5.715,-5.715) L3(-4.445,-5.715) L4(-3.175,-5.715) L5(-1.905,-5.715) L6(-0.635,-5.715) L7(0.635,-5.715) L8(1.905,-5.715) L9(3.175,-5.715) L10(4.445,-5.715) L11(5.715,-5.715) L12(6.985,-5.715) M1(-6.985,-6.985) M2(-5.715,-6.985) M3(-4.445,-6.985) M4(-3.175,-6.985) M5(-1.905,-6.985) M6(-0.635,-6.985) M7(0.635,-6.985) M8(1.905,-6.985) M9(3.175,-6.985) M10(4.445,-6.985) M11(5.715,-6.985) M12(6.985,-6.985)
HC_TK0_SM_10800X8000_MA
  rrect 3.35x2.65 smd: 1(-4.225,0) 2(4.225,0)
HC_TK0_SOT143_4_1400X2885_1920_MA
  rrect 1.05x0.99 smd: 1(-1.015,0.75)
  rrect 1.05x0.57 smd: 2(-1.015,-0.96) 3(1.015,-0.96) 4(1.015,0.96)
HC_TK1_LCC52_5100X8100_DF3650X6650_MA_MFG
  rrect 0.675x0.2 smd: 1(-2.362,3.2) 2(-2.362,2.8) 3(-2.362,2.4) 4(-2.362,2) 5(-2.362,1.6) 6(-2.362,1.2) 7(-2.362,0.8) 8(-2.362,0.4) 9(-2.362,0) 10(-2.362,-0.4) 11(-2.362,-0.8) 12(-2.362,-1.2) 13(-2.362,-1.6) 14(-2.362,-2) 15(-2.362,-2.4) 16(-2.362,-2.8) 17(-2.362,-3.2) 27(2.362,-3.2) 28(2.362,-2.8) 29(2.362,-2.4) 30(2.362,-2) 31(2.362,-1.6) 32(2.362,-1.2) 33(2.362,-0.8) 34(2.362,-0.4) 35(2.362,0) 36(2.362,0.4) 37(2.362,0.8) 38(2.362,1.2) 39(2.362,1.6) 40(2.362,2) 41(2.362,2.4) 42(2.362,2.8) 43(2.362,3.2)
  rrect 0.2x0.675 smd: 18(-1.6,-3.863) 19(-1.2,-3.863) 20(-0.8,-3.863) 21(-0.4,-3.863) 22(0,-3.863) 23(0.4,-3.863) 24(0.8,-3.863) 25(1.2,-3.863) 26(1.6,-3.863) 44(1.6,3.863) 45(1.2,3.863) 46(0.8,3.863) 47(0.4,3.863) 48(0,3.863) 49(-0.4,3.863) 50(-0.8,3.863) 51(-1.2,3.863) 52(-1.6,3.863)
  rrect 3.65x6.65 smd: 53(0,0)
HDR2X5_100MIL_SMT
  rect 3.175x1.27 smd: 1(-2.731,7.62) 2(2.731,7.62) 3(-2.731,5.08) 4(2.731,5.08) 5(-2.731,2.54) 6(2.731,2.54) 7(-2.731,0) 8(2.731,0) 9(-2.731,-2.54) 10(2.731,-2.54)
HDR2X10_100MIL
  rect 3.175x1.27 smd: 1(-2.731,11.43) 2(2.731,11.43) 3(-2.731,8.89) 4(2.731,8.89) 5(-2.731,6.35) 6(2.731,6.35) 7(-2.731,3.81) 8(2.731,3.81) 9(-2.731,1.27) 10(2.731,1.27) 11(-2.731,-1.27) 12(2.731,-1.27) 13(-2.731,-3.81) 14(2.731,-3.81) 15(-2.731,-6.35) 16(2.731,-6.35) 17(-2.731,-8.89) 18(2.731,-8.89) 19(-2.731,-11.43) 20(2.731,-11.43)
IND_0603
  rect 1.016x1.016 smd: 1(-0.762,0) 2(0.762,0)
IND_WURTH_74479276210
  rect 0.8x1.8 smd: 1(-0.8,0) 2(0.8,0)
LQFN42_5X8X0P95_ADI
  rect 0.406x0.254 smd: 1(-2.553,3.503) 15(-2.553,-3.503)
  rect 0.711x0.254 smd: 2(-2.4,3.002) 3(-2.4,2.502) 4(-2.4,2.002) 5(-2.4,1.501) 6(-2.4,1.001) 7(-2.4,0.5) 8(-2.4,0) 9(-2.4,-0.5) 10(-2.4,-1.001) 11(-2.4,-1.501) 12(-2.4,-2.002) 13(-2.4,-2.502) 14(-2.4,-3.002) 22(2.4,-3.503) 23(2.4,-3.002) 24(2.4,-2.502) 25(2.4,-2.002) 26(2.4,-1.501) 27(2.4,-1.001) 28(2.4,-0.5) 29(2.4,0) 30(2.4,0.5) 31(2.4,1.001) 32(2.4,1.501) 33(2.4,2.002) 34(2.4,2.502) 35(2.4,3.002) 36(2.4,3.503)
  rect 0.254x0.406 smd: 16(-2.002,-4.053) 42(-2.002,4.053)
  rect 0.254x0.711 smd: 17(-1.001,-3.9) 18(-0.5,-3.9) 19(0,-3.9) 20(1.001,-3.9) 21(1.501,-3.9) 37(1.501,3.9) 38(1.001,3.9) 39(0,3.9) 40(-0.5,3.9) 41(-1.001,3.9)
  rect 0.711x1.499 smd: 43(0.851,0)
LTQFN38
  rect 0.711x0.279 smd: 1(-2.406,2.75) 2(-2.406,2.25) 3(-2.406,1.75) 4(-2.406,1.25) 5(-2.406,0.75) 6(-2.406,0.25) 7(-2.406,-0.25) 8(-2.406,-0.75) 9(-2.406,-1.25) 10(-2.406,-1.75) 11(-2.406,-2.25) 12(-2.406,-2.75) 20(2.406,-2.75) 21(2.406,-2.25) 22(2.406,-1.75) 23(2.406,-1.25) 24(2.406,-0.75) 25(2.406,-0.25) 26(2.406,0.25) 27(2.406,0.75) 28(2.406,1.25) 29(2.406,1.75) 30(2.406,2.25) 31(2.406,2.75)
  rect 0.279x0.711 smd: 13(-1.5,-3.406) 14(-1,-3.406) 15(-0.5,-3.406) 16(0,-3.406) 17(0.5,-3.406) 18(1,-3.406) 19(1.5,-3.406) 32(1.5,3.406) 33(1,3.406) 34(0.5,3.406) 35(0,3.406) 36(-0.5,3.406) 37(-1,3.406) 38(-1.5,3.406)
  rect 3.15x5.15 smd: 39(0,0)
MOLEX_0470533000_TXSI
  round 1.245 hole 1.245 unplated: (-5.08,-2.16)
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0)
MOLEX_ZQSFP_CAGE
  rect 2.007x2.007 hole 1.05: 1(0,0) 3(0,9) 4(0,18) 5(0,27) 6(-19,22.5) 7(-19,13.5) 8(-19,4.5) 9(-19,-4.5)
  round 1.549 hole 1.05: 2(0,-10.7) 10(-19,-15.2) 11(-16.88,-20.39)
MTH250R150
  round 6.35 hole 3.81: 1(0,0)
OSC2520
  rect 1.143x1.041 smd: 1(-0.971,-0.771) 2(0.971,-0.771) 3(0.971,0.771) 4(-0.971,0.771)
OSC_4PIN_SMD_5X7
  rect 1.8x2 smd: 1(-2.54,-2.1) 2(2.54,-2.1) 3(2.54,2.1) 4(-2.54,2.1)
OSC_SMD_8PIN_3_2X5
  rect 0.74x1.6 smd: 1(-1.27,-1.35) 2(0,-1.35) 3(1.27,-1.35) 4(1.27,1.35) 5(0,1.35) 6(-1.27,1.35)
  rect 0.9x0.7 smd: 7(-2.15,0) 8(2.15,0)
PCIE_2X3_ATX
  round 3.81 hole 2.997: (-4.2,0) (4.2,0)
  rect 2.54x2.54 hole 1.803: 1(4.2,7.3)
  round 2.54 hole 1.803: 2(0,7.3) 3(-4.2,7.3) 4(4.2,12.8) 5(0,12.8) 6(-4.2,12.8)
POWER33
  rect 0.7x0.42 smd: 1(-1.4,0.975) 2(-1.4,0.325) 3(-1.4,-0.325) 4(-1.4,-0.975) 5(1.4,-0.975) 6(1.4,-0.325) 7(1.4,0.325) 8(1.4,0.975)
PW
  rect 0.356x1.524 smd: 1(-1.95,-2.95) 2(-1.3,-2.95) 3(-0.65,-2.95) 4(0,-2.95) 5(0.65,-2.95) 6(1.3,-2.95) 7(1.95,-2.95) 8(1.95,2.95) 9(1.3,2.95) 10(0.65,2.95) 11(0,2.95) 12(-0.65,2.95) 13(-1.3,2.95) 14(-1.95,2.95)
QFN24
  oval 0.813x0.279 smd: 1(-1.95,1.25) 2(-1.95,0.75) 3(-1.95,0.25) 4(-1.95,-0.25) 5(-1.95,-0.75) 6(-1.95,-1.25) 13(1.95,-1.25) 14(1.95,-0.75) 15(1.95,-0.25) 16(1.95,0.25) 17(1.95,0.75) 18(1.95,1.25)
  oval 0.279x0.813 smd: 7(-1.25,-1.95) 8(-0.75,-1.95) 9(-0.25,-1.95) 10(0.25,-1.95) 11(0.75,-1.95) 12(1.25,-1.95) 19(1.25,1.95) 20(0.75,1.95) 21(0.25,1.95) 22(-0.25,1.95) 23(-0.75,1.95) 24(-1.25,1.95)
  rect 2.591x2.591 smd: 25(0,0)
QFN32L
  oval 0.864x0.279 smd: 1(-2.42,1.75) 2(-2.42,1.25) 3(-2.42,0.75) 4(-2.42,0.25) 5(-2.42,-0.25) 6(-2.42,-0.75) 7(-2.42,-1.25) 8(-2.42,-1.75) 17(2.42,-1.75) 18(2.42,-1.25) 19(2.42,-0.75) 20(2.42,-0.25) 21(2.42,0.25) 22(2.42,0.75) 23(2.42,1.25) 24(2.42,1.75)
  oval 0.279x0.864 smd: 9(-1.75,-2.42) 10(-1.25,-2.42) 11(-0.75,-2.42) 12(-0.25,-2.42) 13(0.25,-2.42) 14(0.75,-2.42) 15(1.25,-2.42) 16(1.75,-2.42) 25(1.75,2.42) 26(1.25,2.42) 27(0.75,2.42) 28(0.25,2.42) 29(-0.25,2.42) 30(-0.75,2.42) 31(-1.25,2.42) 32(-1.75,2.42)
  custom 0.875x0.875 smd: 33(0,0)
QFN56
  oval 0.813x0.279 smd: 1(-3.9,3.25) 2(-3.9,2.75) 3(-3.9,2.25) 4(-3.9,1.75) 5(-3.9,1.25) 6(-3.9,0.75) 7(-3.9,0.25) 8(-3.9,-0.25) 9(-3.9,-0.75) 10(-3.9,-1.25) 11(-3.9,-1.75) 12(-3.9,-2.25) 13(-3.9,-2.75) 14(-3.9,-3.25) 29(3.9,-3.25) 30(3.9,-2.75) 31(3.9,-2.25) 32(3.9,-1.75) 33(3.9,-1.25) 34(3.9,-0.75) 35(3.9,-0.25) 36(3.9,0.25) 37(3.9,0.75) 38(3.9,1.25) 39(3.9,1.75) 40(3.9,2.25) 41(3.9,2.75) 42(3.9,3.25)
  oval 0.279x0.813 smd: 15(-3.25,-3.9) 16(-2.75,-3.9) 17(-2.25,-3.9) 18(-1.75,-3.9) 19(-1.25,-3.9) 20(-0.75,-3.9) 21(-0.25,-3.9) 22(0.25,-3.9) 23(0.75,-3.9) 24(1.25,-3.9) 25(1.75,-3.9) 26(2.25,-3.9) 27(2.75,-3.9) 28(3.25,-3.9) 43(3.25,3.9) 44(2.75,3.9) 45(2.25,3.9) 46(1.75,3.9) 47(1.25,3.9) 48(0.75,3.9) 49(0.25,3.9) 50(-0.25,3.9) 51(-0.75,3.9) 52(-1.25,3.9) 53(-1.75,3.9) 54(-2.25,3.9) 55(-2.75,3.9) 56(-3.25,3.9)
  rect 5.842x5.842 smd: 57(0,0)
QFN64_TI
  round 1.016 smd: (-5.5,-5.5) (5.5,5.5)
  oval 0.838x0.279 smd: 1(-4.469,3.75) 2(-4.469,3.25) 3(-4.469,2.75) 4(-4.469,2.25) 5(-4.469,1.75) 6(-4.469,1.25) 7(-4.469,0.75) 8(-4.469,0.25) 9(-4.469,-0.25) 10(-4.469,-0.75) 11(-4.469,-1.25) 12(-4.469,-1.75) 13(-4.469,-2.25) 14(-4.469,-2.75) 15(-4.469,-3.25) 16(-4.469,-3.75) 33(4.469,-3.75) 34(4.469,-3.25) 35(4.469,-2.75) 36(4.469,-2.25) 37(4.469,-1.75) 38(4.469,-1.25) 39(4.469,-0.75) 40(4.469,-0.25) 41(4.469,0.25) 42(4.469,0.75) 43(4.469,1.25) 44(4.469,1.75) 45(4.469,2.25) 46(4.469,2.75) 47(4.469,3.25) 48(4.469,3.75)
  oval 0.279x0.838 smd: 17(-3.75,-4.469) 18(-3.25,-4.469) 19(-2.75,-4.469) 20(-2.25,-4.469) 21(-1.75,-4.469) 22(-1.25,-4.469) 23(-0.75,-4.469) 24(-0.25,-4.469) 25(0.25,-4.469) 26(0.75,-4.469) 27(1.25,-4.469) 28(1.75,-4.469) 29(2.25,-4.469) 30(2.75,-4.469) 31(3.25,-4.469) 32(3.75,-4.469) 49(3.75,4.469) 50(3.25,4.469) 51(2.75,4.469) 52(2.25,4.469) 53(1.75,4.469) 54(1.25,4.469) 55(0.75,4.469) 56(0.25,4.469) 57(-0.25,4.469) 58(-0.75,4.469) 59(-1.25,4.469) 60(-1.75,4.469) 61(-2.25,4.469) 62(-2.75,4.469) 63(-3.25,4.469) 64(-3.75,4.469)
  rect 7.696x7.696 smd: 65(0,0)
QFN_32
  oval 0.686x0.254 smd: 1(-2.31,1.75) 2(-2.31,1.25) 3(-2.31,0.75) 4(-2.31,0.25) 5(-2.31,-0.25) 6(-2.31,-0.75) 7(-2.31,-1.25) 8(-2.31,-1.75) 17(2.31,-1.75) 18(2.31,-1.25) 19(2.31,-0.75) 20(2.31,-0.25) 21(2.31,0.25) 22(2.31,0.75) 23(2.31,1.25) 24(2.31,1.75)
  oval 0.254x0.686 smd: 9(-1.75,-2.31) 10(-1.25,-2.31) 11(-0.75,-2.31) 12(-0.25,-2.31) 13(0.25,-2.31) 14(0.75,-2.31) 15(1.25,-2.31) 16(1.75,-2.31) 25(1.75,2.31) 26(1.25,2.31) 27(0.75,2.31) 28(0.25,2.31) 29(-0.25,2.31) 30(-0.75,2.31) 31(-1.25,2.31) 32(-1.75,2.31)
  rect 2.286x2.286 smd: 33(0,0)
QSH-030-01-C-D-A
  round 1.016 hole 1.016 unplated: (-10.065,2.67) (10.065,2.67)
  rect 0.279x2.286 smd: 1(-7.25,-2.865) 2(-7.25,2.865) 3(-6.75,-2.865) 4(-6.75,2.865) 5(-6.25,-2.865) 6(-6.25,2.865) 7(-5.75,-2.865) 8(-5.75,2.865) 9(-5.25,-2.865) 10(-5.25,2.865) 11(-4.75,-2.865) 12(-4.75,2.865) 13(-4.25,-2.865) 14(-4.25,2.865) 15(-3.75,-2.865) 16(-3.75,2.865) 17(-3.25,-2.865) 18(-3.25,2.865) 19(-2.75,-2.865) 20(-2.75,2.865) 21(-2.25,-2.865) 22(-2.25,2.865) 23(-1.75,-2.865) 24(-1.75,2.865) 25(-1.25,-2.865) 26(-1.25,2.865) 27(-0.75,-2.865) 28(-0.75,2.865) 29(-0.25,-2.865) 30(-0.25,2.865) 31(0.25,-2.865) 32(0.25,2.865) 33(0.75,-2.865) 34(0.75,2.865) 35(1.25,-2.865) 36(1.25,2.865) 37(1.75,-2.865) 38(1.75,2.865) 39(2.25,-2.865) 40(2.25,2.865) 41(2.75,-2.865) 42(2.75,2.865) 43(3.25,-2.865) 44(3.25,2.865) 45(3.75,-2.865) 46(3.75,2.865) 47(4.25,-2.865) 48(4.25,2.865) 49(4.75,-2.865) 50(4.75,2.865) 51(5.25,-2.865) 52(5.25,2.865) 53(5.75,-2.865) 54(5.75,2.865) 55(6.25,-2.865) 56(6.25,2.865) 57(6.75,-2.865) 58(6.75,2.865) 59(7.25,-2.865) 60(7.25,2.865)
  rect 2.54x0.432 smd: 61(-8.065,0) 64(8.065,0)
  rect 4.699x0.432 smd: 62(-3.175,0) 63(3.175,0)
QSOP24P
  oval 0.381x1.676 smd: 1(-3.493,-2.743) 2(-2.857,-2.743) 3(-2.223,-2.743) 4(-1.587,-2.743) 5(-0.953,-2.743) 6(-0.318,-2.743) 7(0.318,-2.743) 8(0.953,-2.743) 9(1.587,-2.743) 10(2.223,-2.743) 11(2.857,-2.743) 12(3.493,-2.743) 13(3.493,2.743) 14(2.857,2.743) 15(2.223,2.743) 16(1.587,2.743) 17(0.953,2.743) 18(0.318,2.743) 19(-0.318,2.743) 20(-0.953,2.743) 21(-1.587,2.743) 22(-2.223,2.743) 23(-2.857,2.743) 24(-3.493,2.743)
QTH-030
  round 1.016 hole 1.016 unplated: (-9.246,2.032) (9.246,2.032)
  round 6.35 hole 3.175: (0,31.75)
  rect 0.305x1.448 smd: 1(-7.256,3.099) 2(-7.256,-3.099) 3(-6.755,3.099) 4(-6.755,-3.099) 5(-6.255,3.099) 6(-6.255,-3.099) 7(-5.754,3.099) 8(-5.754,-3.099) 9(-5.254,3.099) 10(-5.254,-3.099) 11(-4.754,3.099) 12(-4.754,-3.099) 13(-4.253,3.099) 14(-4.253,-3.099) 15(-3.753,3.099) 16(-3.753,-3.099) 17(-3.252,3.099) 18(-3.252,-3.099) 19(-2.752,3.099) 20(-2.752,-3.099) 21(-2.252,3.099) 22(-2.252,-3.099) 23(-1.751,3.099) 24(-1.751,-3.099) 25(-1.251,3.099) 26(-1.251,-3.099) 27(-0.751,3.099) 28(-0.751,-3.099) 29(-0.25,3.099) 30(-0.25,-3.099) 31(0.25,3.099) 32(0.25,-3.099) 33(0.751,3.099) 34(0.751,-3.099) 35(1.251,3.099) 36(1.251,-3.099) 37(1.751,3.099) 38(1.751,-3.099) 39(2.252,3.099) 40(2.252,-3.099) 41(2.752,3.099) 42(2.752,-3.099) 43(3.252,3.099) 44(3.252,-3.099) 45(3.753,3.099) 46(3.753,-3.099) 47(4.253,3.099) 48(4.253,-3.099) 49(4.754,3.099) 50(4.754,-3.099) 51(5.254,3.099) 52(5.254,-3.099) 53(5.754,3.099) 54(5.754,-3.099) 55(6.255,3.099) 56(6.255,-3.099) 57(6.755,3.099) 58(6.755,-3.099) 59(7.256,3.099) 60(7.256,-3.099)
  rect 2.54x0.635 smd: 61(-8.445,0) 64(8.445,0)
  rect 4.699x0.635 smd: 62(-3.175,0) 63(3.175,0)
RJ45
  round 4.064 hole 3.251: (0,-8.89) (11.43,-8.89)
  rect 1.397x1.397 hole 0.889: 1(0,0)
  round 1.397 hole 0.889: 2(1.27,-2.54) 3(2.54,0) 4(3.81,-2.54) 5(5.08,0) 6(6.35,-2.54) 7(7.62,0) 8(8.89,-2.54) 9(10.16,0) 10(11.43,-2.54)
  round 2.083 hole 1.575: 11(-2.03,-5.84) 12(13.46,-5.84)
SENSE
  rect 0.305x0.406 smd: 1(0,0.254) 2(0,-0.254)
SHORT
  rect 0.305x0.406 smd: 1(0,0.254) 2(0,-0.254)
SL1616A
  rect 1.702x1.905 smd: 1(-1.3,0) 2(1.3,0)
SMA_LTI-SASF546-P26-X1
  round 0.81 smd: 1(0,0)
  round 2.03 hole 1.52: 2(-2.54,2.54) 3(2.54,2.54) 4(2.54,-2.54) 5(-2.54,-2.54)
SMD7X5
  rect 1.499x1.295 smd: 1(-2.75,-2.15) 2(2.75,-2.15) 3(2.75,2.15) 4(-2.75,2.15)
SO8
  oval 2.032x0.66 smd: 1(-2.667,1.905) 2(-2.667,0.635) 3(-2.667,-0.635) 4(-2.667,-1.905) 5(2.667,-1.905) 6(2.667,-0.635) 7(2.667,0.635) 8(2.667,1.905)
SO16_WIDE
  rect 0.584x2.184 smd: 1(-4.445,-4.75) 2(-3.175,-4.75) 3(-1.905,-4.75) 4(-0.635,-4.75) 5(0.635,-4.75) 6(1.905,-4.75) 7(3.175,-4.75) 8(4.445,-4.75) 9(4.445,4.75) 10(3.175,4.75) 11(1.905,4.75) 12(0.635,4.75) 13(-0.635,4.75) 14(-1.905,4.75) 15(-3.175,4.75) 16(-4.445,4.75)
SODIMM_DDR4_260
  round 1.092 hole 1.092 unplated: (-34.4,0)
  rect 3.505x4.623 smd: (-33.8,-12) (33.8,-12)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.279x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
SOIC-8
  rect 0.635x2.032 smd: 1(-1.905,-2.584) 2(-0.635,-2.584) 3(0.635,-2.584) 4(1.905,-2.584) 5(1.905,2.584) 6(0.635,2.584) 7(-0.635,2.584) 8(-1.905,2.584)
SOT23
  rect 0.508x0.432 smd: 1(-0.889,0.94) 2(-0.889,-0.965) 3(0.889,0)
SOT23-BJT
  rect 1.016x1.422 smd: B(-0.95,-1.1) C(0,1.1) E(0.95,-1.1)
SOT-143
  rect 0.864x0.889 smd: 1(-0.914,0.762)
  rect 0.864x0.508 smd: 2(-0.914,-0.965) 3(0.94,-0.965) 4(0.94,0.965)
SWSPDT
  round 2.032 hole 1.524: (-3.5,1.75) (-3.5,-4.25) (11.5,1.75) (11.5,-4.25)
  rect 1.219x1.219 hole 0.711: 1(0,0)
  round 1.219 hole 0.711: 2(4,0) 3(8,0) 4(0,-2.5) 5(4,-2.5) 6(8,-2.5)
TP_020RD_SMT
  round 0.508 smd: 1(0,0)
UBGA324
  round 0.406 smd: A1(-6.8,6.8) A2(-6,6.8) A3(-5.2,6.8) A4(-4.4,6.8) A5(-3.6,6.8) A6(-2.8,6.8) A7(-2,6.8) A8(-1.2,6.8) A9(-0.4,6.8) A10(0.4,6.8) A11(1.2,6.8) A12(2,6.8) A13(2.8,6.8) A14(3.6,6.8) A15(4.4,6.8) A16(5.2,6.8) A17(6,6.8) A18(6.8,6.8) B1(-6.8,6) B2(-6,6) B3(-5.2,6) B4(-4.4,6) B5(-3.6,6) B6(-2.8,6) B7(-2,6) B8(-1.2,6) B9(-0.4,6) B10(0.4,6) B11(1.2,6) B12(2,6) B13(2.8,6) B14(3.6,6) B15(4.4,6) B16(5.2,6) B17(6,6) B18(6.8,6) C1(-6.8,5.2) C2(-6,5.2) C3(-5.2,5.2) C4(-4.4,5.2) C5(-3.6,5.2) C6(-2.8,5.2) C7(-2,5.2) C8(-1.2,5.2) C9(-0.4,5.2) C10(0.4,5.2) C11(1.2,5.2) C12(2,5.2) C13(2.8,5.2) C14(3.6,5.2) C15(4.4,5.2) C16(5.2,5.2) C17(6,5.2) C18(6.8,5.2) D1(-6.8,4.4) D2(-6,4.4) D3(-5.2,4.4) D4(-4.4,4.4) D5(-3.6,4.4) D6(-2.8,4.4) D7(-2,4.4) D8(-1.2,4.4) D9(-0.4,4.4) D10(0.4,4.4) D11(1.2,4.4) D12(2,4.4) D13(2.8,4.4) D14(3.6,4.4) D15(4.4,4.4) D16(5.2,4.4) D17(6,4.4) D18(6.8,4.4) E1(-6.8,3.6) E2(-6,3.6) E3(-5.2,3.6) E4(-4.4,3.6) E5(-3.6,3.6) E6(-2.8,3.6) E7(-2,3.6) E8(-1.2,3.6) E9(-0.4,3.6) E10(0.4,3.6) E11(1.2,3.6) E12(2,3.6) E13(2.8,3.6) E14(3.6,3.6) E15(4.4,3.6) E16(5.2,3.6) E17(6,3.6) E18(6.8,3.6) F1(-6.8,2.8) F2(-6,2.8) F3(-5.2,2.8) F4(-4.4,2.8) F5(-3.6,2.8) F6(-2.8,2.8) F7(-2,2.8) F8(-1.2,2.8) F9(-0.4,2.8) F10(0.4,2.8) F11(1.2,2.8) F12(2,2.8) F13(2.8,2.8) F14(3.6,2.8) F15(4.4,2.8) F16(5.2,2.8) F17(6,2.8) F18(6.8,2.8) G1(-6.8,2) G2(-6,2) G3(-5.2,2) G4(-4.4,2) G5(-3.6,2) G6(-2.8,2) G7(-2,2) G8(-1.2,2) G9(-0.4,2) G10(0.4,2) G11(1.2,2) G12(2,2) G13(2.8,2) G14(3.6,2) G15(4.4,2) G16(5.2,2) G17(6,2) G18(6.8,2) H1(-6.8,1.2) H2(-6,1.2) H3(-5.2,1.2) H4(-4.4,1.2) H5(-3.6,1.2) H6(-2.8,1.2) H7(-2,1.2) H8(-1.2,1.2) H9(-0.4,1.2) H10(0.4,1.2) H11(1.2,1.2) H12(2,1.2) H13(2.8,1.2) H14(3.6,1.2) H15(4.4,1.2) H16(5.2,1.2) H17(6,1.2) H18(6.8,1.2) J1(-6.8,0.4) J2(-6,0.4) J3(-5.2,0.4) J4(-4.4,0.4) J5(-3.6,0.4) J6(-2.8,0.4) J7(-2,0.4) J8(-1.2,0.4) J9(-0.4,0.4) J10(0.4,0.4) J11(1.2,0.4) J12(2,0.4) J13(2.8,0.4) J14(3.6,0.4) J15(4.4,0.4) J16(5.2,0.4) J17(6,0.4) J18(6.8,0.4) K1(-6.8,-0.4) K2(-6,-0.4) K3(-5.2,-0.4) K4(-4.4,-0.4) K5(-3.6,-0.4) K6(-2.8,-0.4) K7(-2,-0.4) K8(-1.2,-0.4) K9(-0.4,-0.4) K10(0.4,-0.4) K11(1.2,-0.4) K12(2,-0.4) K13(2.8,-0.4) K14(3.6,-0.4) K15(4.4,-0.4) K16(5.2,-0.4) K17(6,-0.4) K18(6.8,-0.4) L1(-6.8,-1.2) L2(-6,-1.2) L3(-5.2,-1.2) L4(-4.4,-1.2) L5(-3.6,-1.2) L6(-2.8,-1.2) L7(-2,-1.2) L8(-1.2,-1.2) L9(-0.4,-1.2) L10(0.4,-1.2) L11(1.2,-1.2) L12(2,-1.2) L13(2.8,-1.2) L14(3.6,-1.2) L15(4.4,-1.2) L16(5.2,-1.2) L17(6,-1.2) L18(6.8,-1.2) M1(-6.8,-2) M2(-6,-2) M3(-5.2,-2) M4(-4.4,-2) M5(-3.6,-2) M6(-2.8,-2) M7(-2,-2) M8(-1.2,-2) M9(-0.4,-2) M10(0.4,-2) M11(1.2,-2) M12(2,-2) M13(2.8,-2) M14(3.6,-2) M15(4.4,-2) M16(5.2,-2) M17(6,-2) M18(6.8,-2) N1(-6.8,-2.8) N2(-6,-2.8) N3(-5.2,-2.8) N4(-4.4,-2.8) N5(-3.6,-2.8) N6(-2.8,-2.8) N7(-2,-2.8) N8(-1.2,-2.8) N9(-0.4,-2.8) N10(0.4,-2.8) N11(1.2,-2.8) N12(2,-2.8) N13(2.8,-2.8) N14(3.6,-2.8) N15(4.4,-2.8) N16(5.2,-2.8) N17(6,-2.8) N18(6.8,-2.8) P1(-6.8,-3.6) P2(-6,-3.6) P3(-5.2,-3.6) P4(-4.4,-3.6) P5(-3.6,-3.6) P6(-2.8,-3.6) P7(-2,-3.6) P8(-1.2,-3.6) P9(-0.4,-3.6) P10(0.4,-3.6) P11(1.2,-3.6) P12(2,-3.6) P13(2.8,-3.6) P14(3.6,-3.6) P15(4.4,-3.6) P16(5.2,-3.6) P17(6,-3.6) P18(6.8,-3.6) R1(-6.8,-4.4) R2(-6,-4.4) R3(-5.2,-4.4) R4(-4.4,-4.4) R5(-3.6,-4.4) R6(-2.8,-4.4) R7(-2,-4.4) R8(-1.2,-4.4) R9(-0.4,-4.4) R10(0.4,-4.4) R11(1.2,-4.4) R12(2,-4.4) R13(2.8,-4.4) R14(3.6,-4.4) R15(4.4,-4.4) R16(5.2,-4.4) R17(6,-4.4) R18(6.8,-4.4) T1(-6.8,-5.2) T2(-6,-5.2) T3(-5.2,-5.2) T4(-4.4,-5.2) T5(-3.6,-5.2) T6(-2.8,-5.2) T7(-2,-5.2) T8(-1.2,-5.2) T9(-0.4,-5.2) T10(0.4,-5.2) T11(1.2,-5.2) T12(2,-5.2) T13(2.8,-5.2) T14(3.6,-5.2) T15(4.4,-5.2) T16(5.2,-5.2) T17(6,-5.2) T18(6.8,-5.2) U1(-6.8,-6) U2(-6,-6) U3(-5.2,-6) U4(-4.4,-6) U5(-3.6,-6) U6(-2.8,-6) U7(-2,-6) U8(-1.2,-6) U9(-0.4,-6) U10(0.4,-6) U11(1.2,-6) U12(2,-6) U13(2.8,-6) U14(3.6,-6) U15(4.4,-6) U16(5.2,-6) U17(6,-6) U18(6.8,-6) V1(-6.8,-6.8) V2(-6,-6.8) V3(-5.2,-6.8) V4(-4.4,-6.8) V5(-3.6,-6.8) V6(-2.8,-6.8) V7(-2,-6.8) V8(-1.2,-6.8) V9(-0.4,-6.8) V10(0.4,-6.8) V11(1.2,-6.8) V12(2,-6.8) V13(2.8,-6.8) V14(3.6,-6.8) V15(4.4,-6.8) V16(5.2,-6.8) V17(6,-6.8) V18(6.8,-6.8)
UCSP-12
  round 0.25 smd: A1(-0.75,0.5) A2(-0.25,0.5) A3(0.25,0.5) A4(0.75,0.5) B1(-0.75,0) B2(-0.25,0) B3(0.25,0) B4(0.75,0) C1(-0.75,-0.5) C2(-0.25,-0.5) C3(0.25,-0.5) C4(0.75,-0.5)
UMLP
  rect 0.45x0.25 smd: 1(-0.5,0)
  rect 0.25x0.35 smd: 2(-0.4,-0.45) 3(0,-0.45) 4(0.4,-0.45) 6(0.4,0.45) 7(0,0.45) 8(-0.4,0.45)
  rect 0.35x0.25 smd: 5(0.5,0)
unnamed
  round 1.016 smd: 1(0,0)
unnamed#3
  round 3.2 hole 3.2 unplated: (0,0)
USB-67068-8001
  rect 1.45x1.45 hole 0.94: 1(0,0)
  round 1.45 hole 0.94: 2(-2.49,0) 3(-2.49,-2.01) 4(0,-2.01)
  round 3.07 hole 2.31: 5(-7.26,-4.7) 6(4.78,-4.7)
VISHAY_2520
  rect 1.092x2.007 smd: 1(-0.946,0) 2(0.946,0)
WE_LED1206
  rect 1.397x1.778 smd: 1(-1.46,0) 2(1.46,0)
WIDE2512
  rect 6.502x1.321 smd: 1(0,1.26) 2(0,-1.26)
WSL2010
  rect 1.803x2.692 smd: 1(-2.197,0) 2(2.197,0)
WURTH_6X3P5_TACT_SWITCH
  rect 2.311x1.499 smd: 1(-3.356,0) 2(3.356,0)
XTAL_FA-128
  rect 0.94x0.838 smd: 1(-0.725,-0.575) 2(0.725,-0.575) 3(0.725,0.575) 4(-0.725,0.575)
XTAL_SG310
  rect 1.397x1.194 smd: 1(-1.194,-0.953) 2(1.194,-0.953) 3(1.194,0.953) 4(-1.194,0.953)
ZSU
  round 0.279 smd: A1(-0.75,0.433) A3(-0.25,0.433) A5(0.25,0.433) A7(0.75,0.433) B2(-0.5,0) B4(0,0) B6(0.5,0) C1(-0.75,-0.433) C3(-0.25,-0.433) C5(0.25,-0.433) C7(0.75,-0.433)

## Nets
1.2V: C637.1 C638.1 C639.1 C640.1 C641.1 C1237.1 C1238.1 C2091.1 TP186.1(TP) U15.1 U15.6 U15.10 U15.15 U15.57 U15.62 U15.67 U15.71 U15.85 U32.22 U72.C1 U72.D1 U72.D2 U72.E1 U72.E2(VOUT_4)
1.8V: C727.1 C728.1 C729.1 C730.1 C731.1 C762.1 C763.1 C764.1 C765.1 C766.1 C891.2 C899.2 C905.2 C913.2 C921.2 C929.2 C945.2 C1219.1 C1220.1 C1221.1 C1410.2 C1954.2 FB4.2 FB5.1 FB6.1 FB7.1 FB8.1 FB9.1 FB10.1 FB14.1 L18.2 L19.2 L22.1 L24.1 L26.1 L28.1 L31.1 L33.1 R73.2 R77.2 R307.2 R308.2 R371.1 R372.1 R373.1 R384.2 R385.2 R386.2 R387.2 R412.1 R415.1 R422.1 R433.1 R435.2 R436.2 R445.1 R500.2 R501.2 R504.2 R845.2 R945.2 R946.2 R970.2 R972.2 R974.2 TP184.1(TP) U23.N9 U23.P7 U23.P8 U23.P9 U29.G5 U29.H5 U29.J5 U29.K5 U32.20 U45.1 U70.C10 U70.C11 U70.D10 U70.D11 U70.E9 U70.E10 U70.E11 U70.F9 U70.F10(VOUT_9) U70.F11 U70.G9 U70.G10 U70.G11 U81.1
1.8V_SI5338_0: C831.1 C832.1 C833.1 C834.1 C835.1 C836.1 L18.1 R437.1 U36.7 U36.11(VDDO3) U36.15 U36.16 U36.20 U36.24
1.8V_SI5338_1: C844.1 C845.1 C846.1 C848.1 C849.1 C850.1 L19.1 R448.1 U37.4 U37.7 U37.11(VDDO3) U37.15 U37.16 U37.20 U37.24
2.5V: C372.1 C373.1 C375.1 C395.1 C625.1 C626.1 C642.1 C643.1 C644.1 C645.1 C646.1 C647.1 C648.1 C649.1 C1228.1 C1229.1 C1230.1 C1463.1 C1466.1 C1489.1 C1490.1 C1491.1 C1492.1 C1493.1 C1494.1 C1495.1 C1496.1 C1497.2 C1498.2 C1520.1 C1521.1 C1522.1 C1523.1 C1524.1 C1525.1 C1526.1 C1527.1 C1528.2 C1529.2 C1551.1 C1552.1 C1553.1 C1554.1 C1559.2 C1560.2 C1957.2 CON1.255 CON1.257 CON1.259 D2.2 D3.2 D4.2 D5.2 D6.2 FB15.2 J15.9(VCC) R102.1 R103.1 R241.1 R242.1 R243.1 R244.1 R252.2 TP185.1(TP) U2.B1 U3.B1 U3.R9 U4.B1 U4.R9 U5.B1 U5.R9 U6.B1 U6.R9 U7.B1 U7.R9 U15.5 U15.21 U15.26 U15.32 U15.35 U15.36 U15.40 U15.45 U15.48 U15.52 U15.63 U15.66 U15.72 U15.78 U15.88 U15.96 U16.B1 U32.21 U71.C10 U71.C11 U71.D10 U71.D11 U71.E9 U71.E10 U71.E11 U71.F9 U71.F10(VOUT_9) U71.F11 U71.G9 U71.G10 U71.G11
2.5V_PRE: C1595.1 D41.6(VOUT) R107.1 R986.1
3.3V: C532.1 C533.1 C534.1 C535.1 C536.1 C537.1 C546.1 C547.1 C549.1 C550.1 C551.1 C552.1 C559.1 C560.2 C573.1 C574.1 C576.1 C577.1 C580.2 C582.2 C583.2 C584.2 C660.1 C663.1 C740.1 C741.1 C742.1 C743.1 C744.1 C745.1 C746.1 C747.1 C748.1 C749.1 C750.1 C751.1 C752.1 C753.1 C794.2 C796.1 C841.1 C886.2 C892.2 C900.2 C906.2 C909.2 C915.2 C918.2 C924.2 C930.2 C933.1 C934.1 C936.1 C937.1 C939.1 C940.1 C944.2 C946.2 C947.2 C976.1 C977.1 C978.1 C979.1 C980.1 C981.1 C982.1 C983.1 C984.1 C985.1 C986.2 C1136.1 C1137.2 C1145.1 C1146.2 C1154.1 C1155.2 C1169.1 C1170.2 C1199.1 C1200.2 C1217.1 C1218.2 C1226.1 C1227.2 C1328.1 C1329.1 C1612.1 C1613.2 C1780.1 C1786.1 J10.59 J10.60 J11.59 J11.60 J14.A9 J14.A10 J14.B8 L10.1 L11.1 L12.1 L13.1 L14.1 L15.1 L17.1 L21.1 L23.1 L25.1 L27.1 L29.1 L30.1 L32.1 L34.1 L35.1 R9.2 R10.2 R11.2 R59.2 R194.2 R195.2 R196.1 R197.2 R198.1 R199.2 R201.2 R218.1 R219.1 R220.1 R221.1 R222.1 R224.2 R225.2 R234.2 R284.1 R285.1 R286.1 R287.1 R288.1 R289.1 R290.1 R291.1 R375.2 R376.2 R378.2 R388.1 R389.1 R390.1 R391.1 R394.1 R395.1 R396.2 R397.2 R398.2 R399.2 R400.2 R405.1 R406.1 R438.2 R453.2 R454.2 R496.1 R502.1 R506.2 R507.2 R508.1 R558.1 R573.1 R682.2 R695.2 R704.2 R719.2 R744.1 R751.2 R765.1 R771.2 R780.2 R857.2 R872.2 R873.2 R874.2 R875.2 R883.2 R884.2 R885.1 R886.1 R887.2 R888.2 R889.2 R890.2 R910.2 R911.2 R912.2 R929.1 R930.1 R939.1 R984.2 R1013.2 R5303.1 R5304.1 R5391.1 R5394.1 R5403.1 R5412.1 R5421.1 R5430.1 R5439.1 R5448.1 R6044.2 R6046.2 R6050.2 R6054.2 R6058.2 R6062.2 R6067.2 R6071.2 R6075.2 R6076.2 R6077.2 R6078.2 R6079.2 R6080.2 R6081.2 R6082.2 TP169.1(TP) U10.B1 U11.B1 U13.B1 U14.B1 U18.B6 U19.B6 U29.C3 U29.E7 U29.E8 U29.E9 U29.F7 U29.F9 U29.F13 U29.H10 U29.J9 U29.K10 U29.L9 U29.N6(VCC_ONE#N6) U29.N13 U31.15 U31.17(VCC) U40.B1 U41.B1 U42.B1 U44.8 U45.8(VCCB) U46.3(VCC) U53.A7 U53.A8 U53.A9 U53.A10 U53.B7 U53.B8 U53.B9 U53.B10 U53.B11 U53.B12 U53.C7 U53.C8 U53.C9 U53.D7 U53.K7 U53.K8 U53.K9 U53.K10 U53.K11 U53.L7 U53.L8 U53.L9 U53.L10 U53.L11 U53.L12 U53.M7 U53.M8 U53.M9 U53.M10 U60.C1 U60.C8 U60.C9 U60.D1 U60.D3 U60.D4 U60.D5 U60.D7 U60.D8 U60.D9 U60.E8 U61.C1 U61.C8 U61.C9 U61.D1 U61.D3 U61.D4 U61.D5 U61.D7 U61.D8 U61.D9 U61.E8 U62.C1 U62.C8 U62.C9 U62.D1 U62.D3 U62.D4 U62.D5 U62.D7 U62.D8 U62.D9 U62.E8 U63.C1 U63.C8 U63.C9 U63.D1 U63.D3 U63.D4 U63.D5 U63.D7 U63.D8 U63.D9 U63.E8 U64.C1 U64.C8 U64.C9 U64.D1 U64.D3 U64.D4 U64.D5 U64.D7 U64.D8 U64.D9 U64.E8 U67.10 U68.C1 U68.C8 U68.C9 U68.D1 U68.D3 U68.D4 U68.D5 U68.D7 U68.D8 U68.D9 U68.E8 U69.10 U70.C1 U70.C8 U70.C9 U70.D1 U70.D3 U70.D4 U70.D5 U70.D7 U70.D8 U70.D9 U70.E8 U71.C1 U71.C8 U71.C9 U71.D1 U71.D3 U71.D4 U71.D5 U71.D7 U71.D8 U71.D9 U71.E8 U79.B1 X2.4(VCC)
3.3V_PRE: C489.1 C491.2 C492.2 C585.2 C664.2 C670.1 C671.1 C672.1 C673.1 C674.1 C675.1 C676.1 C677.1 C678.1 C679.1 C680.1 C681.1 C682.1 C683.1 C684.1 C685.2 C687.1 C688.1 C689.1 C690.1 C691.1 C692.1 C693.1 C694.1 C695.1 C696.1 C697.1 C698.1 C699.1 C700.1 C701.1 C702.1 C703.1 C704.1 C705.1 C706.1 C707.1 C708.1 C709.1 C710.1 C711.1 C712.1 C713.1 C714.1 C715.1 C716.1 C717.1 C718.1 C851.1 C943.2 C1411.2 J14.B10 J18.4 J19.4 L16.1 R79.2 R180.2 R181.2 R231.2 R232.2 R233.2 R237.1 R239.1 R240.1 R294.1 R296.2 R297.2 R302.1 R309.1 R311.2 R312.2 R335.2 R336.2 R338.2 R340.2 R341.2 R344.1 R347.1 R348.1 R349.2 R350.2 R351.2 R352.1 R354.2 R355.2 R357.2 R359.2 R363.1 R364.1 R367.1 R368.1 R446.2 R484.2 R486.2 R495.1 R528.1 R529.1 R536.2 R542.2 R543.2 R554.2 R574.2 R575.2 R576.2 R636.2 R639.2 R658.1 R661.2 R687.2 R697.2 R707.2 R725.2 R731.2 R739.2 R745.1 R757.2 R764.1 R776.2 R785.2 R792.1 R844.2 R923.2 R924.2 R928.1 R986.2 R987.2 R990.2 R991.2 R992.2 R993.2 R994.2 R995.2 R996.1 R1001.1 R1019.2 R1054.2 R1055.2 R1056.2 R1057.2 R1066.2 R1075.2 R1129.2 R1130.1 R2295.1 R5311.2 R5977.2 R5998.1 R6007.1 R6015.2 R6035.2 R6043.2 TP165.1(TP) U21.3 U21.7 U21.11 U21.17 U21.27 U21.32 U21.43 U21.55 U22.4(VCC) U23.C3 U23.E7 U23.E8 U23.E9 U23.F7 U23.F9 U23.F13 U23.G5 U23.G13 U23.G14 U23.H5 U23.H10 U23.H13 U23.J5 U23.J9 U23.J13 U23.J14 U23.K5 U23.K10 U23.K14 U23.L5 U23.L6 U23.L9 U23.L13 U23.L14 U23.M5 U23.M13 U23.N6(VCC_ONE#N6) U23.N13 U24.24(VCC) U25.24(VCC) U28.4(VCC) U43.8(VCCB) U49.C1 U49.D1 U49.D2 U49.E1 U49.E2(VOUT_4) U81.8(VCCB) X3.4(VCC)
3.3V_PRE_AGND: C497.1 C2108.2 R1121.2 R6034.2 U49.B4 V4.2(SNS)
3.3V_PRE_R: R302.2 U23.H7
5V: C1178.2 C1179.2 C1185.2 C1187.2 C1622.1 C1650.1 C1979.1 C1998.1 C2017.1 C2044.2 C2045.2 C2047.1 C2095.2 C2096.2 J49.2 J49.8 R546.1 R1098.2 R5971.2 R5972.2 R5973.2 R6037.1 TP167.1(TP) U52.C1 U52.D1 U52.D2 U52.E1 U52.E2(VOUT_4) U65.C5 U65.D5 U65.E5 U66.C5 U66.D5 U66.E5 U72.C5 U72.D5 U72.E5 U87.28 U87.29 U88.28 U88.29 U89.28 U89.29 U90.28 U90.29
5V_AGND: C1827.1 C2097.2 R2298.2 R5994.2 ST18.1 U52.B4
12V: C4.1 C5.2 C7.2 C797.1 C798.2 C799.1 C800.2 C965.2 C968.1 C969.1 C1129.1 C1130.2 C1131.2 C1132.2 C1133.2 C1587.1 C1588.2 C1598.1 C1599.1 C1629.1(P) C1665.2 C1666.2 C1667.2 C1668.2 C1669.1 C1670.1 C1688.1 C1689.1 C1690.2 C1691.2 C1692.2 C1693.2 C1711.1 C1712.1 C1713.2 C1714.2 C1715.2 C1716.2 C1734.1 C1735.1 C1736.2 C1737.2 C1738.2 C1739.2 C1743.1 C1796.1 C1844.1(P) C1845.2 C1846.2 C1847.2 C1848.1 C1901.1 C2068.1(P) C2069.1(P) C2070.1(P) J5.1 J5.60 J20.2 J21.2 R541.2 R5323.2 R5996.2 U50.1 U50.2 U50.3(S3) U51.6(VOUT) U54.32 U57.D1 U57.J1 U58.D1 U58.J1 U59.A11 U59.A12 U59.B11 U59.B12 U59.C11 U59.C12 U59.D11 U59.D12 U59.E12 U59.F11 U59.F12 U59.H12 U59.J11 U59.J12 U59.K11 U59.K12 U59.L11 U59.L12 U59.M11 U59.M12 U83.1 U83.2 U83.3(S3) U84.2 U87.20 U87.21 U87.37 U87.38 U87.43(VIN5) U88.20 U88.21 U88.37 U88.38 U88.43(VIN5) U89.20 U89.21 U89.37 U89.38 U89.43(VIN5) U90.20 U90.21 U90.37 U90.38 U90.43(VIN5)
12V_DCIN: C948.1 C949.2 D35.1(CATHODE) J37.1 J37.2 J37.3 R521.2 R522.1 R997.1 R998.1 U48.2(VDD) V2.1
12V_IN: C486.1 C487.1 C950.1 C951.1 C952.1 C953.1 C954.1 C966.1 C967.1 C1596.2 C1597.1 C1817.1 C1896.1 C2048.1 R509.2 R511.1 R516.1 R517.1 R520.2 R533.1 R1126.1 R5312.2 TP166.1(TP) U47.1 U47.2 U47.3(S3) U48.8 U49.C5 U49.D5 U49.E5 U50.5 U50.6 U50.7 U50.8 U51.4 U52.C5 U52.D5 U52.E5 U53.D1 U53.J1 U82.3(VCC)
12V_PCIE: C608.2 C609.2 C610.2 C611.2 C612.2 C613.2 C614.2 C1593.1 C1594.1 J14.A2 J14.A3 J14.B1 J14.B2 J14.B3 U83.5 U84.1 U84.6(VDD)
AGND_1.2V: C2094.1 C2098.2 R794.2 R5484.2 ST21.1 U72.B4
AGND_1.8V: R775.2 R5445.2 R5447.2 R6070.1 R6084.2 ST10.1 U70.E1
AGND_2.5V: R784.2 R5454.2 R5456.2 R6074.1 R6083.2 ST11.1 U71.E1
AGND_3.3V: C1899.1 C1900.1 R553.2 R5320.1 R5322.1 ST1.1 U53.C11(WP) U53.F9 U53.F10 U53.G9 U53.G10
AGND_VCCCLK_GXE_FPGA_2.5V: C2079.1 C2100.2 R6005.2 R6006.2 ST13.1 U65.B4
AGND_VCCFUSEWR_SDM_FPGA_2.4V: C1975.1 C2099.2 R982.1 R5970.2 R6013.2 R6040.2 ST20.1 U66.B4
AGND_VCCH_FPGA_0.9V: C1961.2 C1962.1 R1134.1 R1140.2 R5461.1 R5690.1 R5692.1 R5963.1 R5964.1 ST19.1 U57.F9 U57.F10 U57.G9 U57.G10
AGND_VCCH_GXE_FPGA_1.1V: R702.2 R5409.2 R5411.2 R6053.1 R6088.2 ST6.1 U62.E1
AGND_VCCIO_FPGA_1.2V: C1966.2 R663.2 R668.1 R5469.2 R5475.1 R5476.1 R5478.1 R5479.2 R5480.1 ST3.1 U59.F7 U59.F8 U59.G7 U59.G8
AGND_VCCIO_FPGA_1.5V: R724.2 R5427.2 R5429.2 R6061.1 R6086.2 ST8.1 U64.E1
AGND_VCCIO_FPGA_1.8V: R1018.2 R5418.2 R5420.2 R6057.1 R6087.2 ST16.1 U63.E1
AGND_VCCL_HPS_FPGA_0.9V: R684.2 R686.2 R5393.2 R6045.1 R6090.2 ST4.1 U60.E1
AGND_VCCL_SDM_FPGA_0.8V: R694.2 R5400.2 R5402.2 R6049.1 R6089.2 ST5.1 U61.E1
AGND_VCCPT_FPGA_1.8V: C1922.1 C1923.2 R5324.2 R5330.1 R5333.1 R6038.1 ST2.1 U58.C11(WP) U58.F9 U58.F10 U58.G9 U58.G10
