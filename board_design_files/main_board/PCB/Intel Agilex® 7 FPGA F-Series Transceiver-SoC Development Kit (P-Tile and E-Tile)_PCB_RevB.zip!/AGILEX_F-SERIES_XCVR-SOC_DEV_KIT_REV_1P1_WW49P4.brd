# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FPGA_PB1: length 166
  ART18 w0.114: v2(119.99,119.6) 120.05,119.66 120.93,119.66 121.49,119.1 121.92,119.1 122.42,119.6 122.8,119.6 123.28,119.11 123.7,119.11 124.3,119.71 124.48,119.71 124.7,119.94 124.7,122.65 125.48,123.42 126.15,123.42 126.5,123.77 127.02,123.77 127.33,124.08 127.33,127.23 127.54,127.44 132.18,127.44 133.14,128.4 139.29,128.4 141.2,130.3 141.2,135.54 140.06,136.68 140.06,144.45 138.81,145.69 138.81,150.37 142.24,153.8 144.36,153.8 145.63,155.07 160.3,155.07 165.64,160.4 170.08,160.4 172,162.32 172.81,162.32 178.59,168.1 178.59,172.14 177.93,172.8 177.93,184.66 179.25,185.98 179.25,191.72 176.28,194.69 172.59,194.69 168.91,198.37 161.42,198.37 158.37,195.33 v2(158.37,194.94)
  ART20 w0.114: v2(141.99,195.39) 142.81,194.56 157.99,194.56 v2(158.37,194.94)
  BOTTOM w0.109: C1399.2 v2(141.99,195.39) R276.1
FPGA_PB2: length 226.9
  ART20 w0.114: v2(146.43,195.33) 149.86,195.33 151,196.47 170.05,196.47 170.94,195.58 176.78,195.58 178.82,193.55 182.02,193.55 183.79,191.78 183.79,190.9 183.77,190.88 183.77,189.48 187.05,186.21 196.04,186.21 198.2,188.37 198.2,188.78 198.81,189.38 203.64,189.38 203.79,189.53 205.21,189.53 205.97,188.77 205.97,186.64 205.76,186.43 205.76,186.29 205.52,186.04 205.52,184.81 204.9,184.19 204.9,183.64 201.07,179.81 199.39,179.81 198.98,179.4 196.98,179.4 196.37,180.01 187.63,180.01 186.44,178.82 186.44,171.83 187.71,170.56 187.71,169.67 185.6,167.56 181.94,167.56 181.93,167.55 181.45,167.55 179.27,165.38 179.27,165 176.43,162.16 176.43,162.06 176.16,161.79 176.07,161.79 174.35,160.07 170.61,160.07 168.78,158.24 165.28,158.24 160.71,153.67 140.92,153.67 139.29,152.04 139.29,141.76 139.88,141.17 139.88,139.3 140.64,138.54 140.64,118.43 136.8,114.59 136.19,114.59 135.7,114.1 135.37,114.1 134.9,113.63 134.49,113.63 133.99,113.12 133.62,113.12 132.08,111.58 131.03,111.58 130.62,111.18 130.18,111.18 129.71,111.65 129.3,111.65 128.79,111.14 128.44,111.14 127.91,110.62 127.58,110.62 127.09,110.12 126.71,110.12 126.2,110.63 125.86,110.63 125.06,111.43 122.12,111.43 121.31,112.24 121.31,117.3 121.02,117.59 120.74,117.59 120.23,118.1 v2(119.12,118.1)
  BOTTOM w0.109: C1400.2 146.62,195.39 146.56,195.33 v2(146.43,195.33) 146.3,195.33 146.24,195.39 R277.1
FPGA_PB3: length 219.2
  ART20 w0.114: v2(150.75,195.33) 151.51,196.09 169.9,196.09 170.91,195.07 176.66,195.07 178.56,193.17 181.86,193.17 183.41,191.62 183.41,189.34 186.97,185.78 198.5,185.78 200.89,188.16 203,188.16 203.43,188.6 203.43,188.72 203.9,189.19 204.59,189.19 205.44,188.33 205.44,186.42 205.2,186.18 205.2,185.16 204.59,184.55 204.59,184.29 204.58,184.28 204.58,184.16 202.54,182.12 199.9,182.12 199.54,181.76 196.9,181.76 196.29,181.15 188.14,181.15 186.08,179.09 186.08,171.68 187.32,170.43 187.32,169.8 185.41,167.88 181.81,167.88 181.8,167.87 179.89,167.87 176.19,164.17 176.19,163.49 173.13,160.43 170.46,160.43 168.66,158.62 165.1,158.62 160.53,154.05 140.77,154.05 138.96,152.25 138.96,141.48 139.56,140.88 139.56,139.17 140.25,138.48 140.25,118.88 136.97,115.61 136.25,115.61 135.7,115.06 135.31,115.06 134.81,114.57 134.49,114.57 134.02,114.1 133.64,114.1 133.16,113.61 132.8,113.61 132.27,113.08 131.9,113.08 131.44,112.62 131.05,112.62 130.52,112.09 128.41,112.09 127.94,111.62 127.55,111.62 127.08,111.15 126.71,111.15 126.05,111.81 123.13,111.81 122.16,112.78 122.16,117.86 121.87,118.15 121.45,118.15 120.95,118.64 120.69,118.64 120.23,119.1 v2(119.12,119.1)
  BOTTOM w0.109: C1401.2 150.75,195.33 v2(150.75,195.33) R278.1
FPGA_PB4: length 143.5
  ART18 w0.114: v2(155.32,195.33) 157.1,193.55 158.37,193.55 159.45,194.63 159.7,194.63 161.29,196.22 169.58,196.22 172.25,193.55 175.13,193.55 176.4,192.28 176.4,189.74 176.78,189.36 176.78,180.47 176.02,179.71 176.02,176.83 176.66,176.2 176.66,171.04 176.02,170.41 176.02,169.47 176.28,169.21 176.28,167.51 175.04,166.28 174.35,166.28 169.62,161.54 164.97,161.54 159.64,156.21 145.16,156.21 143.89,154.94 141.6,154.94 137.29,150.62 137.29,143.84 139.06,142.06 139.06,136.14 140.24,134.97 140.24,130.94 138.78,129.48 132.81,129.48 131.73,128.4 125.97,128.4 125.05,127.47 125.05,124.06 124.36,123.37 123.82,123.37 123.04,122.58 123.04,121.02 v2(123.45,120.6)
  BOTTOM w0.109: R280.1 155.26,195.39 v2(155.32,195.33) 155.38,195.39 C1402.2
FPGA_PB5: length 137.8
  ART18 w0.114: v2(159.77,195.39) 161.86,197.49 168.78,197.49 172.34,193.93 175.26,193.93 176.78,192.41 176.78,189.99 177.16,189.61 177.16,172.39 177.77,171.78 177.77,168.4 175.31,165.94 174.6,165.94 173.81,165.15 173.81,164.57 172.31,163.07 171.63,163.07 169.72,161.16 165.1,161.16 159.77,155.83 145.32,155.83 144.05,154.56 141.86,154.56 137.79,150.5 137.79,145.39 139.42,143.76 139.42,136.3 140.56,135.16 140.56,130.81 138.91,129.16 132.94,129.16 131.86,128.08 126.1,128.08 125.37,127.34 125.37,124.01 124.39,123.04 123.8,123.04 123.45,122.69 v2(123.45,121.6)
  BOTTOM w0.109: C1403.2 v2(159.77,195.39) R281.1
FPGA_PB6: length 130
  ART18 w0.114: v2(122.58,121.1) 122.58,121.51 122.15,121.95 122.15,122.43 123.84,124.12 123.84,127.67 125.19,129.03 131.42,129.03 132.53,130.15 138.5,130.15 139.57,131.22 139.57,134.42 136.25,137.74 136.25,150.6 141.35,155.7 143.48,155.7 144.75,156.97 159.38,156.97 166.12,163.7 170.71,163.7 174.37,167.36 174.37,179.56 176.03,181.21 176.03,184.67 175.64,185.06 175.64,191.77 174.62,192.79 171.93,192.79 169.85,194.87 168.4,194.87 167.94,195.33 v2(164.21,195.33)
  BOTTOM w0.109: C1404.2 164.78,195.33 v2(164.21,195.33) 163.64,195.33 R282.1
FPGA_PB7: length 124.7
  ART18 w0.114: v2(168.66,195.45) 169.8,195.45 172.09,193.17 174.88,193.17 176.02,192.02 176.02,186.56 176.4,186.18 176.4,180.92 174.8,179.32 174.8,167.26 170.87,163.32 166.27,163.32 159.54,156.59 144.91,156.59 143.64,155.32 141.48,155.32 136.78,150.62 136.78,143.76 138.73,141.81 138.73,135.97 139.93,134.77 139.93,131.07 138.65,129.79 132.68,129.79 131.6,128.71 125.82,128.71 124.72,127.61 124.72,124.06 124.32,123.66 123.73,123.66 122.58,122.51 v2(122.58,122.1)
  BOTTOM w0.109: R283.1 168.08,195.45 v2(168.66,195.45) 169.1,195.45 C1405.2
FPGA_SW0: length 110.2
  ART20 w0.114: v2(123.45,118.6) 123.88,118.18 123.88,113.91 124.17,113.61 124.52,113.61 125.01,113.13 125.37,113.13 125.87,112.64 126.24,112.64 126.75,113.14 128.17,113.14 128.65,113.63 129.64,113.63 130.09,114.07 130.48,114.07 131,114.59 131.36,114.59 131.94,115.18 132.28,115.18 133.05,115.94 133.69,115.94 134.87,117.12 135.71,117.12 136.25,117.65 136.59,117.65 137.05,118.11 137.93,118.11 138.93,119.1 138.93,140.25 138.28,140.89 138.28,152.6 140.42,154.75 160.21,154.75 164.85,159.38 168.44,159.38 171.22,162.17 172.75,162.17 174.98,164.4 175.39,164.4 179.78,168.78 183.09,168.78 v2(184.33,170.03)
FPGA_SW1: length 110.8
  ART20 w0.114: v2(123.45,119.6) 124.44,119.6 124.78,119.27 124.78,114.4 125.09,114.08 125.36,114.08 125.86,113.59 127.99,113.59 128.92,114.52 129.57,114.52 130.19,115.14 130.56,115.14 131.04,115.62 132.14,115.62 133.01,116.48 133.65,116.48 135.81,118.64 136.6,118.64 136.87,118.91 136.87,122.9 136.98,123.01 136.98,130.38 137.52,130.92 137.52,141.05 136.98,141.58 136.98,151.79 140.26,155.07 160.02,155.07 164.72,159.77 168.31,159.77 171.03,162.48 172.62,162.48 174.85,164.71 175.13,164.71 179.56,169.14 182.73,169.14 184.03,170.44 185.19,170.44 v2(185.6,170.03)
FPGA_SW2: length 114.7
  ART20 w0.114: v2(186.87,170.03) 185.12,168.28 179.84,168.28 175.88,164.31 175.88,163.73 173.3,161.16 170.69,161.16 168.53,159 164.93,159 160.33,154.41 140.61,154.41 138.63,152.43 138.63,141.22 139.24,140.61 139.24,139.04 139.85,138.43 139.85,119.27 137.21,116.62 136.27,116.62 135.71,116.07 135.37,116.07 134.92,115.62 134.35,115.62 133.86,115.13 133.67,115.13 133.08,114.54 132.75,114.54 132.3,114.08 131.81,114.08 131.32,113.59 130.92,113.59 130.45,113.12 128.61,113.12 128.12,112.62 127.57,112.62 127.06,112.12 124.96,112.12 124.46,112.61 124.16,112.61 123.67,113.09 123.3,113.09 123.06,113.33 123.06,117.62 v2(122.58,118.1)
FPGA_SW3: length 104.9
  ART16 w0.114: v2(188.14,170.03) 188.14,165.08 185.8,162.74 185.8,157.48 183.51,155.19 182.5,155.19 179.71,152.4 178.31,152.4 177.55,153.16 175.51,153.16 174.88,152.53 173.48,152.53 172.85,153.16 170.56,153.16 169.93,152.53 168.53,152.53 168.02,153.03 158.24,153.03 157.61,152.4 157.61,151.79 157.16,151.34 156.63,151.34 156.18,150.9 156.18,148.97 153.8,146.59 153.8,138.56 152.4,137.16 146.43,137.16 142.03,132.76 132.21,132.76 130.77,131.32 127.05,131.32 123.8,128.07 123.8,123.02 123.01,122.24 123.01,119.53 v2(122.58,119.1)
FPGA_SW4: length 107.1
  ART16 w0.114: v2(189.41,170.03) 188.88,170.56 188.09,170.56 187.71,170.18 187.71,165.23 185.45,162.97 185.45,158.78 179.58,152.91 178.44,152.91 177.8,153.54 175.26,153.54 174.62,152.91 173.86,152.91 173.23,153.54 170.31,153.54 169.67,152.91 168.91,152.91 168.4,153.42 157.71,153.42 155.01,150.72 155.01,148.41 153.42,146.81 153.42,138.68 152.27,137.54 146.3,137.54 141.97,133.21 131.84,133.21 130.34,131.71 126.71,131.71 122.75,127.75 122.75,123.19 122.15,122.59 122.15,119.03 v2(121.72,118.6)
FPGA_SW5: length 106.8
  ART16 w0.114: v2(190.68,170.03) 189.77,170.94 187.96,170.94 187.32,170.31 187.32,165.38 185.04,163.09 185.04,159.26 179.71,153.92 157.73,153.92 154.63,150.82 154.63,149.99 153.03,148.39 153.03,139.06 151.89,137.92 146.18,137.92 143.91,135.65 133.46,135.65 130.14,132.33 126.33,132.33 122.33,128.34 122.33,123.34 121.32,122.33 121.32,120 v2(121.72,119.6)
FPGA_SW6: length 113.2
  ART16 w0.114: v2(191.95,170.03) 190.28,171.7 187.2,171.7 186.06,170.56 186.06,165.43 184.33,163.7 184.33,159.53 179.48,154.69 157.28,154.69 154.68,152.09 154.68,152.02 152.27,149.61 152.27,139.7 151.26,138.68 145.8,138.68 143.51,136.4 132.94,136.4 129.64,133.1 125.23,133.1 120.28,128.14 120.28,123.75 119.52,122.99 119.52,118.38 119.8,118.1 v2(120.85,118.1)
FPGA_SW7: length 111.9
  ART16 w0.114: v2(120.85,119.1) 120.38,119.57 120.38,123.15 121.28,124.05 121.28,128.27 125.73,132.71 129.91,132.71 133.21,136.02 143.64,136.02 145.92,138.3 151.64,138.3 152.65,139.32 152.65,149.54 157.42,154.31 179.64,154.31 184.68,159.35 184.68,163.35 186.44,165.1 186.44,170.43 187.32,171.32 189.99,171.32 191.77,169.54 192.74,169.54 v2(193.22,170.03)
FPGA_SYS_RESETN: length 91.1
  ART16 w0.114: v2(129.51,119.1) 129.06,119.56 129.06,122.47 129.91,123.32 129.91,126.73 131.19,128.02 146.46,128.02 147.24,128.8 154.58,128.8 156.29,130.51 v2(156.29,132.64)
  ART20 w0.114: v2(156.29,132.64) 158.57,132.64 160.52,130.7 164.67,130.7 165.02,130.34 165.02,129.51 165.47,129.07 166.41,129.07 166.98,128.5 167.18,128.5 168.58,127.1 168.58,125.93 169.33,125.18 170.73,125.18 170.99,124.92 170.99,124.33 172.19,123.14 172.19,122.02 172.59,121.62 173.28,121.62 174.96,119.94 174.96,115.62 173.94,114.6 173.94,109.6 169.75,105.41 169.75,103.71 167.44,101.4 164.13,101.4 163.77,101.03 163.77,100.48 v2(164.27,99.98)
FPGA_SYSTEM_CLK: length 125.6
  ART16 w0.114: v2(50.93,104.29) 52.98,104.29 54,105.3 54,111.63 57.53,115.16 61.11,115.16 64.44,118.49 64.44,125.4 v2(64.62,125.58)
  BOTTOM w0.109: v2(64.62,125.58) 64.62,128.78 74.52,138.68 78.97,138.68 80.36,137.29 108.18,137.29 110.34,139.45 112.49,139.45 113,138.94 114.15,138.94 115.92,137.16 115.92,130.81 114.65,129.54 114.65,124.59 115.67,123.57 123.16,123.57 123.9,122.83 123.9,116.8 124.18,116.52 124.46,116.52 124.74,116.24 124.74,115.44 125.02,115.16 125.4,115.16 125.88,114.68 126.02,114.68 R1028.1 ; R452.1 v2(50.93,104.29)
FPGA_TEMP0N: length 81.5
  TOP w0.254: v3(169.49,116.29) 169.49,115.45 C793.2 169.69,115.23 U31.24
  ART07 w0.254: v2(129.51,92.1) 129.17,92.44 129.17,92.79 128.83,93.14 128.83,93.54 128.22,94.15 128.22,95.38 128.19,95.41 128.19,97.79 128.22,97.82 128.22,97.89 128.24,97.91 128.24,98.29 128.22,98.31 128.22,98.38 128.19,98.41 128.19,98.79 128.22,98.82 128.22,98.89 128.24,98.91 128.24,99.29 128.22,99.31 128.22,99.38 128.19,99.41 128.19,99.79 128.22,99.82 128.22,99.89 128.24,99.91 128.24,100.29 128.22,100.31 128.22,100.38 128.19,100.41 128.19,100.79 128.22,100.82 128.22,100.89 128.24,100.91 128.24,101.29 128.22,101.31 128.22,101.38 128.19,101.41 128.19,101.79 128.22,101.82 128.22,101.89 128.24,101.91 128.24,102.29 128.22,102.31 128.22,102.38 128.19,102.41 128.19,102.79 128.22,102.82 128.22,102.89 128.24,102.91 128.24,103.29 128.22,103.31 128.22,103.38 128.19,103.41 128.19,103.79 128.22,103.82 128.22,103.89 128.24,103.91 128.24,104.29 128.22,104.31 128.22,104.38 128.19,104.41 128.19,104.79 128.22,104.82 128.22,104.89 128.24,104.91 128.24,105.29 128.22,105.31 128.22,105.38 128.18,105.42 128.18,105.78 128.22,105.82 128.22,105.89 128.24,105.91 128.24,106.29 128.22,106.31 128.22,106.38 128.19,106.41 128.19,106.79 128.22,106.82 128.22,106.89 128.24,106.91 128.24,107.29 128.22,107.31 128.22,107.38 128.19,107.41 128.19,107.79 128.22,107.82 128.22,107.89 128.24,107.91 128.24,108.29 128.22,108.31 128.22,108.38 128.19,108.41 128.19,108.86 128.24,108.91 128.24,109.29 128.19,109.34 128.19,109.89 128.4,110.1 128.79,110.1 129.34,110.64 129.72,110.64 130.21,111.14 130.62,111.14 131.06,111.58 133.18,111.58 133.65,112.06 134.02,112.06 134.52,112.56 134.86,112.56 135.43,113.13 135.81,113.13 136.24,113.56 138.18,113.56 140.82,116.2 142.01,116.2 142.85,117.04 142.85,125.04 143.94,126.14 148.71,126.14 149.24,125.6 154.82,125.6 155.25,126.03 163.8,126.03 164.29,125.55 164.29,124.63 165.48,123.44 165.96,123.44 169.82,119.58 169.82,116.63 v3(169.49,116.29)
FPGA_TEMP0P: length 87.1
  TOP w0.254: U31.23 170.19,114.47 170.2,114.48 170.2,115.27 C793.1 170.37,116.06 170.37,116.07 v3(170.37,116.29)
  ART07 w0.254: v2(129.51,91.1) 128.47,91.1 128.12,91.45 128.12,92.79 128.24,92.91 128.24,93.42 127.47,94.19 127.47,97.76 127.32,97.91 127.32,98.29 127.47,98.44 127.47,98.76 127.32,98.91 127.32,99.29 127.47,99.44 127.47,99.76 127.32,99.91 127.32,100.29 127.47,100.44 127.47,100.76 127.32,100.91 127.32,101.29 127.47,101.44 127.47,101.76 127.32,101.91 127.32,102.29 127.47,102.44 127.47,102.76 127.32,102.91 127.32,103.29 127.47,103.44 127.47,103.76 127.32,103.91 127.32,104.29 127.47,104.44 127.47,104.76 127.32,104.91 127.32,105.29 127.47,105.44 127.47,105.76 127.32,105.91 127.32,106.29 127.47,106.44 127.47,106.76 127.32,106.91 127.32,107.29 127.47,107.44 127.47,107.76 127.32,107.91 127.32,108.29 127.47,108.44 127.47,108.76 127.32,108.91 127.32,109.36 127.37,109.41 127.37,109.79 127.32,109.84 127.32,110.29 127.59,110.56 127.65,110.56 127.74,110.64 127.97,110.64 128.47,111.14 128.84,111.14 129.4,111.71 129.84,111.71 130.28,112.14 130.57,112.14 131.02,112.6 131.47,112.6 131.92,112.14 132.3,112.14 132.76,112.6 133.15,112.6 133.59,113.04 133.64,113.04 133.65,113.06 133.96,113.06 134.47,113.56 134.87,113.56 135.44,114.13 135.83,114.13 136.25,114.56 136.63,114.56 137.24,113.94 138.02,113.94 140.66,116.59 141.85,116.59 142.47,117.2 142.47,125.2 143.78,126.52 148.87,126.52 149.4,125.98 154.66,125.98 155.09,126.42 163.96,126.42 164.67,125.7 164.67,124.79 165.63,123.83 166.12,123.83 170.21,119.74 170.21,116.45 v3(170.37,116.29)
FPGA_TEMP1N: length 83
  TOP w0.254: v3(166.31,113.35) 167.13,113.35 C791.2 167.78,113.35 168.49,112.64 U31.2
  ART03 w0.254: v2(101.8,105.1) 102.2,105.5 102.2,105.85 102.44,106.09 102.81,106.09 103.31,106.59 103.69,106.59 104.21,107.11 104.59,107.11 105.08,107.59 105.41,107.59 105.74,107.92 105.74,108.28 105.56,108.46 105.56,108.75 105.9,109.09 106.31,109.09 106.82,109.6 107.19,109.6 107.69,110.11 108.05,110.11 108.5,110.56 108.92,110.56 109.38,110.1 109.81,110.1 110.27,110.56 110.65,110.56 111.12,110.08 111.53,110.08 112,110.56 112.38,110.56 112.81,110.13 113.31,110.13 113.74,110.56 114.11,110.56 114.55,110.12 115.02,110.12 115.47,110.57 115.8,110.57 116.32,111.09 116.72,111.09 117.26,111.62 117.59,111.62 118.11,112.14 118.41,112.14 118.42,112.14 118.44,112.14 118.71,112.41 118.71,112.79 118.67,112.83 118.67,112.91 118.66,112.91 118.66,113.29 118.67,113.29 118.67,113.37 118.71,113.41 118.71,113.79 118.67,113.83 118.67,113.91 118.66,113.91 118.66,114.29 118.67,114.29 118.67,114.37 118.71,114.41 118.71,114.79 118.67,114.83 118.67,114.91 118.66,114.91 118.66,115.29 119.33,115.95 119.33,116.64 119.78,117.09 120.17,117.09 120.65,117.58 121.05,117.58 121.53,118.06 121.84,118.06 122.39,118.6 122.81,118.6 123.26,119.06 123.63,119.06 124.13,119.56 124.51,119.56 124.51,119.55 124.52,119.55 124.94,119.13 125.43,119.13 125.86,119.56 126.24,119.56 126.24,119.56 126.27,119.56 126.73,119.09 127.19,119.09 128.21,118.07 130.57,118.07 131.06,118.56 131.48,118.56 131.98,118.06 132.28,118.06 132.82,118.6 133.48,118.6 134.03,118.06 135.56,118.06 136.06,118.56 136.63,118.56 137.13,118.06 137.56,118.06 137.83,118.32 138.34,118.32 140.26,116.41 140.42,116.41 140.45,116.43 141.55,116.43 141.57,116.41 144.48,116.41 144.96,116.89 159.2,116.89 162.56,113.54 166.12,113.54 v3(166.31,113.35)
FPGA_TEMP1P: length 84.6
  TOP w0.254: v3(166.31,114.23) 166.31,114.22 166.67,114.22 166.68,114.23 C791.1 167.43,114.23 168.53,113.14 U31.1
  ART03 w0.254: v2(100.07,106.1) 101.09,106.1 101.59,106.59 101.94,106.59 102.46,107.11 102.9,107.11 103.34,107.56 103.64,107.56 104.21,108.13 104.57,108.13 104.86,108.41 104.86,108.79 104.85,108.8 104.85,108.91 104.73,109.03 104.73,109.23 105.1,109.6 105.41,109.6 105.92,110.11 106.32,110.11 106.83,110.62 107.19,110.62 107.66,111.09 108,111.09 108.49,111.58 108.96,111.58 109.43,111.11 109.79,111.11 110.23,111.56 110.65,111.56 111.08,111.13 111.54,111.13 112.03,111.61 112.39,111.61 112.87,111.13 113.23,111.13 113.69,111.58 114.14,111.58 114.63,111.1 114.99,111.1 115.49,111.61 115.85,111.61 116.3,112.06 116.66,112.06 117.8,113.2 117.8,113.79 117.86,113.85 117.86,114.35 117.8,114.41 117.8,114.79 117.85,114.84 117.85,115.36 117.8,115.41 117.8,115.79 117.89,115.89 117.89,116.31 117.8,116.41 117.8,116.79 118.15,117.14 118.44,117.14 118.9,117.6 119.28,117.6 119.78,118.11 120.16,118.11 120.67,118.62 121.04,118.62 121.51,119.09 121.93,119.09 122.4,119.56 122.71,119.56 123.21,120.06 123.63,120.06 124.13,120.56 124.51,120.56 124.96,120.1 125.41,120.1 125.86,120.56 126.24,120.56 126.65,120.14 126.75,120.14 126.77,120.12 127.09,120.12 127.62,119.58 129.72,119.58 130.2,119.1 130.53,119.1 131.01,119.58 131.42,119.58 131.9,119.1 132.28,119.1 132.74,119.56 133.24,119.56 133.65,119.14 135.6,119.14 136.01,119.56 136.63,119.56 137.09,119.1 137.56,119.1 137.92,118.75 138.49,118.75 140.45,116.79 144.32,116.79 144.8,117.27 159.36,117.27 162.71,113.92 165.99,113.92 v3(166.31,114.23)
FPGA_TEMP2N: length 54.5
  TOP w0.254: U31.4 168.41,111.64 168.41,111.63 167.45,111.63 C792.2 167.13,111.32 v3(166.31,111.32)
  ART05 w0.254: v2(124.32,109.1) 124.32,109.41 123.83,109.9 123.83,110.26 124.64,111.07 125.38,111.07 125.86,111.56 125.88,111.56 126.47,112.14 127.1,112.14 127.37,112.41 127.37,112.45 128.05,113.13 130.58,113.13 131.01,113.56 131.49,113.56 131.95,113.11 132.25,113.11 132.89,112.47 133.14,112.47 133.55,112.06 134.08,112.06 134.52,111.63 134.9,111.63 135.34,112.07 135.77,112.07 136.23,111.61 136.63,111.61 137.06,112.04 137.46,112.04 137.85,112.42 138.76,112.42 140.46,114.12 140.46,115.54 141.38,116.46 144.7,116.46 145.06,116.81 153.14,116.81 154.15,115.8 161.26,115.8 165.48,111.58 166.04,111.58 v3(166.31,111.32)
FPGA_TEMP2P: length 56.9
  TOP w0.254: v3(166.31,112.2) 166.31,112.2 C792.1 167.65,112.2 167.84,112.01 168.25,112.01 168.37,112.14 U31.3
  ART05 w0.254: v3(166.31,112.2) 166.07,111.96 165.64,111.96 161.42,116.18 154.31,116.18 153.29,117.2 144.9,117.2 144.55,116.84 141.24,116.84 140.11,115.7 140.11,114.27 138.61,112.78 137.9,112.78 137.52,113.16 137.16,113.16 136.63,112.62 136.27,112.62 135.77,113.12 135.42,113.12 134.87,112.57 134.51,112.57 134.03,113.06 134.03,113.06 133.96,113.13 133.65,113.13 133.17,113.61 132.76,113.61 132.32,114.06 131.95,114.06 131.45,114.56 131.06,114.56 131.05,114.55 131.01,114.55 130.58,114.12 130.22,114.12 129.74,113.64 127.84,113.64 127.26,113.06 126.73,113.06 126.32,112.65 126.26,112.65 125.67,112.07 125.65,112.07 125.17,111.58 123.7,111.58 122.89,110.78 122.89,110.52 123.04,110.38 123.04,110.29 123.04,110.29 123.04,109.91 123.04,109.91 123.04,109.86 122.93,109.75 122.93,109.4 123.45,108.88 v2(123.45,108.6)
FPGA_TEMP3N: length 59.1
  TOP w0.254: U31.7 168.27,109.93 167.74,109.4 167.25,109.4 C795.2 167.13,109.29 v3(166.31,109.29)
  ART05 w0.254: v2(121.72,108.6) 122.01,108.31 122.01,108.03 122.4,107.64 122.76,107.64 123.23,107.18 123.26,107.14 123.63,107.14 124.13,106.64 124.51,106.64 125.01,107.14 125.37,107.14 125.87,107.64 126.24,107.64 126.51,107.91 126.51,108.29 126.42,108.38 126.42,108.82 126.51,108.91 126.51,108.93 126.69,109.12 127.1,109.12 127.62,109.64 127.97,109.64 128.24,109.91 128.24,110.36 128.19,110.41 128.19,110.79 128.46,111.06 128.82,111.06 129.32,111.56 129.7,111.56 129.73,111.53 129.74,111.53 130.12,111.15 130.18,111.15 130.19,111.14 130.57,111.14 130.57,111.15 130.65,111.15 131.06,111.56 131.09,111.56 131.16,111.63 131.74,111.63 131.89,111.48 131.98,111.48 132.03,111.43 132.37,111.43 133.65,110.14 133.7,110.14 133.78,110.06 134.11,110.06 134.52,109.64 134.94,109.64 135.35,110.06 135.38,110.06 135.39,110.06 135.76,110.06 135.77,110.06 135.81,110.06 136.24,109.63 136.63,109.63 137.13,110.13 137.49,110.13 138.17,110.82 138.55,110.82 141.15,110.82 144.15,113.82 144.15,114.47 144.71,115.04 151.87,115.04 152.65,114.25 160.9,114.25 165.6,109.55 166.04,109.55 v3(166.31,109.29)
FPGA_TEMP3P: length 57.2
  TOP w0.254: U31.5 168.54,111.14 168.22,110.82 168.22,110.42 167.84,110.03 167.27,110.03 C795.1 167.13,110.17 166.9,110.17 v3(166.31,110.17)
  ART05 w0.254: v3(166.31,110.17) 166.2,110.06 166.07,109.93 165.76,109.93 161.06,114.63 152.81,114.63 152.02,115.42 144.55,115.42 143.76,114.63 143.76,113.98 140.99,111.2 139.46,111.2 138.05,111.2 137.51,111.2 137.19,111.2 136.63,110.64 136.25,110.64 135.77,111.12 135.38,111.12 134.9,110.64 134.49,110.64 134.06,111.07 133.44,111.07 132.58,111.94 132.24,111.94 132.19,111.99 132.1,111.99 131.95,112.14 131.85,112.14 131.43,112.56 131.06,112.56 130.56,112.07 129.11,112.07 129.11,112.06 128.39,112.06 127.97,111.64 127.95,111.64 127.94,111.63 127.71,111.63 127.63,111.56 127.59,111.56 127.22,111.19 127.15,111.19 127.1,111.14 126.8,111.14 126.46,110.8 126.46,110.39 126.57,110.29 126.57,109.9 126.22,109.56 125.86,109.56 125.37,109.07 124.99,109.07 124.51,108.58 124.08,108.58 123.64,108.14 123.26,108.14 123.25,108.15 123.18,108.15 122.77,108.56 122.72,108.56 122.7,108.58 122.45,108.58 121.72,109.32 v2(121.72,109.6)
FPGA_TEST_ALERTN: length 68.9
  TOP w0.109: U17.A3 155.71,146.46 v2(155.55,146.3)
  ART03 w0.114: v2(155.55,146.3) 155.34,146.1 154.29,146.1 152.4,144.21 152.4,139.73 151.28,138.61 148.31,138.61 146.46,136.76 122.23,136.76 113.28,127.81 113.28,119.94 114.32,118.9 114.32,115.43 v2(115.66,114.1)
  BOTTOM w0.109: R274.1 155.45,146.2 v2(155.55,146.3)
FPGA_TEST_SCL: length 65.3
  TOP w0.109: U17.A1 v2(157.33,146.45)
  ART03 w0.114: v2(157.33,146.45) 156.13,145.26 154.68,145.26 153.34,143.92 153.34,139.09 150.06,135.81 150.06,134.59 149.05,133.58 146.99,133.58 144.7,135.86 122.6,135.86 114.48,127.74 114.48,122.28 v2(115.66,121.1)
  BOTTOM w0.109: R272.1 157.99,145.79 v2(157.33,146.45)
FPGA_TEST_SDA: length 61.3
  TOP w0.109: U17.A2 156.21,146.41 v2(156.31,146.3)
  ART03 w0.114: v2(156.31,146.3) 155.69,145.68 154.47,145.68 152.88,144.1 152.88,139.42 151.61,138.15 148.56,138.15 146.73,136.31 122.42,136.31 113.97,127.86 113.97,121.14 v2(113.92,121.1)
  BOTTOM w0.109: v2(156.31,146.3) 156.31,145.89 R273.1
FPGA_TESTI2C_ALERTN: length 11.3
  TOP w0.109: U17.C3 155.71,148.68 v2(155.48,148.91)
  ART05 w0.114: v2(154.21,139.7) 154.21,141.29 154.79,141.86 154.79,146.68 155.29,147.19 155.29,148.72 v2(155.48,148.91)
  BOTTOM w0.109: v2(155.48,148.91) 155.45,148.94 R269.1
FPGA_TESTI2C_SCL: length 13.2
  TOP w0.109: U17.C1 156.71,148.12 157.45,148.87 v2(157.99,148.87)
  ART05 w0.114: v2(157.99,148.87) 157.25,149.61 155.17,149.61 154.79,149.22 154.79,147.57 154.21,147 v2(154.21,142.24)
  BOTTOM w0.109: R271.1 v2(157.99,148.87)
FPGA_TESTI2C_SDA: length 9.5
  TOP w0.109: v2(156.72,148.87) 156.21,148.36 U17.C2
  ART05 w0.114: v2(159.36,144.14) 159.36,145.41 156.72,148.05 v2(156.72,148.87)
  BOTTOM w0.109: J17.1 159.67,143.45 159.53,143.59 159.53,143.97 v2(159.36,144.14) ; R270.1 v2(156.72,148.87)
FPGA_TESTI2C_TSN:
  vias: v2(155.71,147.57)
FPGA_TESTIO0: length 63.3
  ART16 w0.114: v2(139.29,157.73) 139,157.73 137.59,156.32 137.59,155.22 135.1,152.73 135.1,151.55 134.89,151.34 134.89,151.09 135.1,150.89 135.1,150.03 134.99,149.92 134.42,149.92 134.3,149.8 134.3,149.57 134.42,149.46 134.99,149.46 135.1,149.35 135.1,148.58 134.95,148.43 134.95,148.12 135.1,147.97 135.1,147.53 134.89,147.32 134.89,147.07 135.1,146.86 135.1,146.61 134.89,146.41 134.89,146.16 135.1,145.95 135.1,145.7 134.89,145.49 134.89,145.24 135.1,145.03 135.1,144.78 134.89,144.58 134.89,144.33 135.1,144.12 135.1,143.87 134.89,143.66 134.89,143.41 135.1,143.21 135.1,142.47 128.27,135.64 122.27,135.64 115.21,128.57 115.21,114.39 v2(113.92,113.1)
  BOTTOM w0.109: J16.2 v2(139.29,157.73)
FPGA_TESTIO1: length 63.9
  ART16 w0.114: v2(113.92,114.1) 114.4,114.57 114.4,128.6 121.94,136.14 128.01,136.14 133.88,142.01 133.88,153.37 134.21,153.7 135.25,153.7 137.1,155.54 137.1,156.5 138.95,158.36 140.27,158.36 140.89,157.73 v2(141.83,157.73)
  BOTTOM w0.109: J16.4 v2(141.83,157.73)
FPGA_TESTIO2: length 73.4
  ART16 w0.114: v2(113.06,113.6) 113.53,114.07 113.53,128.59 121.59,136.65 127.63,136.65 133.43,142.44 133.43,154.15 134.19,154.92 134.79,154.92 136.12,156.25 136.12,157.05 138.7,159.63 147.21,159.63 147.6,159.23 147.6,158.68 v2(146.91,157.99)
  BOTTOM w0.109: J16.8 v2(146.91,157.99)
FPGA_TESTIO3: length 75.8
  ART16 w0.114: v2(149.45,157.99) 150.01,158.55 150.01,159.36 149.33,160.04 138.42,160.04 134.71,156.34 134.44,156.34 133.93,155.83 133.93,155.3 132.99,154.36 132.99,142.65 127.51,137.16 121.28,137.16 112.92,128.79 112.92,122.36 112.6,122.05 112.6,115.06 v2(113.06,114.6)
  BOTTOM w0.109: J16.10 v2(149.45,157.99)
FPGA_TESTIO4: length 63.4
  ART16 w0.114: v2(139.29,159.14) 140.77,159.14 141.54,158.37 141.91,158.37 142.39,157.89 142.39,157.4 141.96,156.97 140.23,156.97 135.59,152.32 135.59,142.27 128.45,135.13 122.88,135.13 116.56,128.8 116.56,122.35 116.13,121.92 116.13,117.27 116.35,117.04 116.69,117.04 117.39,116.34 v2(117.39,116.1)
  BOTTOM w0.109: J16.1 v2(139.29,159.14)
FPGA_TESTIO5: length 60.3
  ART16 w0.114: v2(117.39,117.1) 116.94,117.55 116.94,121.67 117.62,122.35 117.62,128.68 123.66,134.71 128.82,134.71 133.81,139.7 134.47,139.7 135.43,140.67 135.43,141.48 136.19,142.24 136.19,152.17 140.36,156.34 142.16,156.34 143.15,157.33 143.15,158.09 142.1,159.14 v2(141.83,159.14)
  BOTTOM w0.109: J16.3 v2(141.83,159.14)
FPGA_TESTIO6: length 63.6
  ART16 w0.114: v2(116.52,115.6) 116.54,115.62 117.5,115.62 117.78,115.9 117.78,121.86 118.18,122.27 118.18,123.37 118.92,124.1 118.92,128.82 124.28,134.19 129.03,134.19 133.93,139.09 134.77,139.09 136.02,140.34 136.02,141.12 137.34,142.44 137.34,152.27 140.64,155.57 143.35,155.57 v2(146.91,159.14)
  BOTTOM w0.109: J16.7 v2(146.91,159.14)
FPGA_TESTIO7: length 69
  ART16 w0.114: v2(149.45,159.01) 145.38,154.94 140.82,154.94 138.25,152.37 138.25,141.94 134.87,138.56 134.09,138.56 129.13,133.6 124.64,133.6 119.86,128.83 119.86,124 118.64,122.78 118.64,115.37 118.36,115.09 118.06,115.09 117.68,114.71 116.53,114.71 116.09,115.15 116.09,116.17 v2(116.52,116.6)
  BOTTOM w0.109: J16.9 v2(149.45,159.01)
FPGA_TESTIO8: length 60.8
  ART03 w0.114: v2(153.03,132.05) 156.13,132.05 156.26,131.93 156.26,128.93 156.08,128.75 116.25,128.75 114.96,127.46 114.96,122.86 116.15,121.67 116.15,119.91 114.93,118.69 114.93,118.01 115.18,117.76 115.18,116.58 v2(115.66,116.1)
FPGA_TESTIO9: length 61.5
  ART03 w0.114: v2(157.58,132.08) 156.83,132.08 156.72,131.96 156.72,130.63 156.83,130.52 157.16,130.52 157.27,130.41 157.27,130.18 157.16,130.06 156.83,130.06 156.72,129.95 156.72,129.72 156.83,129.61 157.16,129.61 157.27,129.49 157.27,129.26 157.16,129.15 156.83,129.15 156.72,129.03 156.72,128.37 156.6,128.26 116.44,128.26 115.42,127.23 115.42,123.09 116.66,121.84 116.66,119.84 115.27,118.45 115.27,117.94 115.66,117.55 v2(115.66,117.1)
  BOTTOM w0.109: J17.9 v2(157.58,132.08)
FPGA_TESTIO10: length 60
  ART03 w0.114: v2(161.54,125.35) 160.58,126.31 149.45,126.31 148.44,127.33 140.41,127.33 138.38,125.3 135.94,125.3 135.29,124.65 127.95,124.65 127.04,123.74 123.05,123.74 120.83,121.51 120.55,121.51 120.06,121.03 119.73,121.03 119.23,120.52 118.84,120.52 118.34,120.01 117.96,120.01 116.05,118.11 116.05,113.83 115.88,113.66 115.19,113.66 114.3,114.55 113.74,114.55 113.48,114.81 113.48,116.66 v2(113.92,117.1)
FPGA_TESTIO11: length 59.2
  ART03 w0.114: v2(160.4,125.35) 159.87,125.88 149.2,125.88 148.64,126.44 140.71,126.44 139.85,125.58 139.85,124.21 139.24,123.6 128.19,123.6 127.84,123.24 124.36,123.24 122.68,121.56 122.32,121.56 121.94,121.18 121.66,121.18 121.13,120.65 120.77,120.65 120.24,120.12 119.83,120.12 119.39,119.67 118.98,119.67 118.49,119.18 117.68,119.18 116.91,118.41 116.91,117.44 116.69,117.22 116.69,116.98 116.91,116.76 116.91,116.44 116.81,116.34 116.81,115.86 116.81,115.86 116.91,115.76 116.91,115.44 116.81,115.34 116.81,115.27 116.42,114.88 116.42,113.6 116.02,113.21 114.75,113.21 114.37,113.59 113.79,113.59 113.31,114.07 113.03,114.07 112.6,114.5 112.6,115.14 v2(113.06,115.6)
FPGA_TESTIO12: length 63.8
  ART03 w0.114: v2(159.33,125.35) 158.01,124.03 158.01,123.49 157.25,122.73 156.13,122.73 154.94,123.93 154.94,124.59 154.18,125.35 148.59,125.35 148.03,125.91 141.07,125.91 140.48,125.32 140.48,124.05 139.57,123.14 129.56,123.14 128.72,122.3 128.14,122.3 127.78,122.66 125.47,122.66 124.36,121.54 124.03,121.54 123.52,121.03 123.19,121.03 122.68,120.52 122.32,120.52 121.84,120.04 121.49,120.04 121,119.56 120.6,119.56 120.11,119.07 119.81,119.07 119.33,118.59 118.97,118.59 118.49,118.11 118.03,118.11 117.52,117.6 117.26,117.6 117.1,117.44 117.1,117.36 116.94,117.2 116.94,117 117.11,116.83 117.11,116.37 117,116.26 117,115.94 117.12,115.82 117.12,115.38 117,115.26 117,115.19 116.74,114.92 116.74,113.46 115.87,112.6 115.47,112.6 115.02,112.15 114.56,112.15 114.04,112.67 113.76,112.67 113.31,113.13 112.95,113.13 112.47,113.61 112.06,113.61 111.76,113.92 111.76,115.29 112.16,115.7 112.39,115.7 113.06,116.36 v2(113.06,116.6)
FPGA_VREFN_ADC: length 26.2
  ART03 w0.254: v2(158.92,80.85) 157.35,82.42 152.6,82.42 149.93,85.09 149.93,86.46 145.64,90.75 140.61,90.75 139.55,91.82 138.45,91.82 v2(138.17,92.1)
FPGA_VREFP_ADC: length 25
  ART03 w0.254: v2(138.17,91.1) 138.45,91.37 139.36,91.37 141.12,89.61 146.15,89.61 149.48,86.29 149.48,84.91 152.42,81.98 157.04,81.98 157.52,81.49 v2(157.52,80.85)
FPGA_VSIGN_0: length 154.7
  ART16 w0.114: v2(173.96,140.59) 173.46,140.08 173.46,130.77 175.5,128.72 178.03,128.72 179.9,126.85 181.35,126.85 182.37,125.83 184.96,125.83 186.18,124.61 189.09,124.61 189.2,124.71 189.21,124.71 189.23,124.74 189.71,124.74 189.85,124.6 189.85,122.13 190.48,121.49 191.01,121.49 193.75,118.75 193.88,118.75 194.68,117.94 194.68,78.23 191.64,75.19 187.93,75.19 187.91,75.16 185.2,75.16 181.37,78.99 164.02,78.99 160.25,75.22 140.2,75.22 139.6,75.82 139.6,88.67 v2(138.17,90.1)
  BOTTOM w0.114: J49.3 172.63,140.47 172.74,140.59 v2(173.96,140.59)
FPGA_VSIGN_1: length 144.3
  ART16 w0.114: v2(174.85,131.95) 175.3,131.5 175.3,130.81 176.76,129.35 178.34,129.35 178.92,128.78 180.77,128.78 183,126.54 185.16,126.54 185.72,125.99 188.4,125.99 189.01,125.38 189.94,125.38 189.94,125.37 190.1,125.37 190.68,124.79 190.68,123.61 191.34,122.95 191.34,122.61 193.23,120.72 193.81,120.72 194.89,119.63 194.89,118.6 195.3,118.2 195.3,77.67 194.89,77.27 194.89,76.46 192.93,74.5 184.81,74.5 181.08,78.23 164.65,78.23 161.03,74.61 139.88,74.61 138.91,75.58 138.91,86.36 v2(138.17,87.1)
  BOTTOM w0.114: J49.9 v2(174.85,131.95)
FPGA_VSIGP_0: length 156.1
  ART16 w0.114: v2(174.72,142.11) 174.72,140.15 173.91,139.34 173.91,130.99 175.87,129.03 178.15,129.03 179.93,127.25 181.45,127.25 182.5,126.21 185.01,126.21 186.28,124.94 188.99,124.94 189.12,125.07 189.81,125.07 190.2,124.69 190.2,122.21 190.61,121.8 191.14,121.8 193.88,119.06 194,119.06 194.99,118.07 194.99,77.8 192,74.8 184.94,74.8 181.13,78.61 164.25,78.61 160.55,74.91 140.04,74.91 139.29,75.67 139.29,87.98 v2(138.17,89.1)
  BOTTOM w0.114: J49.1 v2(174.72,142.11)
FPGA_VSIGP_1: length 146.3
  ART16 w0.114: v2(174.85,134.49) 175.91,133.43 175.91,131.07 177.29,129.69 178.44,129.69 179.04,129.09 180.88,129.09 183.08,126.9 185.24,126.9 185.85,126.29 188.53,126.29 189.04,125.78 190.13,125.78 190.98,124.92 190.98,123.75 191.67,123.06 191.67,122.82 193.46,121.02 194.09,121.02 195.2,119.91 195.2,119.76 195.2,119.76 195.2,118.73 195.61,118.32 195.61,77.54 195.2,77.14 195.2,76.33 195.2,76.33 195.2,76.23 193.09,74.12 184.76,74.12 181.56,77.32 164.35,77.32 161.33,74.3 139.64,74.3 138.58,75.36 138.58,85.69 v2(138.17,86.1)
  BOTTOM w0.114: J49.7 v2(174.85,134.49)
FX2_DN: length 13.4
  TOP w0.097: CN1.2 11.64,174.57 10.8,175.42 10.8,175.55 11.16,175.92 12.14,175.92 12.29,175.77 12.52,175.77 12.67,175.92 13.03,175.92 13.18,175.77 13.41,175.77 13.56,175.92 14.97,175.92 v3(15.27,175.62) 15.56,175.92 19.6,175.92 19.74,175.78 U21.9
  BOTTOM w0.097: v3(15.27,175.62) 15.56,175.92 16.03,175.92 16.18,175.76 U20.2
FX2_DP: length 13.3
  TOP w0.097: CN1.3 9.73,174.57 10.57,175.42 10.57,175.65 11.07,176.15 14.97,176.15 v3(15.27,176.45) 15.56,176.15 19.61,176.15 19.74,176.28 U21.8
  BOTTOM w0.097: U20.3 16.18,176.26 16.08,176.15 15.56,176.15 v3(15.27,176.45)
FX2_FLAGA: length 20
  TOP w0.109: U23.E17 v2(34.73,179.12) ; v3(29.71,173.81) 29.18,173.28 U21.29
  ART18 w0.114: v3(29.71,173.81) 29.71,174.1 29.6,174.22 29.26,174.22 29.13,174.35 29.13,175.15 29.25,175.26 30.09,175.26 30.2,175.37 30.2,176.19 30.09,176.3 29.36,176.3 29.24,176.43 29.24,177.17 29.38,177.31 30.44,177.31 30.61,177.14 30.61,174.95 30.72,174.84 30.91,174.84 31.06,174.99 31.06,178.53 31.25,178.71 34.62,178.71 34.73,178.83 v2(34.73,179.12)
FX2_FLAGB: length 20.5
  TOP w0.109: v3(28.78,173.84) 28.72,173.78 U21.30 ; U23.D18 v2(33.94,179.92)
  ART18 w0.114: v3(28.78,173.84) 28.78,173.62 28.67,173.51 27.74,173.51 27.58,173.66 27.58,173.9 27.7,174.02 28.08,174.02 28.19,174.13 28.19,174.36 28.08,174.47 27.7,174.47 27.58,174.59 27.58,174.82 27.7,174.93 28.08,174.93 28.19,175.04 28.19,175.27 28.08,175.39 27.7,175.39 27.58,175.5 27.58,175.73 27.7,175.84 28.08,175.84 28.19,175.96 28.19,176.19 28.08,176.3 27.7,176.3 27.58,176.42 27.58,176.64 27.7,176.76 28.08,176.76 28.19,176.87 28.19,177.1 28.08,177.22 27.7,177.22 27.58,177.33 27.58,177.65 28.22,178.28 30.23,178.28 31.45,179.5 34.95,179.5 35.08,179.63 35.08,179.84 34.96,179.96 33.98,179.96 v2(33.94,179.92)
FX2_FLAGC: length 23.6
  TOP w0.109: U23.G12 v2(36.33,175.12) ; v3(29.72,174.78) 29.22,174.28 U21.31
  ART05 w0.114: v2(36.33,175.12) 36.08,175.12 35.97,175.01 35.97,174.1 35.85,173.99 35.69,173.99 35.56,174.12 35.56,175.04 35.45,175.16 35.24,175.16 35.13,175.04 35.13,172.87 35,172.75 34.47,172.75 34.34,172.87 34.34,175.08 34.18,175.23 33.87,175.23 33.76,175.12 33.76,174.69 33.65,174.57 33.42,174.57 33.3,174.69 33.3,175.12 33.19,175.23 32.91,175.23 32.79,175.12 32.79,174.29 32.91,174.18 33.52,174.18 33.63,174.06 33.63,173.84 33.52,173.72 32.91,173.72 32.79,173.61 32.79,173.15 32.71,173.07 32.03,173.07 31.93,173.18 31.93,173.84 32.31,174.22 32.31,175.12 32.19,175.23 32,175.23 31.88,175.11 31.88,174.83 31.78,174.73 31.55,174.73 31.45,174.83 31.45,175.01 31.36,175.09 30.98,175.09 30.75,174.87 29.8,174.87 v3(29.72,174.78)
FX2_PA0: length 26.9
  TOP w0.109: v3(29.72,175.77) 29.23,175.28 U21.33 ; U23.L18 v2(40.34,179.92)
  ART05 w0.114: v2(40.34,179.92) 40.03,180.23 40.03,180.48 40.22,180.67 40.63,180.67 40.75,180.56 40.75,178.04 40.87,177.93 41.37,177.93 41.53,177.77 41.53,174.88 41.37,174.73 39.34,174.73 39.23,174.61 39.23,174.41 39.11,174.29 38.88,174.29 38.77,174.41 38.77,174.61 38.66,174.73 38.41,174.73 38.3,174.84 38.3,176.21 38.18,176.33 33.67,176.33 33.53,176.47 33.53,176.77 33.41,176.88 33.19,176.88 33.07,176.77 33.07,176.47 32.96,176.35 32.73,176.35 32.61,176.47 32.61,176.97 32.5,177.09 32.27,177.09 32.16,176.97 32.16,176.1 32.04,175.99 31.64,175.99 31.48,176.15 30.83,176.15 30.45,175.77 v3(29.72,175.77)
FX2_PA1: length 23.9
  TOP w0.109: U23.M17 v2(41.14,179.12) ; U21.34 v3(28.79,175.78)
  ART05 w0.114: v3(28.79,175.78) 29.28,175.28 30.58,175.28 30.82,175.53 31.86,175.53 31.88,175.54 34.31,175.54 34.33,175.53 37.37,175.53 37.54,175.36 37.54,174.11 37.69,173.96 37.79,173.96 37.8,173.96 41.78,173.96 41.78,173.95 42.08,173.95 42.08,173.96 42.14,173.96 42.34,174.16 42.34,177.64 42.37,177.67 42.37,177.79 42.49,177.91 43.04,177.91 43.15,178.02 43.15,178.25 43.04,178.36 42.49,178.36 42.37,178.48 42.37,178.55 42.22,178.7 41.55,178.7 v2(41.14,179.12)
FX2_PA2: length 27.1
  TOP w0.109: U21.35 29.25,176.28 v3(29.75,176.78) ; U23.K17 v2(39.54,179.12)
  ART05 w0.114: v2(39.54,179.12) 39.24,179.41 38.76,179.41 38.66,179.31 38.66,178.41 38.17,177.93 34.59,177.93 34.36,178.15 34.36,179.63 34.74,180.01 34.74,180.29 34.63,180.41 33,180.41 32.89,180.52 32.89,180.81 33,180.92 34.97,180.92 35.1,181.06 35.1,181.34 34.99,181.46 32.43,181.46 32.32,181.34 32.32,180.5 32.87,179.96 33.19,179.96 33.3,179.84 33.3,179.62 33.19,179.5 32.13,179.5 31.9,179.27 31.9,178.84 31.66,178.61 31.66,178.44 31.77,178.34 31.77,178.18 31.61,178.02 31.45,178.02 31.34,178.12 31.18,178.12 30.78,177.72 30.78,177.32 30.23,176.78 v3(29.75,176.78)
FX2_PA3: length 25.2
  TOP w0.109: U21.36 v3(28.77,176.78) ; U23.L17 v2(40.34,179.12)
  ART05 w0.114: v3(28.77,176.78) 29.28,176.28 30.35,176.28 31.22,177.14 31.66,177.14 31.68,177.16 31.68,177.16 31.9,177.37 31.9,177.67 32.12,177.89 32.46,177.89 32.73,178.16 32.73,178.57 32.84,178.69 33.4,178.69 33.55,178.54 33.55,177.2 33.67,177.09 38.2,177.09 38.73,176.56 39.02,176.56 39.14,176.44 39.14,176.21 39.02,176.1 38.8,176.1 38.68,175.99 38.68,175.65 38.8,175.54 40.64,175.54 40.74,175.64 40.74,176.95 40.56,177.13 38.81,177.13 38.55,177.39 38.55,177.61 38.67,177.73 39.84,177.73 39.95,177.84 39.95,178.74 v2(40.34,179.12)
FX2_PA4: length 27
  TOP w0.109: U23.J18 v2(37.93,179.92) ; v3(29.72,177.77) 29.22,177.28 U21.37
  ART05 w0.114: v3(29.72,177.77) 29.76,177.82 29.76,177.95 30.99,179.18 30.99,182.47 31.1,182.58 31.58,182.58 31.7,182.7 31.7,182.93 31.58,183.04 31.1,183.04 30.99,183.15 30.99,183.37 31.1,183.49 33.81,183.49 33.92,183.6 33.92,184.11 34.04,184.23 34.27,184.23 34.38,184.11 34.38,183.6 34.5,183.49 34.73,183.49 34.84,183.6 34.84,184.11 34.95,184.23 35.18,184.23 35.3,184.11 35.3,183.6 35.41,183.49 35.64,183.49 35.75,183.6 35.75,184.11 35.87,184.23 36.1,184.23 36.21,184.11 36.21,183.6 36.33,183.49 36.4,183.49 36.52,183.37 36.52,183.09 36.4,182.97 35.95,182.97 35.84,182.86 35.84,182.63 35.95,182.51 36.34,182.51 36.45,182.4 36.45,181.55 36.57,181.43 36.76,181.43 36.88,181.32 36.88,181.09 36.76,180.97 36.57,180.97 36.45,180.86 36.45,180.83 35.79,180.16 35.79,179.73 35.99,179.53 37.54,179.53 v2(37.93,179.92)
FX2_PA5: length 27.2
  TOP w0.109: U23.K18 v2(39.54,179.92) ; U21.38 v3(28.77,177.78)
  ART05 w0.114: v3(28.77,177.78) 29.24,177.31 29.91,177.31 30.18,177.58 30.18,177.73 31.46,179.01 31.46,179.33 31.9,179.77 31.9,179.78 31.9,179.78 31.9,180.37 31.79,180.49 31.58,180.49 31.47,180.6 31.47,180.83 31.58,180.94 31.79,180.94 31.9,181.06 31.9,181.29 31.79,181.4 31.58,181.4 31.47,181.52 31.47,181.74 31.58,181.86 31.79,181.86 31.9,181.97 31.9,182.23 32.13,182.46 32.13,182.89 32.24,183.01 32.47,183.01 32.59,182.89 32.59,182.46 32.7,182.35 32.93,182.35 33.04,182.46 33.04,182.89 33.16,183.01 33.39,183.01 33.5,182.89 33.5,182.46 33.61,182.35 33.84,182.35 33.96,182.46 33.96,182.89 34.07,183.01 34.3,183.01 34.41,182.89 34.41,182.46 34.53,182.35 34.76,182.35 34.87,182.46 34.87,182.89 34.99,183.01 35.21,183.01 35.33,182.89 35.33,182.46 35.44,182.35 35.47,182.35 35.58,182.23 35.58,181.5 35.7,181.38 35.87,181.38 35.99,181.27 35.99,181.04 35.87,180.92 35.7,180.92 35.58,180.81 35.58,180.64 35.18,180.24 35.18,178.79 35.25,178.71 38.21,178.71 38.33,178.83 38.33,179.75 38.49,179.92 v2(39.54,179.92)
FX2_PA6: length 26.9
  TOP w0.109: U23.G18 v2(36.33,179.92) ; v3(29.75,178.78) 29.25,178.28 U21.39
  ART05 w0.114: v3(29.75,178.78) 30.28,179.3 30.57,179.59 30.57,180.02 30.27,180.31 30.27,181.07 30.39,181.19 30.44,181.19 30.55,181.3 30.55,181.53 30.44,181.64 30.39,181.64 30.27,181.76 30.27,181.99 30.39,182.1 30.44,182.1 30.55,182.22 30.55,182.44 30.44,182.56 30.39,182.56 30.27,182.67 30.27,182.9 30.39,183.02 30.44,183.02 30.55,183.13 30.55,183.36 30.44,183.47 30.39,183.47 30.27,183.59 30.27,183.88 30.39,183.99 33.16,183.99 33.83,184.66 36.87,184.66 36.98,184.54 36.98,184.05 37.09,183.93 38.75,183.93 38.86,183.82 38.86,183.59 38.75,183.48 37.09,183.48 36.98,183.36 36.98,183.13 37.09,183.02 38.21,183.02 38.33,182.9 38.33,182.68 38.21,182.56 37.28,182.56 37.17,182.45 37.17,182.29 37.34,182.11 37.34,180.93 v2(36.33,179.92)
FX2_PA7: length 27.3
  TOP w0.109: U23.H18 v2(37.13,179.92) ; U21.40 v3(28.77,178.78)
  ART05 w0.114: v2(37.13,179.92) 37.42,180.2 37.5,180.2 38.23,180.93 38.23,181.95 38.61,182.32 39.23,182.32 39.34,182.43 39.34,182.65 39.23,182.76 39.1,182.76 38.99,182.88 38.99,183.11 39.1,183.22 39.23,183.22 39.34,183.33 39.34,184.42 39.23,184.53 37.61,184.53 37.06,185.09 33.6,185.09 32.92,184.41 31.91,184.41 31.8,184.52 31.8,184.59 31.68,184.71 31.45,184.71 31.34,184.59 31.34,184.52 31.23,184.41 31,184.41 30.88,184.52 30.88,185 30.77,185.11 30.54,185.11 30.42,185 30.42,184.52 30.31,184.41 30.05,184.41 29.85,184.21 29.85,183.84 29.73,183.73 29.63,183.73 29.51,183.61 29.51,183.39 29.63,183.27 29.73,183.27 29.85,183.16 29.85,182.93 29.73,182.81 29.63,182.81 29.51,182.7 29.51,182.47 29.63,182.36 29.73,182.36 29.85,182.24 29.85,182.01 29.73,181.9 29.63,181.9 29.51,181.79 29.51,181.56 29.63,181.44 29.73,181.44 29.85,181.33 29.85,180.49 29.62,180.26 29.62,179.62 29.48,179.48 29.32,179.48 29.06,179.75 28.89,179.75 28.73,179.58 28.73,179.42 29,179.16 29,179 v3(28.77,178.78)
FX2_PB0: length 24.9
  TOP w0.109: U23.G17 v2(36.33,179.12) ; U21.18 22.3,171.3 v3(22.8,170.8)
  ART18 w0.114: v2(36.33,179.12) 36.33,179.29 35.26,180.36 31.37,180.36 30.28,179.27 28.5,179.27 27.1,177.88 27.1,173.57 26.99,173.46 26.24,173.46 25.73,172.95 22.78,172.95 22.34,172.5 22.34,171.27 v3(22.8,170.8)
FX2_PB1: length 22.5
  TOP w0.109: U21.19 22.8,171.8 v3(22.8,171.8) ; U23.H17 v2(37.13,179.12)
  ART18 w0.114: v2(37.13,179.12) 36.9,179.12 36.5,178.71 35.33,178.71 35.13,178.51 35.13,178.05 35,177.93 33.78,177.93 33.55,177.7 33.55,176.89 33.49,176.82 33.33,176.82 32.95,177.19 32.79,177.19 32.63,177.03 32.63,176.87 33,176.5 33,176.34 32.84,176.17 32.68,176.17 32.31,176.55 32.15,176.55 31.98,176.38 31.98,176.22 32.36,175.85 32.36,175.69 32.19,175.53 32.03,175.53 31.9,175.66 31.74,175.66 31.58,175.5 31.58,175.33 31.71,175.2 31.71,175.04 29.7,173.04 26.44,173.04 25.87,172.47 23.46,172.47 v3(22.8,171.8)
FX2_PB2: length 24
  TOP w0.109: v3(23.8,170.8) 23.3,171.3 U21.20 ; U23.J12 v2(37.93,175.12)
  ART18 w0.114: v3(23.8,170.8) 23.8,169.8 24.23,169.37 24.58,169.37 24.69,169.25 24.69,169.15 24.81,169.04 25.04,169.04 25.15,169.15 25.15,169.25 25.27,169.37 25.49,169.37 25.61,169.25 25.61,169.15 25.72,169.04 25.95,169.04 26.07,169.15 26.07,169.25 26.18,169.37 26.41,169.37 26.52,169.25 26.52,169.15 26.64,169.04 26.87,169.04 26.98,169.15 26.98,169.25 27.09,169.37 27.32,169.37 27.44,169.25 27.44,169.15 27.55,169.04 27.78,169.04 27.89,169.15 27.89,169.25 28.01,169.37 28.42,169.37 29.28,168.5 30.16,168.5 30.28,168.62 30.73,168.62 31.19,169.09 31.19,169.37 32.51,170.69 34.08,170.69 34.34,170.94 34.34,171.28 34.57,171.51 34.91,171.51 35.15,171.75 35.15,172.17 35.27,172.29 36.45,172.29 37.56,173.4 37.56,174.47 37.93,174.84 v2(37.93,175.12)
FX2_PB3: length 24.9
  TOP w0.109: v3(23.8,171.8) 23.8,171.8 U21.21 ; v2(37.93,174.32) U23.J11
  ART18 w0.114: v3(23.8,171.8) 23.29,171.29 23.29,169.71 24.49,168.51 28.54,168.51 29.03,168.02 29.51,168.02 29.73,167.8 30.74,167.8 31.57,168.63 31.57,169.26 31.97,169.67 31.97,169.67 32.18,169.88 32.19,169.88 32.21,169.9 34.14,169.9 34.34,170.1 34.34,170.44 34.58,170.68 34.59,170.68 34.63,170.73 36.61,170.73 36.75,170.86 36.75,172.1 37,172.34 38.34,172.34 38.45,172.45 38.45,173.8 v2(37.93,174.32)
FX2_PB4: length 24
  TOP w0.109: v3(24.8,170.8) 24.3,171.3 U21.22 ; U23.H15 v2(37.13,177.52)
  ART18 w0.114: v2(37.13,177.52) 37.13,177.29 36.75,176.91 36.75,175.74 36.52,175.51 36.19,175.51 35.91,175.23 35.91,174.14 35.65,173.88 34.58,173.88 34.37,173.67 34.37,173.34 34.13,173.09 34.13,172.93 34.31,172.75 34.31,172.59 34.15,172.43 33.99,172.43 33.75,172.66 33.59,172.66 33.32,172.39 33.04,172.39 32.48,171.83 31.67,171.83 30.93,171.09 30.93,170.42 30.82,170.3 30.52,170.3 30.4,170.42 30.4,170.81 30.29,170.93 29.96,170.93 29.84,170.81 29.84,170.37 29.73,170.26 29.38,170.26 29.26,170.37 29.26,170.78 29.15,170.89 28.92,170.89 28.81,170.78 28.81,170.37 28.69,170.26 28.46,170.26 28.35,170.37 28.35,170.78 28.23,170.89 28.01,170.89 27.89,170.78 27.89,170.37 27.78,170.26 25.6,170.26 25.05,170.8 v3(24.8,170.8)
FX2_PB5: length 23.5
  TOP w0.109: U23.J15 v2(37.93,177.52) ; v3(24.8,171.8) 24.8,171.8 U21.23
  ART18 w0.114: v3(24.8,171.8) 24.28,171.28 24.28,169.94 24.39,169.82 24.57,169.82 24.68,169.94 24.68,170.14 24.8,170.26 25.01,170.26 25.14,170.12 25.14,169.94 25.25,169.82 30.99,169.82 32.69,171.53 34.14,171.53 34.34,171.73 34.34,172.08 34.87,172.62 34.87,172.74 34.73,172.89 34.73,173.01 34.86,173.14 34.98,173.14 35.15,172.97 35.28,172.97 35.38,173.07 35.84,173.07 35.96,173.2 35.96,173.71 36.14,173.89 36.47,173.89 36.7,174.12 36.7,175.23 36.95,175.49 37.26,175.49 37.56,175.79 37.56,177.15 v2(37.93,177.52)
FX2_PB6: length 23.7
  TOP w0.109: U23.H16 v2(37.13,178.32) ; U21.24 25.3,171.3 v3(25.8,170.8)
  ART18 w0.114: v2(37.13,178.32) 37.13,178.08 36.75,177.7 36.75,177.37 36.52,177.14 36.22,177.14 35.91,176.83 35.91,175.67 35.72,175.47 35.39,175.47 35.15,175.24 35.15,174.83 35.01,174.68 34.58,174.68 34.58,174.68 34.52,174.68 34.34,174.5 34.34,174.2 34.01,173.88 33.41,173.88 33.1,173.56 33.1,173.4 33.37,173.13 33.37,172.97 33.21,172.81 33.05,172.81 32.78,173.08 32.61,173.08 32.45,172.92 32.45,172.75 32.62,172.59 32.62,172.42 32.46,172.26 32.3,172.26 32.13,172.43 31.97,172.43 31.7,172.16 30.68,172.16 30.56,172.05 30.56,171.46 30.45,171.35 30.22,171.35 30.1,171.46 30.1,172.05 29.99,172.16 29.76,172.16 29.65,172.05 29.65,171.46 29.53,171.35 29.3,171.35 29.19,171.46 29.19,172.05 29.08,172.16 28.67,172.16 27.81,171.3 27.29,171.3 27.17,171.18 27.17,170.83 27.06,170.71 26.83,170.71 26.72,170.83 26.72,171.18 26.6,171.3 26.29,171.3 v3(25.8,170.8)
FX2_PB7: length 23.6
  TOP w0.109: v3(25.8,171.8) 25.8,171.8 U21.25 ; U23.J16 v2(37.93,178.32)
  ART18 w0.114: v3(25.8,171.8) 26.61,172.62 30.05,172.62 30.16,172.73 30.16,172.91 30.31,173.05 30.58,173.05 30.7,172.93 30.7,172.73 30.81,172.62 31.04,172.62 31.15,172.73 31.15,172.93 31.27,173.05 31.72,173.05 31.95,173.28 31.95,174.14 32.07,174.26 32.24,174.26 32.68,173.82 32.84,173.82 33.01,173.98 33.01,174.14 32.28,174.87 32.28,175.03 32.44,175.19 32.6,175.19 33.33,174.46 33.49,174.46 33.65,174.62 33.65,174.79 33.21,175.23 33.21,175.4 33.37,175.56 33.53,175.56 33.98,175.11 34.14,175.11 34.3,175.27 34.3,175.43 33.85,175.88 33.85,176.04 34.11,176.3 34.97,176.3 35.15,176.48 35.15,176.86 35.41,177.11 35.74,177.11 35.91,177.29 35.91,177.75 36.12,177.95 36.52,177.95 36.75,178.18 36.75,178.48 36.98,178.71 37.54,178.71 v2(37.93,178.32)
FX2_PD0: length 31.4
  TOP w0.109: v2(25.8,183.04) 26.17,182.67 26.17,182.63 26.22,182.58 26.22,181.06 26.3,180.97 U21.45
  ART05 w0.114: v2(25.8,183.04) 26.26,182.12 26.26,181.58 25.99,181.01 25.16,179.44 25.16,179.42 25.16,173.82 25.34,172.21 25.34,171.09 25.17,169.8 v3(18.69,157.04)
  BOTTOM w0.109: R304.2 v3(18.69,157.04)
FX2_PD1: length 26.7
  TOP w0.109: v2(25.8,181.89) 25.8,181.89 U21.46
  ART05 w0.114: v3(18.03,161.61) 18.03,163.93 20.39,166.29 20.39,179.32 22.1,181.02 25.04,181.02 25.27,181.09 25.59,181.41 v2(25.8,181.89)
FX2_PD2: length 27.7
  TOP w0.109: v2(24.8,183.04) 25.3,182.54 U21.47
  ART05 w0.114: v2(24.8,183.04) 25.25,182.22 25.25,181.69 25.04,181.48 22.63,181.48 22.22,181.89 20.25,181.89 19.57,181.21 19.57,179.76 19.81,179.52 19.81,178.43 19.59,178.22 19.59,175.31 19.57,175.3 19.57,170.69 19.42,170.54 19.42,167.91 v3(17.57,166.06)
  BOTTOM w0.109: v3(17.57,166.06) 17.88,166.06 18.03,166.22 R305.2
FX2_PD3: length 32.7
  TOP w0.109: v2(24.8,181.89) 24.8,181.89 U21.48
  ART05 w0.114: v2(24.8,181.89) 24.29,182.4 20.04,182.4 18.91,181.27 18.91,179.82 18.66,179.57 18.66,178.49 18.56,178.38 18.56,171.74 18.36,171.54 18.36,171.16 18.56,170.96 18.56,169.62 16.05,167.11 16.05,160.46 v3(17.32,159.19)
  BOTTOM w0.109: R306.2 v3(17.32,159.19)
FX2_PD4: length 27.7
  TOP w0.109: U21.49 24.3,182.54 v2(23.8,183.04) ; U23.G15 v2(36.33,177.52)
  ART03 w0.114: v2(23.8,183.04) 24.22,183.46 26.26,183.46 27.4,184.61 28.2,184.61 28.32,184.49 28.32,184.24 28.43,184.12 28.66,184.12 28.77,184.24 28.77,184.49 28.89,184.61 29.12,184.61 29.23,184.49 29.23,184.24 29.34,184.12 29.57,184.12 29.69,184.24 29.69,184.49 29.8,184.61 30.03,184.61 30.14,184.49 30.14,184.24 30.26,184.12 30.49,184.12 30.6,184.24 30.6,184.49 30.72,184.61 31.01,184.61 31.48,184.14 31.81,184.14 31.93,184.25 31.93,184.44 32.04,184.56 32.27,184.56 32.38,184.44 32.38,184.25 32.5,184.14 32.73,184.14 32.84,184.25 32.84,184.44 32.96,184.56 33.18,184.56 33.3,184.44 33.3,184.25 33.41,184.14 33.64,184.14 33.76,184.25 33.76,184.44 33.87,184.56 34.1,184.56 34.21,184.44 34.21,184.25 34.33,184.14 34.99,184.14 36.52,182.6 36.52,181.36 37.54,180.34 37.54,178.15 37.31,177.93 36.73,177.93 36.33,177.53 v2(36.33,177.52)
FX2_PD5: length 27.9
  TOP w0.109: v2(23.8,181.89) 23.8,181.89 U21.50 ; U23.F15 v2(35.54,177.52)
  ART03 w0.114: v2(35.54,177.52) 35.94,177.92 35.94,180.18 35.4,180.72 35.24,180.72 35.06,180.54 34.9,180.54 34.74,180.7 34.74,180.87 34.92,181.05 34.92,181.21 34.74,181.39 34.74,182.59 34.62,182.7 33.95,182.7 33.83,182.59 33.83,182.21 33.72,182.09 33.49,182.09 33.37,182.21 33.37,182.59 33.26,182.7 32.7,182.7 32.59,182.59 32.59,182.13 32.47,182.02 32.25,182.02 32.13,182.13 32.13,182.59 32.02,182.7 31.79,182.7 31.67,182.59 31.67,182.13 31.56,182.02 31.33,182.02 31.22,182.13 31.22,182.59 31.1,182.7 30.87,182.7 30.76,182.59 30.76,182.13 30.65,182.02 30.42,182.02 30.3,182.13 30.3,182.59 30.19,182.7 29.96,182.7 29.85,182.59 29.85,182.13 29.73,182.02 29.5,182.02 29.39,182.13 29.39,182.59 29.27,182.7 28.92,182.7 28.81,182.59 28.81,181.88 28.7,181.76 28.47,181.76 28.35,181.88 28.35,182.59 28.24,182.7 27.23,182.7 26.51,181.99 26.51,181.83 26.68,181.66 26.68,181.49 26.52,181.33 26.36,181.33 26.19,181.5 26.03,181.5 25.84,181.32 24.37,181.32 v2(23.8,181.89)
