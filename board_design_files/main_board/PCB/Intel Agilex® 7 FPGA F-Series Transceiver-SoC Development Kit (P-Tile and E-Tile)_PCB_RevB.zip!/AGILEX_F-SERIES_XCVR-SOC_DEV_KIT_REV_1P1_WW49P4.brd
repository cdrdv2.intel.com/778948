# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MEM_DMAN2: length 66.8
  TOP w0.109: v2(143.57,52.12) CON1.54
  ART05 w0.114: v2(143.57,52.12) 144.67,53.23 146.52,53.23 146.64,53.34 146.64,57.71 146.52,57.82 144.1,57.82 143.94,57.98 143.94,58.23 144.06,58.34 146.45,58.34 146.57,58.45 146.57,58.68 146.45,58.8 144.06,58.8 143.94,58.91 143.94,59.21 144.06,59.33 146.3,59.33 146.44,59.47 146.44,59.73 146.3,59.87 144.9,59.87 144.77,59.99 144.77,61.54 144.62,61.69 143.09,61.69 142.97,61.81 142.97,62.04 143.09,62.15 144.29,62.15 144.41,62.26 144.41,62.85 144.56,63.01 144.56,64.23 144.01,64.78 142.66,64.78 140.74,66.7 140.32,66.7 137.86,69.15 137.86,71.89 136.57,73.18 136.57,77.95 133.47,81.05 arc(133.47,81.21) 133.41,81.35 arc(133.34,81.6) 133.41,81.85 133.41,81.85 arc(133.48,82.1) 133.41,82.35 arc(133.34,82.6) 133.41,82.85 133.41,82.85 arc(133.48,83.1) 133.41,83.35 arc(133.34,83.6) 133.41,83.85 arc(133.48,84.1) 133.41,84.35 133.41,84.35 arc(133.23,84.53) 132.98,84.6 arc(132.73,84.67) 132.55,84.85 132.54,84.85 arc(132.36,85.03) 132.11,85.1 132.11,85.1 arc(131.86,85.17) 131.68,85.35 131.68,85.35 arc(131.49,85.53) 131.25,85.6 131.24,85.6 arc(130.99,85.67) 130.81,85.85 130.81,85.85 arc(130.63,86.03) 130.38,86.1 130.38,86.1 arc(130.13,86.17) 129.95,86.35 129.94,86.35 arc(129.76,86.53) 129.51,86.6 129.51,86.6 arc(129.26,86.67) 129.08,86.85 129.08,86.85 arc(128.65,87.1) 128.22,86.85 128.21,86.85 arc(128.03,86.67) 127.78,86.6 127.78,86.6 arc(127.53,86.53) 127.35,86.35 127.35,86.35 arc(127.16,86.17) 126.92,86.1 126.91,86.1 arc(126.66,86.03) 126.48,85.85 126.48,85.85 arc(126.3,85.67) 126.05,85.6 arc(125.8,85.53) 125.62,85.35 125.62,85.35 arc(125.55,85.1) 125.62,84.85 v2(126.05,84.1)
MEM_DMAN3: length 64.4
  TOP w0.109: v2(138.4,62.71) 138.32,62.63 CON1.75
  ART05 w0.114: v2(138.4,62.71) 138.4,61.46 138.26,61.32 137.4,61.32 137.17,61.55 137.17,64.6 136.94,64.84 133.95,64.84 133.84,64.72 133.84,64.45 133.72,64.33 133.49,64.33 133.38,64.45 133.38,64.72 133.27,64.84 133.04,64.84 132.92,64.72 132.92,64.45 132.81,64.33 132.58,64.33 132.47,64.45 132.47,64.72 132.35,64.84 132.11,64.84 131.97,64.69 131.97,63.64 132.23,63.37 132.23,62.3 132.35,62.19 133.54,62.19 133.68,62.05 133.68,61.83 133.58,61.73 132.38,61.73 132.27,61.61 132.27,61.35 132.38,61.23 132.64,61.23 132.75,61.12 132.75,59.93 132.61,59.79 132.49,59.79 132.49,59.78 130.77,59.78 130.66,59.67 130.66,59.44 130.79,59.31 132.22,59.31 132.33,59.19 132.33,58.96 132.22,58.85 130.74,58.85 130.63,58.73 130.63,58.45 130.76,58.31 134.08,58.31 134.2,58.19 134.2,57.93 134.1,57.83 130.37,57.83 130.21,57.99 130.21,59.83 129.55,60.48 129.55,61.09 129.36,61.28 128.76,61.28 128.64,61.4 128.64,61.63 128.76,61.74 129.44,61.74 129.55,61.85 129.55,63.86 128.64,64.78 126.56,64.78 126.3,65.04 126.3,73.43 127.12,74.25 127.12,78.91 126.21,79.82 126.21,80.94 v2(126.05,81.1)
MEM_DMBN0: length 72.4
  TOP w0.109: v2(110.57,52.12) CON1.178
  ART05 w0.114: v2(110.57,52.12) 110.97,52.12 111.08,52.24 111.08,53 111.2,53.12 115.7,53.12 115.82,53.24 115.82,53.46 115.7,53.58 111.2,53.58 111.08,53.69 111.08,53.92 111.2,54.03 115.69,54.03 115.82,54.16 115.82,55.91 115.7,56.03 114.58,56.03 114.46,55.91 114.46,54.51 114.35,54.4 114.12,54.4 114.01,54.51 114.01,55.91 113.89,56.03 112.64,56.03 112.53,55.91 112.53,55.12 112.41,55.01 112.18,55.01 112.07,55.12 112.07,55.91 111.96,56.03 111.69,56.03 111.54,55.89 111.54,55.16 111.42,55.03 111.2,55.03 111.08,55.14 111.08,59.13 111.22,59.26 111.5,59.26 111.62,59.37 111.62,60.82 111.5,60.94 109.81,60.94 109.7,61.05 109.7,62.94 109.4,63.25 109.4,63.86 109.51,63.98 109.9,63.98 110.02,64.09 110.02,64.32 109.9,64.43 109.51,64.43 109.4,64.55 109.4,64.78 109.51,64.89 109.9,64.89 110.02,65 110.02,65.23 109.9,65.35 109.51,65.35 109.19,65.66 109.19,69.57 109.9,70.28 115.03,70.28 115.22,70.47 115.22,71.45 115.42,71.64 119.52,71.64 119.64,71.75 119.64,80.82 119.56,80.9 119.56,83.17 v2(119.99,83.6)
MEM_DMBN1: length 68.4
  TOP w0.109: v2(105.47,62.74) 105.32,62.59 CON1.199
  ART07 w0.114: v2(105.47,62.74) 105.46,62.73 105.46,61.01 105.58,60.88 105.78,60.88 105.9,61 105.9,63.03 105.47,63.46 105.47,64 105.58,64.12 105.6,64.12 105.72,64.23 105.72,64.46 105.6,64.58 105.58,64.58 105.47,64.69 105.47,64.99 105.66,65.18 105.82,65.18 106.09,64.91 106.25,64.91 106.41,65.07 106.41,65.23 106.14,65.5 106.14,65.66 106.42,65.94 106.58,65.94 107.17,65.34 107.33,65.34 107.49,65.51 107.49,65.67 106.9,66.26 106.9,66.42 107.06,66.58 107.23,66.58 108.46,65.34 108.62,65.34 108.79,65.51 108.79,65.67 107.55,66.91 107.55,67.07 107.71,67.23 107.87,67.23 109.69,65.41 109.85,65.41 110.01,65.58 110.01,65.74 108.2,67.55 108.2,67.71 108.36,67.88 108.52,67.88 109.02,67.37 109.18,67.37 109.33,67.52 109.33,67.71 108.84,68.2 108.84,68.36 109.08,68.6 109.34,68.6 109.56,68.82 109.56,69.08 110.56,70.08 113.03,70.08 114.21,68.9 114.21,66.97 114.32,66.85 114.51,66.85 114.62,66.97 114.62,68.1 114.74,68.22 114.94,68.22 115.08,68.08 115.08,66.92 115.2,66.81 115.42,66.81 115.54,66.92 115.54,68.1 115.65,68.22 115.86,68.22 116,68.08 116,66.92 116.11,66.81 116.34,66.81 116.45,66.92 116.45,68.1 116.57,68.22 116.77,68.22 116.91,68.08 116.91,66.92 117.02,66.81 117.25,66.81 117.37,66.92 117.37,68.1 117.48,68.22 117.69,68.22 117.82,68.08 117.82,66.87 117.96,66.73 118.17,66.73 118.28,66.84 118.28,68.1 118.4,68.22 118.6,68.22 118.74,68.08 118.74,66.59 118.85,66.48 119.13,66.48 119.27,66.62 119.27,77.85 120.09,78.68 120.09,81.18 119.99,81.28 v2(119.99,81.6)
MEM_DMBN2: length 75.4
  TOP w0.109: v2(100.07,52.12) CON1.220
  ART07 w0.114: v2(113.92,84.1) 113.92,84.62 113.56,84.99 112.85,84.99 112.6,84.74 112.6,82.92 112.25,82.56 112.01,82.56 111.49,82.04 111,82.04 110.67,81.71 110.25,81.71 109.87,82.09 107.7,82.09 107.29,81.69 107.29,81.48 102.71,76.9 102.71,76.72 102.87,76.56 102.87,76.4 102.71,76.24 102.54,76.24 102.38,76.39 102.22,76.39 102.05,76.22 102.05,74.46 101.88,74.29 101.88,74.01 102.07,73.83 102.07,73.67 101.85,73.44 101.68,73.44 101.5,73.62 101.21,73.62 100.78,73.18 99.72,73.18 98.06,71.53 98.06,71.37 98.47,70.96 98.47,70.8 98.31,70.64 98.15,70.64 97.79,70.99 97.63,70.99 97.43,70.8 97.43,64.78 99.11,63.1 99.11,62.32 98.88,62.09 98.88,60.01 99,59.89 100.15,59.89 100.27,59.78 100.27,58.96 100.15,58.85 99.68,58.85 99.57,58.96 99.57,59.42 99.46,59.54 99.23,59.54 99.11,59.42 99.11,58.96 99,58.85 98.77,58.85 98.66,58.96 98.66,59.42 98.54,59.54 98.31,59.54 98.2,59.42 98.2,58.96 98.08,58.85 97.84,58.85 97.73,58.74 97.73,58.51 97.84,58.39 100.15,58.39 100.27,58.28 100.27,58.05 100.15,57.94 97.84,57.94 97.73,57.82 97.73,57.59 97.84,57.48 100.15,57.48 100.27,57.36 100.27,57.14 100.15,57.02 97.84,57.02 97.73,56.91 97.73,56.68 97.84,56.56 100.15,56.56 100.27,56.45 100.27,56.22 100.15,56.11 97.84,56.11 97.73,55.99 97.73,55.76 97.84,55.65 100.15,55.65 100.27,55.53 100.27,55.29 100.07,55.09 99.1,55.09 98.99,54.98 98.99,53.35 99.16,53.18 99.32,53.18 100.04,53.9 100.2,53.9 100.36,53.74 100.36,53.58 99.64,52.86 99.64,52.69 100.07,52.27 v2(100.07,52.12)
MEM_DMBN3: length 69.9
  TOP w0.109: CON1.241 94.82,62.59 v2(94.97,62.74)
  ART05 w0.114: v2(113.92,81.1) 113.92,80.55 108.42,75.04 107.43,75.04 99.97,67.58 99.97,67.42 101.81,65.58 101.81,65.42 101.65,65.26 101.49,65.26 99.65,67.1 99.49,67.1 99.33,66.94 99.33,66.77 101.17,64.94 101.17,64.77 101,64.61 100.84,64.61 99,66.45 98.84,66.45 98.67,66.28 98.67,66.12 99.96,64.83 99.96,64.67 99.8,64.51 99.64,64.51 98.35,65.8 98.19,65.8 98.02,65.62 98.02,65.46 98.68,64.8 98.68,64.64 98.52,64.47 98.36,64.47 97.69,65.14 97.53,65.14 96.73,64.34 95.94,64.34 95.4,63.8 95.4,62.15 95.73,61.82 101.02,61.82 101.15,61.69 101.15,61.46 101.04,61.35 95.97,61.35 95.84,61.23 95.84,61.01 95.97,60.89 99.9,60.89 100.01,60.78 100.01,60 99.9,59.88 95.93,59.88 95.82,60 95.82,60.5 94.97,61.35 v2(94.97,62.74)
MEM_DQ_ADDR_CMD0: length 57.2
  TOP w0.109: v2(131.07,52.12) CON1.104
  ART07 w0.114: v2(131.07,52.12) 130.71,52.48 128.13,52.48 128.01,52.6 128.01,52.82 128.13,52.94 128.64,52.94 128.75,53.05 128.75,55.8 128.59,55.96 128.59,59.24 128.27,59.56 128.27,60.4 127.71,60.96 126.64,60.96 125.85,61.75 125.85,64.82 125.55,65.12 125.55,65.13 125.29,65.39 125.13,65.39 124.42,64.69 124.26,64.69 124.1,64.85 124.1,65.01 124.81,65.72 124.81,65.88 124.64,66.04 124.48,66.04 123.78,65.33 123.61,65.33 123.45,65.49 123.45,65.66 124.16,66.36 124.16,66.52 124,66.69 123.84,66.69 123.13,65.98 122.97,65.98 122.81,66.14 122.81,66.3 123.51,67.01 123.51,67.17 123.19,67.49 123.19,79.81 122.92,80.08 122.92,80.3 arc(122.84,80.6) 122.92,80.9 122.92,80.9 arc(122.98,81.1) 122.92,81.3 arc(122.84,81.6) 122.92,81.9 arc(122.98,82.1) 122.92,82.3 arc(122.84,82.6) 122.92,82.9 122.92,82.9 arc(122.98,83.1) 122.92,83.3 122.92,83.3 arc(122.78,83.44) 122.58,83.49 arc(122.28,83.57) 122.06,83.8 122.06,83.8 arc(121.91,83.94) 121.72,83.99 121.44,83.99 121.13,83.68 120.61,83.68 120.24,84.05 119.84,84.05 119.34,83.56 118.9,83.56 118.58,83.88 118.58,84.32 118.67,84.41 118.67,84.79 118.4,85.06 118.3,85.1 118.26,85.1 arc(118.01,85.17) 117.82,85.35 117.82,85.35 arc(117.64,85.53) 117.39,85.6 117.39,85.6 arc(117.14,85.67) 116.96,85.85 116.96,85.85 arc(116.89,86.1) 116.96,86.35 arc(117.02,86.6) 116.96,86.85 arc(116.89,87.1) 116.96,87.35 arc(117.02,87.6) 116.96,87.85 arc(116.89,88.1) 116.96,88.35 v2(117.39,89.1)
MEM_DQ_ADDR_CMD1: length 57
  TOP w0.109: CON1.105 130.82,62.47 v2(130.55,62.74)
  ART07 w0.114: v2(130.55,62.74) 130.55,62.16 130.6,62.1 130.6,60.71 130.91,60.4 130.91,60.03 130.91,60.02 130.91,55.36 130.77,55.22 130.48,55.22 130.36,55.33 130.36,58.71 130.25,58.83 130.02,58.83 129.91,58.71 129.91,56.2 129.79,56.08 129.5,56.08 129.39,56.2 129.39,57.99 129.51,58.11 129.51,59.6 127.45,61.66 127.45,62.94 126.82,63.58 126.82,63.78 126.44,64.16 126.44,64.77 123.54,67.67 123.54,79.89 123.23,80.2 123.23,80.29 123.11,80.4 arc(123.06,80.6) 123.11,80.8 123.11,80.8 arc(123.19,81.1) 123.11,81.4 arc(123.06,81.6) 123.11,81.8 123.11,81.8 arc(123.19,82.1) 123.11,82.4 arc(123.06,82.6) 123.11,82.8 arc(123.19,83.1) 123.11,83.4 arc(122.89,83.63) 122.59,83.71 122.58,83.71 arc(122.39,83.76) 122.25,83.9 122.25,83.9 arc(122.02,84.13) 121.72,84.21 arc(121.53,84.26) 121.38,84.4 121.38,84.4 arc(121.27,84.54) 121.14,84.64 120.63,84.64 120.42,84.85 arc(120.23,85.03) 119.99,85.1 119.99,85.1 119.82,85.16 119.34,85.64 118.93,85.64 118.71,85.83 118.69,85.85 arc(118.5,86.03) 118.26,86.1 arc(118.01,86.17) 117.82,86.35 117.82,86.35 arc(117.76,86.6) 117.82,86.85 arc(117.89,87.1) 117.82,87.35 arc(117.76,87.6) 117.82,87.85 arc(117.89,88.1) 117.82,88.35 arc(117.76,88.6) 117.82,88.85 arc(117.89,89.1) 117.82,89.35 v2(117.39,90.1)
MEM_DQ_ADDR_CMD2: length 58.4
  TOP w0.109: v2(131.35,63.04) 131.35,63.01 131.82,62.54 CON1.101
  ART07 w0.114: v2(118.26,88.6) 118.26,88.18 118.35,88.09 arc(118.54,88.01) 118.69,87.85 118.69,87.85 arc(118.75,87.6) 118.69,87.35 arc(118.62,87.1) 118.69,86.85 118.69,86.85 arc(118.87,86.67) 119.12,86.6 arc(119.37,86.53) 119.55,86.35 119.55,86.35 arc(119.74,86.17) 119.98,86.1 119.99,86.1 arc(120.24,86.03) 120.42,85.85 120.42,85.85 arc(120.61,85.67) 120.85,85.6 120.85,85.6 arc(121.1,85.53) 121.29,85.35 121.29,85.35 arc(121.47,85.17) 121.72,85.1 arc(121.97,85.03) 122.15,84.85 122.15,84.85 arc(122.34,84.67) 122.58,84.6 arc(122.83,84.53) 123.02,84.35 123.02,84.35 arc(123.2,84.17) 123.45,84.1 123.45,84.1 arc(123.7,84.03) 123.88,83.85 123.88,83.85 arc(123.95,83.6) 123.88,83.35 arc(123.82,83.1) 123.88,82.85 arc(123.95,82.6) 123.88,82.35 arc(123.82,82.1) 123.88,81.85 arc(123.95,81.6) 123.88,81.35 arc(123.82,81.1) 123.88,80.85 123.89,80.85 123.89,80.2 124.03,80.06 124.03,79.12 124.56,78.59 124.56,74.42 123.9,73.76 123.9,67.76 124.63,67.02 124.8,67.02 125.53,67.75 125.69,67.75 125.85,67.59 125.85,67.43 125.12,66.7 125.12,66.54 125.28,66.38 125.44,66.38 126.14,67.07 126.3,67.07 126.45,66.92 126.45,66.73 125.77,66.05 125.77,65.89 125.93,65.73 126.09,65.73 126.8,66.44 126.96,66.44 127.12,66.27 127.12,66.11 126.41,65.41 126.41,65.24 126.57,65.08 126.74,65.08 126.98,65.33 127.15,65.33 127.31,65.17 127.31,65.01 126.8,64.51 126.8,64.34 126.94,64.21 127.15,64.21 127.86,64.91 128.02,64.91 128.18,64.75 128.18,64.59 127.96,64.37 127.96,64.21 128.44,63.73 128.44,63.39 128.64,63.2 129.08,63.2 129.33,63.45 129.55,63.45 129.66,63.33 129.66,62.33 129.55,62.22 127.98,62.22 127.86,62.1 127.86,61.89 127.99,61.76 129.65,61.76 129.8,61.61 129.8,61.19 129.68,61.08 129.05,61.08 128.93,60.96 128.93,60.76 129.14,60.55 130.07,60.55 130.19,60.67 130.19,61.9 130.1,61.99 130.1,63.63 130.33,63.86 130.72,63.86 130.96,63.62 130.96,63.28 130.93,63.25 130.93,62.89 130.96,62.86 130.96,62.55 131.07,62.43 131.3,62.43 131.42,62.55 131.42,62.97 v2(131.35,63.04)
MEM_DQ_ADDR_CMD3: length 58.3
  TOP w0.109: v2(132.07,52.12) CON1.100
  ART07 w0.114: v2(118.26,89.6) 118.69,88.85 arc(118.87,88.67) 119.12,88.6 arc(119.37,88.53) 119.55,88.35 119.55,88.35 arc(119.62,88.1) 119.55,87.85 arc(119.49,87.6) 119.55,87.35 arc(119.74,87.17) 119.99,87.1 119.99,87.1 arc(120.23,87.03) 120.42,86.85 120.42,86.85 arc(120.6,86.67) 120.85,86.6 120.86,86.6 arc(121.1,86.53) 121.29,86.35 121.29,86.35 arc(121.47,86.17) 121.72,86.1 arc(121.97,86.03) 122.15,85.85 122.15,85.85 arc(122.34,85.67) 122.58,85.6 arc(122.83,85.53) 123.02,85.35 123.02,85.35 arc(123.2,85.17) 123.45,85.1 123.45,85.1 arc(123.7,85.03) 123.88,84.85 123.89,84.85 arc(124.07,84.67) 124.32,84.6 124.32,84.6 124.5,84.52 124.74,84.28 124.74,83.92 124.64,83.82 124.64,83.38 124.76,83.26 124.76,82.94 124.64,82.82 124.64,82.38 124.76,82.25 124.76,81.95 124.64,81.82 124.64,81.38 124.66,81.36 124.66,81.31 124.97,81 124.97,80.59 124.85,80.47 124.57,80.47 124.46,80.36 124.46,80.13 124.57,80.01 124.85,80.01 124.97,79.9 124.97,79.67 124.85,79.56 124.62,79.56 124.51,79.44 124.51,79.21 124.62,79.1 124.8,79.1 124.91,78.98 124.91,73.85 124.8,73.74 124.36,73.74 124.23,73.61 124.23,73.37 124.34,73.25 124.89,73.25 125,73.14 125,72.91 124.89,72.8 124.34,72.8 124.23,72.68 124.23,72.45 124.34,72.34 124.89,72.34 125,72.22 125,72 124.89,71.88 124.34,71.88 124.23,71.77 124.23,71.54 124.34,71.42 124.89,71.42 125,71.31 125,71.08 124.89,70.97 124.34,70.97 124.23,70.85 124.23,70.62 124.34,70.51 124.89,70.51 125,70.4 125,70.17 124.89,70.05 124.34,70.05 124.23,69.94 124.23,69.67 124.53,69.37 124.53,69.2 124.23,68.9 124.23,68.68 124.36,68.55 124.52,68.55 124.86,68.88 125.02,68.88 125.19,68.71 125.19,68.55 124.48,67.84 124.48,67.69 124.64,67.54 124.81,67.54 125.52,68.25 125.68,68.25 128.26,65.66 128.26,65.16 129.39,64.03 129.94,64.03 130.08,64.17 130.89,64.17 131.76,63.3 131.76,60.79 131.85,60.7 131.85,59.92 131.32,59.39 131.32,55.17 131.04,54.89 131.04,53.16 v2(132.07,52.12)
MEM_DQ_ADDR_CMD4: length 56.5
  TOP w0.109: v2(133.07,52.12) 133.07,53.3
  ART07 w0.114: v2(133.07,52.12) 132.05,53.14 132.05,54.69 131.73,55 131.73,55.23 131.85,55.35 131.99,55.35 132.14,55.5 132.14,55.73 132.02,55.84 131.81,55.84 131.73,55.91 131.73,58.97 132.74,59.97 132.74,60.4 132.18,60.96 132.18,63.47 130.59,65.06 130.38,65.06 129.91,64.59 129.84,64.52 129.66,64.52 129.51,64.67 129.51,64.83 130.06,65.38 130.06,65.55 129.89,65.71 129.73,65.71 129.48,65.45 129.31,65.45 129.15,65.61 129.15,65.77 129.41,66.03 129.41,66.19 129.21,66.39 129.05,66.39 128.67,66.01 128.51,66.01 128.35,66.18 128.35,66.34 128.72,66.72 128.72,66.88 128.56,67.04 128.4,67.04 128.02,66.66 127.86,66.66 127.7,66.82 127.7,66.98 128.08,67.36 128.08,67.52 127.92,67.69 127.75,67.69 127.38,67.31 127.21,67.31 127.05,67.47 127.05,67.63 127.43,68.01 127.43,68.17 127.27,68.33 127.11,68.33 126.73,67.95 126.57,67.95 126.41,68.12 126.41,68.28 126.78,68.66 126.78,68.82 126.62,68.98 126.46,68.98 126.08,68.6 125.92,68.6 125.76,68.76 125.76,68.92 126.14,69.3 126.14,69.46 125.98,69.63 125.81,69.63 125.44,69.25 125.27,69.25 125.11,69.41 125.11,69.57 125.49,69.95 125.49,74.1 125.35,74.24 125.35,79.47 125.55,79.68 125.55,81.19 125.73,81.37 125.73,81.84 125.62,81.95 125.62,82.26 125.77,82.41 125.77,82.82 125.62,82.97 125.62,83.22 125.78,83.39 125.78,83.77 125.6,83.95 125.6,84.25 125.74,84.39 125.74,84.81 125.36,85.2 124.89,85.2 124.54,85.55 arc(124.43,85.59) 124.32,85.6 124.32,85.6 arc(124.07,85.67) 123.89,85.85 123.88,85.85 arc(123.7,86.03) 123.45,86.1 123.45,86.1 arc(123.2,86.17) 123.02,86.35 123.02,86.35 arc(122.83,86.53) 122.58,86.6 arc(122.34,86.67) 122.15,86.85 122.15,86.85 arc(121.97,87.03) 121.72,87.1 arc(121.47,87.17) 121.29,87.35 121.29,87.35 arc(121.1,87.53) 120.86,87.6 120.85,87.6 arc(120.6,87.67) 120.42,87.85 119.99,88.6 arc(119.99,88.6) v2(119.99,88.6)
MEM_DQ_ADDR_CMD5: length 54.6
  TOP w0.109: v2(135.07,52.12) CON1.88
  ART07 w0.114: v2(120.85,89.1) 121.72,89.1 arc(121.97,89.17) 122.15,89.35 122.15,89.35 arc(122.58,89.6) 123.02,89.35 123.02,89.35 arc(123.2,89.17) 123.45,89.1 123.45,89.1 arc(123.7,89.03) 123.88,88.85 123.89,88.85 arc(124.07,88.67) 124.32,88.6 124.32,88.6 arc(124.57,88.53) 124.75,88.35 124.75,88.35 arc(124.94,88.17) 125.18,88.1 arc(125.43,88.03) 125.61,87.85 125.62,87.85 arc(125.8,87.67) 126.05,87.6 126.06,87.59 126.25,87.59 126.61,87.24 126.61,87.1 127.52,86.18 127.52,85.56 arc(127.5,85.42) 127.44,85.3 arc(127.39,85.1) 127.44,84.9 arc(127.52,84.6) 127.44,84.3 arc(127.39,84.1) 127.44,83.9 arc(127.52,83.6) 127.44,83.3 arc(127.39,83.1) 127.44,82.9 127.44,82.9 arc(127.52,82.6) 127.44,82.3 arc(127.39,82.1) 127.44,81.9 arc(127.52,81.6) 127.44,81.3 arc(127.39,81.1) 127.44,80.9 127.44,79.86 127.53,79.77 127.53,78.23 128.09,77.67 128.09,72.62 133.58,67.13 133.58,65.26 134.55,64.28 134.55,63.38 134.33,63.16 134.33,62.39 134.46,62.25 135.07,62.25 135.2,62.12 135.2,61.89 135.09,61.78 134.39,61.78 134.27,61.66 134.27,61.43 134.39,61.32 135.09,61.32 135.2,61.21 135.2,60.98 135.09,60.86 134.45,60.86 134.34,60.75 134.34,58.32 133.88,57.86 132.67,57.86 132.56,57.74 132.56,57.51 132.67,57.4 133.89,57.4 134.01,57.28 134.01,57.04 133.89,56.93 133.18,56.93 133.07,56.81 133.07,56.59 133.18,56.47 133.89,56.47 134.01,56.36 134.01,53.19 v2(135.07,52.12)
MEM_DQ_ADDR_CMD6: length 54.5
  TOP w0.109: CON1.91 134.32,62.56 v2(134.75,62.99)
  ART07 w0.114: v2(120.85,90.1) 121.94,90.1 122.1,90.25 122.15,90.35 arc(122.58,90.6) 123.02,90.35 123.02,90.35 arc(123.2,90.17) 123.45,90.1 123.45,90.1 arc(123.7,90.03) 123.88,89.85 123.89,89.85 arc(124.07,89.67) 124.32,89.6 124.32,89.6 arc(124.57,89.53) 124.75,89.35 124.75,89.35 arc(124.94,89.17) 125.18,89.1 arc(125.43,89.03) 125.61,88.85 125.62,88.85 arc(125.8,88.67) 126.05,88.6 arc(126.3,88.53) 126.48,88.35 126.48,88.35 arc(126.66,88.17) 126.91,88.1 126.92,88.1 arc(127.16,88.03) 127.35,87.85 127.35,87.85 127.36,87.84 arc(127.49,87.58) 127.43,87.3 arc(127.38,87.1) 127.43,86.9 127.53,86.73 128.06,86.2 128.06,85.77 arc(128.04,85.53) 128.12,85.3 arc(128.17,85.1) 128.12,84.9 arc(128.04,84.6) 128.12,84.3 arc(128.17,84.1) 128.12,83.9 arc(128.04,83.6) 128.12,83.3 arc(128.17,83.1) 128.12,82.9 128.12,82.9 arc(128.04,82.6) 128.12,82.3 arc(128.17,82.1) 128.12,81.9 arc(128.04,81.6) 128.12,81.3 arc(128.16,81.18) 128.17,81.05 128.17,80.82 127.85,80.49 127.85,80.38 127.96,80.26 128.23,80.26 128.34,80.15 128.34,79.92 128.23,79.81 127.98,79.81 127.86,79.69 127.86,79.46 127.98,79.35 128.23,79.35 128.34,79.23 128.34,79.01 128.23,78.89 127.98,78.89 127.86,78.78 127.86,78.52 127.98,78.41 128.29,78.41 128.42,78.28 128.42,72.9 134.5,66.82 134.5,66.65 133.97,66.12 133.97,65.92 134.11,65.77 134.27,65.77 134.83,66.33 134.99,66.33 135.15,66.17 135.15,66.01 134.32,65.18 134.32,65.01 134.48,64.85 134.64,64.85 135.47,65.68 135.64,65.68 135.81,65.51 135.81,65.35 135.34,64.89 135.34,64.7 135.48,64.57 135.67,64.57 136.13,65.03 136.29,65.03 136.5,64.82 136.5,61.03 136.38,60.91 136.05,60.91 135.94,61.02 135.94,62.76 135.55,63.15 135.55,63.31 135.86,63.63 136.04,63.63 136.14,63.73 136.14,64.06 136.01,64.18 135.06,64.18 134.95,64.07 134.95,63.19 v2(134.75,62.99)
MEM_DQ_ADDR_CMD7: length 54.4
  TOP w0.109: v2(134.07,52.12) CON1.92
  ART07 w0.114: v2(121.72,88.6) 122.58,88.6 arc(122.83,88.53) 123.02,88.35 123.02,88.35 arc(123.2,88.17) 123.45,88.1 123.45,88.1 arc(123.7,88.03) 123.88,87.85 123.89,87.85 arc(124.07,87.67) 124.32,87.6 124.32,87.6 arc(124.57,87.53) 124.75,87.35 124.75,87.35 arc(124.94,87.17) 125.18,87.1 arc(125.43,87.03) 125.61,86.85 125.62,86.85 125.88,86.59 126.57,86.59 127.25,85.9 127.25,85.8 arc(127.31,85.6) 127.25,85.4 arc(127.17,85.1) 127.25,84.8 arc(127.31,84.6) 127.25,84.4 arc(127.17,84.1) 127.25,83.8 arc(127.31,83.6) 127.25,83.4 arc(127.17,83.1) 127.25,82.8 arc(127.31,82.6) 127.25,82.4 arc(127.17,82.1) 127.25,81.8 127.25,81.8 arc(127.31,81.6) 127.25,81.4 arc(127.19,81.22) 127.18,81.03 127.18,80.87 127.1,80.8 127.1,72.95 133.14,66.9 133.14,65.12 133.16,65.11 133.16,65.09 134.13,64.11 134.13,63.65 133.91,63.42 133.91,62.33 133.79,62.21 132.65,62.21 132.53,62.1 132.53,61.87 132.65,61.76 133.69,61.76 133.8,61.64 133.8,61.39 133.7,61.29 132.79,61.29 132.69,61.19 132.69,60.9 132.81,60.78 133.29,60.78 133.41,60.67 133.41,59.36 133.29,59.24 132.7,59.24 132.59,59.13 132.59,58.9 132.7,58.79 133.29,58.79 133.41,58.67 133.41,58.43 133.29,58.32 132.22,58.32 132.1,58.2 132.1,56.23 132.33,56.01 133.46,56.01 133.58,55.89 133.58,55.65 133.46,55.54 132.62,55.54 132.51,55.42 132.51,55.19 132.62,55.08 133.03,55.08 133.14,54.96 133.14,53.05 v2(134.07,52.12)
MEM_DQ_ADDR_CMD8: length 55.1
  TOP w0.109: v2(135.4,62.71) 135.32,62.63 CON1.87
  ART07 w0.114: v2(121.72,89.6) 120.63,89.6 120.39,89.84 120.39,90.3 120.7,90.6 121.04,90.6 121.29,90.85 arc(121.47,91.03) 121.72,91.1 arc(121.97,91.17) 122.15,91.35 122.15,91.35 arc(122.58,91.6) 123.02,91.35 123.02,91.35 arc(123.2,91.17) 123.45,91.1 123.45,91.1 arc(123.7,91.03) 123.88,90.85 123.89,90.85 arc(124.07,90.67) 124.32,90.6 124.32,90.6 arc(124.57,90.53) 124.75,90.35 124.75,90.35 arc(124.94,90.17) 125.18,90.1 arc(125.43,90.03) 125.61,89.85 125.62,89.85 arc(125.8,89.67) 126.05,89.6 arc(126.3,89.53) 126.48,89.35 126.48,89.35 arc(126.66,89.17) 126.91,89.1 126.92,89.1 arc(127.16,89.03) 127.35,88.85 127.35,88.85 arc(127.53,88.67) 127.78,88.6 127.78,88.6 arc(128.03,88.53) 128.21,88.35 arc(128.28,88.1) 128.21,87.85 128.19,87.8 arc(128.14,87.58) 128.24,87.38 arc(128.24,87.37) 128.24,87.37 128.24,86.47 128.31,86.4 arc(128.39,86.1) 128.31,85.8 arc(128.25,85.6) 128.31,85.4 arc(128.39,85.1) 128.31,84.8 arc(128.25,84.6) 128.31,84.4 arc(128.39,84.1) 128.31,83.8 arc(128.25,83.6) 128.31,83.4 arc(128.39,83.1) 128.31,82.8 arc(128.25,82.6) 128.31,82.4 arc(128.39,82.1) 128.31,81.8 128.31,81.8 arc(128.25,81.6) 128.31,81.4 arc(128.35,81.31) 128.38,81.21 128.66,80.93 128.66,78.84 128.75,78.76 128.75,73.02 136.81,64.96 136.81,60.88 136.34,60.41 136.34,59.88 136.23,59.77 135.85,59.77 135.74,59.65 135.74,59.42 135.85,59.31 136.28,59.31 136.4,59.2 136.4,58.97 136.28,58.85 135.85,58.85 135.74,58.74 135.74,58.51 135.85,58.4 136.31,58.4 136.42,58.28 136.42,58.05 136.31,57.94 135.44,57.94 135.33,58.05 135.33,60.45 135.61,60.73 135.61,62.5 v2(135.4,62.71)
MEM_DQA0: length 63.3
  TOP w0.109: v2(155.07,52.12) CON1.8
  ART07 w0.114: v2(155.07,52.12) 155.07,56.82 155.18,56.94 155.53,56.94 155.64,57.05 155.64,57.28 155.53,57.4 155.18,57.4 155.07,57.51 155.07,58 156.31,59.24 156.31,61.89 156.42,62.01 157.19,62.01 158.18,62.99 158.18,64.4 156.49,66.09 156.49,70.76 146.52,80.73 145.63,80.73 142.82,83.54 142.82,83.77 140.61,85.98 140.61,86.14 140.68,86.21 140.68,86.37 140.51,86.54 140.35,86.54 140.28,86.47 140.12,86.47 139.96,86.63 139.96,86.79 140.03,86.86 140.03,87.02 139.87,87.18 139.71,87.18 139.64,87.11 139.48,87.11 139.22,87.37 139.22,87.92 139.04,88.1 arc(138.79,88.17) 138.61,88.34 138.6,88.35 arc(138.42,88.53) 138.17,88.6 138.17,88.6 arc(137.92,88.67) 137.74,88.85 137.74,88.85 arc(137.55,89.03) 137.31,89.1 arc(137.06,89.17) 136.88,89.35 136.87,89.35 arc(136.69,89.53) 136.44,89.6 arc(136.19,89.67) 136.01,89.85 136.01,89.85 arc(135.83,90.03) 135.58,90.1 135.57,90.1 arc(135.33,90.17) 135.14,90.35 135.14,90.35 arc(134.96,90.53) 134.71,90.6 134.71,90.6 arc(134.46,90.53) 134.28,90.35 134.27,90.35 arc(134.09,90.17) 133.84,90.1 arc(133.6,90.03) 133.41,89.85 133.41,89.85 arc(133.23,89.67) 132.98,89.6 arc(132.73,89.53) 132.55,89.35 132.54,89.35 arc(132.36,89.17) 132.11,89.1 132.11,89.1 arc(131.86,89.03) 131.68,88.85 131.68,88.85 arc(131.49,88.67) 131.25,88.6 131.24,88.6 arc(130.99,88.53) 130.81,88.35 130.81,88.35 arc(130.63,88.17) 130.38,88.1 130.38,88.1 arc(130.13,88.03) 129.95,87.85 arc(129.88,87.6) 129.94,87.35 129.95,87.35 arc(130.01,87.1) 129.95,86.85 129.94,86.85 arc(129.8,86.69) 129.6,86.61 arc(129.51,86.56) 129.41,86.51 arc(129.28,86.42) 129.17,86.3 arc(129.12,86.1) 129.17,85.9 arc(129.21,85.84) 129.23,85.77 v2(129.51,85.1)
MEM_DQA1: length 62.2
  TOP w0.109: v2(155.32,62.68) CON1.7
  ART07 w0.114: v2(130.38,83.6) 130.78,84 130.78,85.32 130.81,85.35 arc(130.99,85.53) 131.24,85.6 131.25,85.6 arc(131.49,85.67) 131.68,85.85 131.68,85.85 arc(131.74,86.1) 131.68,86.35 arc(131.61,86.6) 131.68,86.85 131.68,86.85 arc(131.86,87.03) 132.11,87.1 arc(132.36,87.17) 132.54,87.35 132.55,87.35 arc(132.73,87.53) 132.98,87.6 arc(133.23,87.67) 133.41,87.85 133.41,87.85 arc(133.6,88.03) 133.84,88.1 arc(134.09,88.17) 134.27,88.35 134.28,88.35 arc(134.46,88.53) 134.71,88.6 134.71,88.6 arc(134.96,88.53) 135.14,88.35 135.14,88.35 arc(135.33,88.17) 135.57,88.1 135.58,88.1 arc(135.83,88.03) 136.01,87.85 136.01,87.85 arc(136.19,87.67) 136.44,87.6 arc(136.69,87.53) 136.87,87.35 136.88,87.35 arc(137.06,87.17) 137.31,87.1 arc(137.55,87.03) 137.74,86.85 137.74,86.85 arc(137.92,86.67) 138.17,86.6 138.69,86.6 140.19,85.1 140.19,83.83 142.53,81.5 142.53,81.03 143.21,80.35 144.57,80.35 145.9,79.02 146.22,79.02 146.5,78.74 147.18,78.74 154.57,71.35 154.57,64.09 154.99,63.67 154.99,63.33 154.87,63.2 154.87,62.37 154.75,62.25 153.47,62.25 153.32,62.1 153.32,61.86 153.48,61.71 154.96,61.71 155.08,61.59 155.08,61.36 154.96,61.25 153.86,61.25 153.74,61.13 153.74,59.96 153.86,59.85 154.83,59.85 154.95,59.73 154.95,59.53 154.81,59.39 153.32,59.39 153.2,59.27 153.2,59 153.35,58.86 155.2,58.86 155.32,58.97 v2(155.32,62.68)
MEM_DQA2: length 61.2
  TOP w0.109: v2(152.07,52.12) CON1.20
  ART07 w0.114: v2(152.07,52.12) 152.07,53.81 152.24,53.98 152.87,53.98 152.98,54.1 152.98,55.25 152.52,55.71 151.26,55.71 151.15,55.83 151.15,56.13 151.26,56.24 152.38,56.24 152.5,56.36 152.5,56.58 152.38,56.7 151.26,56.7 151.15,56.81 151.15,57.04 151.26,57.16 152.38,57.16 152.5,57.27 152.5,57.5 152.38,57.61 151.26,57.61 151.15,57.73 151.15,57.96 151.26,58.07 152.38,58.07 152.5,58.18 152.5,58.41 152.38,58.53 151.26,58.53 151.15,58.64 151.15,58.87 151.26,58.98 152.38,58.98 152.5,59.1 152.5,59.33 152.38,59.44 151.26,59.44 151.15,59.56 151.15,59.8 151.26,59.91 151.68,59.91 151.8,60.03 151.8,60.73 151.68,60.85 151.47,60.85 151.36,60.96 151.36,62 151.47,62.12 151.84,62.12 152.23,62.51 152.23,62.92 152.38,63.06 152.38,63.88 152.35,63.91 152.35,63.91 151.95,64.31 151.95,69.59 145.75,75.79 139.89,75.79 139.7,75.97 139.7,77.82 138.93,78.6 137.41,78.6 137.3,78.71 137.3,80.9 136.95,81.25 arc(136.91,81.3) 136.87,81.35 arc(136.81,81.6) 136.87,81.85 136.88,81.85 arc(136.94,82.1) 136.87,82.35 arc(136.81,82.6) 136.87,82.85 136.87,82.85 arc(136.94,83.1) 136.87,83.35 136.87,83.35 arc(136.69,83.53) 136.44,83.6 arc(136.19,83.67) 136.01,83.85 136.01,83.85 arc(135.83,84.03) 135.58,84.1 135.57,84.1 arc(135.33,84.17) 135.14,84.35 135.14,84.35 arc(134.96,84.53) 134.71,84.6 134.57,84.58 134.39,84.5 134.19,84.29 133.83,84.12 v2(132.98,84.1)
MEM_DQA3: length 60
  TOP w0.109: v2(151.82,62.68) CON1.21
  ART07 w0.114: v2(151.82,62.68) 151.82,62.95 152.06,63.2 152.06,63.75 152.04,63.77 152.04,63.78 151.61,64.2 151.61,68.47 151.31,68.77 151.31,68.93 151.62,69.23 151.62,69.39 151.46,69.55 151.29,69.55 150.99,69.25 150.83,69.25 150.67,69.41 150.67,69.57 150.97,69.88 150.97,70.04 150.81,70.2 150.65,70.2 150.34,69.9 150.18,69.9 150.02,70.06 150.02,70.22 150.32,70.52 150.32,70.69 150.16,70.85 150,70.85 149.7,70.54 149.54,70.54 149.37,70.71 149.37,70.87 149.68,71.17 149.68,71.33 149.52,71.49 149.35,71.49 149.05,71.19 148.89,71.19 148.73,71.35 148.73,71.51 149.03,71.82 149.03,71.98 148.87,72.14 148.71,72.14 148.4,71.84 148.24,71.84 148.08,72 148.08,72.16 148.38,72.46 148.38,72.63 148.22,72.79 148.06,72.79 147.76,72.48 147.6,72.48 147.43,72.65 147.43,72.81 147.74,73.11 147.74,73.27 147.58,73.43 147.41,73.43 147.11,73.13 146.95,73.13 146.79,73.29 146.79,73.45 147.09,73.76 147.09,73.92 146.93,74.08 146.77,74.08 146.46,73.78 146.3,73.78 146.14,73.94 146.14,74.1 146.44,74.4 146.44,74.56 146.28,74.73 146.12,74.73 145.82,74.42 145,74.42 144.89,74.54 144.89,75.36 144.77,75.47 144.54,75.47 144.43,75.36 144.43,74.54 144.31,74.42 144.09,74.42 143.97,74.54 143.97,75.36 143.86,75.47 143.63,75.47 143.51,75.36 143.51,74.54 143.4,74.42 143.17,74.42 143.06,74.54 143.06,75.36 142.94,75.47 142.71,75.47 142.6,75.36 142.6,74.54 142.49,74.42 142.26,74.42 142.14,74.54 142.14,75.36 142.03,75.47 141.8,75.47 141.68,75.36 141.68,74.54 141.57,74.42 141.34,74.42 141.23,74.54 141.23,75.36 141.11,75.47 140.88,75.47 140.77,75.36 140.77,74.54 140.66,74.42 140.43,74.42 140.31,74.54 140.31,75.36 140.2,75.47 139.97,75.47 139.86,75.36 139.86,74.54 139.74,74.42 139.5,74.42 139.39,74.54 139.39,77.69 138.8,78.28 136.65,78.28 136.28,78.66 136.28,78.89 136.39,79.01 136.87,79.01 136.98,79.12 136.98,79.35 136.87,79.47 135.52,79.47 135.4,79.59 135.4,79.81 135.51,79.92 136.87,79.92 136.98,80.04 136.98,80.27 136.87,80.38 136.12,80.38 136.01,80.49 136.01,80.85 arc(135.94,81.1) 136.01,81.35 136.01,81.35 arc(136.07,81.6) 136.01,81.85 136.01,81.85 arc(135.94,82.1) 136.01,82.35 arc(136.07,82.6) 136.01,82.85 136.01,82.85 arc(135.83,83.03) 135.58,83.1 135.57,83.1 arc(135.33,83.17) 135.14,83.35 135.14,83.35 arc(134.96,83.53) 134.71,83.6 v2(133.84,83.6)
MEM_DQA4: length 63.2
  TOP w0.109: v2(156.07,52.12) CON1.4
  ART07 w0.114: v2(129.51,84.1) 129.11,85.01 129.08,85.16 129.04,85.64 arc(129.02,85.72) 128.99,85.8 arc(128.91,86.1) 128.99,86.4 arc(129.03,86.5) 129.05,86.61 129.05,87.28 arc(129.07,87.36) 129.12,87.43 arc(129.14,87.65) 129.08,87.85 arc(129.01,88.1) 129.08,88.35 129.08,88.35 arc(129.26,88.53) 129.51,88.6 arc(129.76,88.67) 129.94,88.85 129.95,88.85 arc(130.13,89.03) 130.38,89.1 arc(130.63,89.17) 130.81,89.35 130.81,89.35 arc(131,89.53) 131.25,89.6 arc(131.49,89.67) 131.68,89.85 131.68,89.85 arc(131.86,90.03) 132.11,90.1 132.11,90.1 arc(132.36,90.17) 132.54,90.35 132.55,90.35 arc(132.73,90.53) 132.98,90.6 arc(133.23,90.67) 133.41,90.85 133.41,90.85 arc(133.6,91.03) 133.84,91.1 arc(134.09,91.17) 134.27,91.35 134.28,91.35 arc(134.46,91.53) 134.71,91.6 134.71,91.6 arc(134.96,91.53) 135.14,91.35 135.14,91.35 arc(135.33,91.17) 135.57,91.1 135.58,91.1 arc(135.83,91.03) 136.01,90.85 136.01,90.85 arc(136.19,90.67) 136.44,90.6 arc(136.69,90.53) 136.87,90.35 136.88,90.35 arc(137.06,90.17) 137.31,90.1 arc(137.55,90.03) 137.74,89.85 137.74,89.85 arc(137.92,89.67) 138.17,89.6 138.17,89.6 arc(138.42,89.53) 138.6,89.35 138.61,89.34 arc(138.71,89.22) 138.84,89.14 141.48,86.38 156.88,70.98 158.28,66.92 158.5,65 158.5,62.66 157.27,61.44 157.27,59.56 156.07,58.35 v2(156.07,52.12)
MEM_DQA5: length 62.1
  TOP w0.109: v2(156.32,62.68) CON1.3
  ART07 w0.114: v2(156.32,62.68) 156.16,62.84 156.16,63.89 156.03,64.02 155.18,64.02 155.07,64.13 155.07,64.42 155.18,64.54 155.97,64.54 156.1,64.66 156.1,64.9 156,65.01 155.01,65.01 154.89,65.13 154.89,65.37 155,65.48 155.97,65.48 156.09,65.6 156.09,65.82 155.97,65.94 155,65.94 154.89,66.05 154.89,66.28 155,66.4 155.97,66.4 156.09,66.51 156.09,66.74 155.97,66.85 155,66.85 154.89,66.97 154.89,67.2 155,67.31 155.97,67.31 156.09,67.42 156.09,67.65 155.97,67.77 155,67.77 154.89,67.88 154.89,68.11 155,68.22 155.97,68.22 156.09,68.34 156.09,68.57 155.97,68.68 155,68.68 154.89,68.8 154.89,69.02 155,69.14 155.97,69.14 156.09,69.25 156.09,69.48 155.97,69.6 155,69.6 154.89,69.71 154.89,69.94 155,70.05 155.97,70.05 156.09,70.17 156.09,70.4 155.97,70.51 155,70.51 154.89,70.62 154.89,71.48 147.3,79.07 146.66,79.07 146.38,79.34 146.03,79.34 142.21,83.16 141.86,83.16 140.75,84.26 140.75,85.18 138.38,87.55 138.38,87.6 138.17,87.6 arc(137.92,87.67) 137.74,87.85 137.74,87.85 arc(137.55,88.03) 137.31,88.1 arc(137.06,88.17) 136.88,88.35 136.87,88.35 arc(136.69,88.53) 136.44,88.6 arc(136.19,88.67) 136.01,88.85 136.01,88.85 arc(135.83,89.03) 135.58,89.1 135.57,89.1 arc(135.33,89.17) 135.14,89.35 135.14,89.35 arc(134.96,89.53) 134.71,89.6 134.71,89.6 arc(134.46,89.53) 134.28,89.35 134.27,89.35 arc(134.09,89.17) 133.84,89.1 arc(133.6,89.03) 133.41,88.85 133.41,88.85 arc(133.23,88.67) 132.98,88.6 arc(132.73,88.53) 132.55,88.35 132.54,88.35 arc(132.36,88.17) 132.11,88.1 132.11,88.1 arc(131.86,88.03) 131.68,87.85 131.68,87.85 arc(131.5,87.67) 131.25,87.6 131.25,87.6 arc(131,87.53) 130.81,87.35 130.81,87.35 arc(130.75,87.1) 130.81,86.85 arc(130.88,86.6) 130.81,86.35 130.81,86.35 arc(130.63,86.17) 130.38,86.1 arc(130.13,86.03) 129.95,85.85 129.95,85.85 arc(129.88,85.6) 129.95,85.35 130.38,84.92 v2(130.38,84.6)
MEM_DQA6: length 61.3
  TOP w0.109: v2(153.07,52.12) CON1.16
  ART07 w0.114: v2(132.98,85.1) 132.98,85.42 133.41,85.85 133.41,85.85 arc(133.6,86.03) 133.84,86.1 arc(134.09,86.17) 134.27,86.35 134.28,86.35 arc(134.46,86.53) 134.71,86.6 134.71,86.6 arc(134.96,86.53) 135.14,86.35 135.14,86.35 arc(135.33,86.17) 135.57,86.1 135.58,86.1 arc(135.83,86.03) 136.01,85.85 136.01,85.85 arc(136.19,85.67) 136.44,85.6 arc(136.69,85.53) 136.87,85.35 136.88,85.35 arc(137.06,85.17) 137.31,85.1 arc(137.55,85.03) 137.74,84.85 137.74,84.85 arc(137.92,84.67) 138.17,84.6 138.17,84.6 arc(138.42,84.53) 138.6,84.35 139.02,83.94 139.02,79.4 140.25,78.18 144.26,78.18 146.01,76.42 150.92,71.52 151.26,71.52 151.92,72.17 152.23,72.17 153.48,70.92 153.48,65.98 153.06,65.56 153.06,62.93 153.11,62.88 153.11,62.5 152.85,62.24 152.85,61.93 152.73,61.81 152.21,61.81 152.1,61.7 152.1,61.47 152.21,61.36 152.73,61.36 152.85,61.24 152.85,58.66 152.96,58.54 154.21,58.54 154.32,58.43 154.32,58.2 154.21,58.08 152.96,58.08 152.85,57.97 152.85,57.74 152.96,57.63 154.21,57.63 154.32,57.51 154.32,57.28 154.21,57.17 152.96,57.17 152.85,57.06 152.85,56.83 152.96,56.71 154.21,56.71 154.32,56.6 154.32,56.37 154.21,56.25 152.96,56.25 152.85,56.14 152.85,55.9 154.02,54.72 154.02,53.08 v2(153.07,52.12)
MEM_DQA7: length 60.2
  TOP w0.109: CON1.17 152.82,62.59 v2(152.7,62.71)
  ART07 w0.114: v2(152.7,62.71) 152.7,62.71 152.7,64.01 152.67,64.04 152.67,64.04 152.27,64.44 152.27,66.07 152.38,66.18 153.05,66.18 153.17,66.3 153.17,66.52 153.05,66.64 152.38,66.64 152.27,66.75 152.27,66.98 152.38,67.1 153.05,67.1 153.17,67.21 153.17,67.44 153.05,67.55 152.38,67.55 152.27,67.67 152.27,67.9 152.38,68.01 153.05,68.01 153.17,68.13 153.17,68.35 153.05,68.47 152.38,68.47 152.27,68.58 152.27,68.81 152.38,68.93 153.05,68.93 153.17,69.04 153.17,69.27 153.05,69.38 152.38,69.38 152.27,69.5 152.27,69.72 152.25,69.74 152.25,69.9 152.97,70.62 152.97,70.78 152.81,70.94 152.65,70.94 151.93,70.22 151.76,70.22 151.6,70.38 151.6,70.55 152.32,71.27 152.32,71.43 152.16,71.59 152,71.59 151.28,70.87 151.12,70.87 145.88,76.1 144.82,76.1 144.71,76.22 144.71,76.81 144.59,76.92 144.36,76.92 144.25,76.81 144.25,76.22 144.14,76.1 143.91,76.1 143.79,76.22 143.79,76.81 143.68,76.92 143.45,76.92 143.34,76.81 143.34,76.22 143.22,76.1 142.81,76.1 142.69,76.22 142.69,77 142.6,77.1 142.6,77.7 142.49,77.81 142.19,77.81 142.07,77.7 142.07,76.91 142.24,76.75 142.24,76.22 142.12,76.1 141.94,76.1 141.83,76.22 141.83,76.52 141.73,76.61 141.31,76.61 141.19,76.73 141.19,76.94 141.08,77.06 140.85,77.06 140.73,76.94 140.73,76.73 140.62,76.61 140.16,76.61 140.02,76.75 140.02,77.95 139.06,78.91 138.78,78.91 138.67,79.03 138.67,81.56 138.55,81.68 138.33,81.68 138.21,81.56 138.21,79.03 138.1,78.91 137.86,78.91 137.74,79.03 137.74,81.35 arc(137.81,81.6) 137.74,81.85 137.74,81.85 arc(137.67,82.1) 137.74,82.35 arc(137.81,82.6) 137.74,82.85 137.74,82.85 arc(137.67,83.1) 137.74,83.35 arc(137.81,83.6) 137.74,83.85 137.74,83.85 arc(137.55,84.03) 137.31,84.1 arc(137.06,84.17) 136.88,84.35 136.87,84.35 arc(136.69,84.53) 136.44,84.6 arc(136.19,84.67) 136.01,84.85 136.01,84.85 arc(135.83,85.03) 135.58,85.1 135.57,85.1 arc(135.33,85.17) 135.14,85.35 135.14,85.35 arc(134.96,85.53) 134.71,85.6 134.71,85.6 arc(134.46,85.53) 134.28,85.35 134.27,85.35 v2(133.84,84.6)
MEM_DQA8: length 56.1
  TOP w0.109: v2(150.07,52.12) CON1.28
  ART07 w0.114: v2(150.07,52.12) 150.07,54.8 148.81,56.06 148.81,57.37 148.69,57.48 146.61,57.48 146.49,57.6 146.49,57.83 146.61,57.94 148.69,57.94 148.81,58.05 148.81,58.28 148.69,58.4 146.61,58.4 146.49,58.51 146.49,58.74 146.61,58.85 148.69,58.85 148.81,58.97 148.81,59.2 148.69,59.31 146.61,59.31 146.49,59.43 146.49,59.65 146.61,59.77 148.69,59.77 148.81,59.88 148.81,60.81 149.05,61.05 149.05,62.17 149.41,62.53 149.41,62.88 149.29,63 149.29,64.03 147.56,65.75 142.43,65.75 137.95,70.23 137.95,70.39 139.1,71.53 139.1,71.7 134.48,76.32 134.48,77.89 132.56,79.8 132.56,81.69 v2(132.98,82.1)
MEM_DQA9: length 56
  TOP w0.109: v2(149.82,62.68) CON1.29
  ART07 w0.114: v2(132.98,81.1) 132.98,79.99 135.44,77.53 135.44,75.81 139.63,71.62 139.63,71.45 138.49,70.32 138.49,70.15 138.65,69.99 138.81,69.99 139.95,71.13 140.11,71.13 140.27,70.97 140.27,70.81 139.14,69.67 139.14,69.51 139.3,69.35 139.46,69.35 140.6,70.48 140.76,70.48 140.92,70.32 140.92,70.16 139.78,69.02 139.78,68.86 139.94,68.7 140.11,68.7 141.24,69.84 141.41,69.84 141.57,69.68 141.57,69.51 140.43,68.38 140.43,68.22 140.59,68.05 140.75,68.05 141.89,69.19 142.05,69.19 142.21,69.03 142.21,68.87 141.08,67.73 141.08,67.57 141.24,67.41 141.4,67.41 142.54,68.54 142.7,68.54 142.86,68.38 142.86,68.22 141.72,67.08 141.72,66.92 141.88,66.76 142.05,66.76 143.18,67.9 143.35,67.9 143.52,67.73 143.52,67.57 142.37,66.42 142.37,66.26 142.51,66.12 142.72,66.12 143.84,67.24 144,67.24 144.17,67.07 144.17,66.91 143.61,66.35 143.61,66.19 143.73,66.07 143.98,66.07 144.49,66.59 144.66,66.59 145.18,66.07 147.69,66.07 148.38,65.38 148.54,65.38 148.84,65.69 149,65.69 149.17,65.53 149.17,65.37 148.86,65.06 148.86,64.9 149.02,64.74 149.18,64.74 149.49,65.04 149.65,65.04 149.81,64.88 149.81,64.72 149.57,64.48 149.57,64.31 150.17,63.72 150.17,63.3 149.82,62.95 v2(149.82,62.68)
MEM_DQA10: length 59.4
  TOP w0.109: v2(146.82,62.68) CON1.41
  ART07 w0.114: v2(129.51,82.1) 129.51,81.65 129.83,81.33 129.83,81.33 129.97,81.19 129.97,73.29 137.87,65.4 137.87,64.4 138.01,64.25 139.12,64.25 139.79,63.58 139.79,62.57 139.49,62.27 139.17,62.27 139.03,62.13 139.03,60.99 139.29,60.74 139.29,59.33 139.17,59.21 138.2,59.21 138.08,59.1 138.08,58.87 138.2,58.76 139.26,58.76 139.37,58.64 139.37,58.41 139.26,58.3 138.2,58.3 138.08,58.19 138.08,57.96 138.2,57.84 139.26,57.84 139.37,57.73 139.37,57.5 139.26,57.39 138.2,57.39 138.08,57.27 138.08,57.04 138.2,56.93 139.26,56.93 139.37,56.81 139.37,56.6 139.26,56.49 136.08,56.49 135.97,56.37 135.97,56.14 136.08,56.03 139.53,56.03 139.78,56.28 139.78,59.51 140.26,60 140.26,61.81 140.52,62.06 146.2,62.06 v2(146.82,62.68)
MEM_DQA11: length 59.2
  TOP w0.109: v2(146.57,52.12) CON1.42
  ART07 w0.114: v2(129.51,81.1) 129.51,79.96 129.59,79.89 129.59,73.23 137.55,65.26 137.55,64.03 137.67,63.91 138.61,63.91 138.81,63.72 138.81,62.44 138.34,61.97 137.67,61.97 137.55,61.86 137.55,61.63 137.67,61.52 138.18,61.52 138.29,61.4 138.29,59.99 137.69,59.38 137.69,57.27 137.43,57.01 135.63,57.01 135.53,56.91 135.53,55.24 135.64,55.13 138.11,55.13 138.29,54.94 138.29,54.38 138.05,54.14 135.67,54.14 135.56,54.02 135.56,53.78 135.67,53.67 138.18,53.67 138.29,53.55 138.29,53.32 138.18,53.21 135.67,53.21 135.56,53.1 135.56,52.81 135.73,52.63 146.06,52.63 v2(146.57,52.12)
MEM_DQA12: length 56.1
  TOP w0.109: v2(151.07,52.12) CON1.24
  ART07 w0.114: v2(151.07,52.12) 151.07,54.71 150.81,54.98 150.35,54.98 149.28,56.04 149.28,59.8 149.39,59.91 149.72,59.91 149.86,60.06 149.86,60.93 149.97,61.04 150.23,61.04 150.34,61.15 150.34,61.38 150.23,61.49 149.52,61.49 149.4,61.61 149.4,61.83 149.51,61.95 150.23,61.95 150.34,62.06 150.34,62.84 150.54,63.04 150.54,65.44 150.43,65.56 150.03,65.56 149.92,65.67 149.92,65.9 150.03,66.01 150.43,66.01 150.54,66.13 150.54,66.36 150.43,66.47 150.03,66.47 149.92,66.59 149.92,66.81 150.03,66.93 150.43,66.93 150.54,67.04 150.54,68.04 149.2,69.38 147.36,69.38 146.41,68.43 146.41,66.51 146.3,66.4 146.05,66.4 145.95,66.5 145.95,67.91 145.85,68.01 145.55,68.01 145.45,67.9 145.45,66.88 145.32,66.76 145.06,66.76 144.9,66.92 144.9,67.91 144.82,67.99 143.7,67.99 138.33,73.36 138.33,75.27 138.04,75.57 136.12,75.57 135.75,75.94 135.75,77.66 133.45,79.96 133.45,82.21 v2(133.84,82.6)
MEM_DQA13: length 55.7
  TOP w0.109: v2(150.82,62.68) CON1.25
  ART07 w0.114: v2(133.84,81.6) 133.84,80.02 136.49,77.37 136.49,76.04 136.6,75.92 136.83,75.92 136.95,76.04 136.95,77.43 137.06,77.54 138.49,77.54 138.65,77.38 138.65,73.8 138.76,73.69 139.14,73.69 139.25,73.57 139.25,72.94 139.37,72.83 139.59,72.83 139.71,72.94 139.71,73.57 139.82,73.69 140.05,73.69 140.17,73.57 140.17,72.08 140.29,71.96 140.51,71.96 140.62,72.08 140.62,73.57 140.74,73.69 140.97,73.69 141.08,73.57 141.08,71.06 141.2,70.94 141.41,70.94 141.54,71.07 141.54,73.57 141.65,73.69 143.32,73.69 143.44,73.57 143.44,73.41 143.28,73.25 142.12,73.25 141.99,73.13 141.99,72.88 142.11,72.77 142.38,72.77 142.49,72.66 142.49,72.43 142.38,72.31 142.11,72.31 141.99,72.2 141.99,71.95 142.11,71.83 142.2,71.83 142.31,71.72 142.31,71.49 142.2,71.38 142.11,71.38 141.99,71.26 141.99,70.15 143.54,68.6 145.9,68.6 147.8,70.5 147.8,70.67 147.24,71.22 147.24,71.39 147.36,71.5 147.54,71.5 148.36,70.68 148.36,70.52 148.02,70.19 148.02,70.02 148.18,69.86 148.34,69.86 148.68,70.2 148.84,70.2 150.87,68.16 150.87,62.74 v2(150.82,62.68)
MEM_DQA14: length 59.4
  TOP w0.109: CON1.38 v2(147.57,52.12)
  ART07 w0.114: v2(147.57,52.12) 147.57,52.8 147.37,52.99 138.88,52.99 138.77,53.11 138.77,53.34 138.88,53.45 140.46,53.45 140.57,53.57 140.57,59.32 141.27,60.02 141.27,61.63 141.39,61.74 146.93,61.74 147.26,62.08 147.26,63.63 146.84,64.05 139.77,64.05 130.38,73.44 130.38,81.05 130.02,81.41 130.02,81.41 129.99,81.44 129.99,82.21 v2(130.38,82.6)
MEM_DQA15: length 59.3
  TOP w0.109: v2(147.82,62.68) CON1.37
  ART07 w0.114: v2(130.38,81.6) 130.78,81.19 130.78,78.41 130.9,78.3 132.08,78.3 132.19,78.18 132.19,77.95 132.08,77.84 130.93,77.84 130.78,77.69 130.78,75.54 130.9,75.43 132.94,75.43 133.06,75.32 133.06,75.09 132.94,74.97 130.9,74.97 130.78,74.86 130.78,74.62 130.9,74.5 131.18,74.5 131.3,74.39 131.3,74.16 131.18,74.05 130.9,74.05 130.78,73.93 130.78,73.49 131.49,72.78 131.66,72.78 131.88,73.01 132.07,73.01 132.22,72.86 132.22,72.69 131.98,72.45 131.98,72.29 132.15,72.12 132.32,72.12 133.11,72.91 133.27,72.91 133.43,72.75 133.43,72.59 132.64,71.8 132.64,71.63 132.8,71.47 132.96,71.47 133.75,72.26 133.91,72.26 134.08,72.1 134.08,71.94 133.29,71.15 133.29,70.99 133.45,70.83 133.61,70.83 134.4,71.62 134.56,71.62 134.72,71.45 134.72,71.29 133.93,70.5 133.93,70.34 134.09,70.18 134.25,70.18 135.05,70.97 135.21,70.97 135.37,70.81 135.37,70.65 134.58,69.86 134.58,69.69 134.74,69.53 134.9,69.53 135.69,70.32 135.85,70.32 136.01,70.16 136.01,70 135.22,69.21 135.22,69.05 135.39,68.89 135.55,68.89 136.34,69.68 136.5,69.68 136.66,69.51 136.66,69.35 135.87,68.56 135.87,68.4 136.03,68.24 136.19,68.24 136.98,69.03 137.15,69.03 137.31,68.87 137.31,68.71 136.52,67.92 136.52,67.75 136.68,67.59 136.84,67.59 137.63,68.38 137.79,68.38 137.95,68.22 137.95,68.06 137.16,67.27 137.16,67.11 139.9,64.37 146.97,64.37 147.82,63.52 v2(147.82,62.68)
MEM_DQA16: length 69.5
  TOP w0.109: v2(144.57,52.12) CON1.50
  ART05 w0.114: v2(144.57,52.12) 144.57,52.13 144.57,52.3 145.13,52.85 147.15,52.85 147.53,53.24 147.53,54.75 147.1,55.19 147.1,55.43 147.21,55.54 147.77,55.54 147.89,55.66 147.89,55.88 147.77,56 147.21,56 147.1,56.11 147.1,56.34 147.21,56.46 147.77,56.46 147.89,56.57 147.89,56.8 147.77,56.91 147.21,56.91 147.1,57.03 147.1,57.26 147.21,57.37 147.77,57.37 147.89,57.48 147.89,57.71 147.77,57.83 147.21,57.83 147.1,57.94 147.1,58.17 147.21,58.28 147.77,58.28 147.89,58.4 147.89,58.63 147.77,58.74 147.21,58.74 147.1,58.86 147.1,59.08 147.21,59.2 147.77,59.2 147.89,59.31 147.89,59.54 147.77,59.66 147.21,59.66 147.1,59.77 147.1,59.8 146.85,60.05 146.85,61.4 147.26,61.82 147.26,64.18 141.8,69.65 141.8,73.45 139.67,75.58 139.51,75.58 138.83,74.91 138.67,74.91 138.51,75.07 138.51,75.23 139.18,75.91 139.18,76.07 138.34,76.92 138.34,77.81 135.94,80.21 135.94,81.1 arc(135.96,81.23) 136.01,81.35 arc(136.07,81.6) 136.01,81.85 136.01,81.85 arc(135.94,82.1) 136.01,82.35 arc(136.08,82.6) 136.01,82.85 136.01,82.85 arc(135.94,83.1) 136.01,83.35 arc(136.07,83.6) 136.01,83.85 arc(135.94,84.1) 136.01,84.35 arc(136.07,84.6) 136.01,84.85 arc(135.94,85.1) 136.01,85.35 arc(136.07,85.6) 136.01,85.85 arc(135.83,86.03) 135.58,86.1 135.57,86.1 arc(135.33,86.17) 135.14,86.35 135.14,86.35 arc(134.96,86.53) 134.71,86.6 134.71,86.6 arc(134.46,86.67) 134.28,86.85 134.27,86.85 arc(134.09,87.03) 133.84,87.1 arc(133.6,87.17) 133.41,87.34 133.41,87.35 arc(133.22,87.53) 132.98,87.6 arc(132.73,87.67) 132.55,87.85 132.54,87.85 arc(132.36,88.03) 132.11,88.1 arc(131.86,88.17) 131.68,88.35 131.68,88.35 arc(131.49,88.53) 131.25,88.6 arc(131,88.67) 130.81,88.85 130.81,88.85 arc(130.63,89.03) 130.38,89.1 arc(130.13,89.17) 129.95,89.35 129.94,89.35 arc(129.76,89.53) 129.51,89.6 arc(129.26,89.67) 129.08,89.85 129.08,89.85 arc(128.65,90.1) 128.22,89.85 128.21,89.85 arc(128.03,89.67) 127.78,89.6 127.78,89.6 arc(127.53,89.53) 127.35,89.35 127.35,89.35 arc(127.16,89.17) 126.92,89.1 126.91,89.1 arc(126.66,89.03) 126.48,88.85 126.48,88.85 arc(126.3,88.67) 126.05,88.6 arc(125.8,88.53) 125.62,88.35 125.61,88.35 arc(125.43,88.17) 125.18,88.1 arc(124.94,88.03) 124.75,87.85 124.75,87.85 arc(124.57,87.67) 124.32,87.6 124.32,87.6 arc(124.07,87.53) 123.89,87.35 123.88,87.35 arc(123.7,87.17) 123.45,87.1 123.45,87.1 arc(123.2,87.03) 123.02,86.85 arc(122.95,86.6) 123.02,86.35 arc(123.08,86.1) 123.02,85.85 arc(122.95,85.6) 123.02,85.35 arc(123.22,85.05) 123.45,84.79 v2(123.45,84.6)
MEM_DQA17: length 69.3
  TOP w0.109: v2(144.82,62.68) CON1.49
  ART05 w0.114: v2(144.82,62.68) 144.88,62.74 144.88,63.54 145.02,63.69 145.33,63.69 145.45,63.81 145.45,63.97 145.34,64.08 145.07,64.08 144.96,64.2 144.96,64.45 145.28,64.77 145.28,64.93 145.11,65.1 144.95,65.1 144.69,64.85 144.53,64.85 144.31,65.07 144.31,65.23 144.57,65.48 144.57,65.67 144.41,65.83 144.24,65.83 143.57,65.15 143.41,65.15 143.25,65.32 143.25,65.48 143.92,66.15 143.92,66.31 143.75,66.48 143.59,66.48 142.58,65.47 142.41,65.47 142.25,65.63 142.25,65.79 143.26,66.81 143.26,66.97 143.1,67.13 142.94,67.13 141.93,66.12 141.77,66.12 141.61,66.28 141.61,66.44 142.62,67.45 142.62,67.61 142.46,67.78 142.29,67.78 141.28,66.76 141.12,66.76 140.96,66.93 140.96,67.09 141.97,68.1 141.97,68.26 141.81,68.42 141.65,68.42 140.46,67.24 140.29,67.24 140.13,67.39 140.13,67.55 141.32,68.75 141.32,68.91 141.16,69.07 141,69.07 139.8,67.86 139.64,67.86 139.49,68.01 139.49,68.2 140.68,69.39 140.68,69.55 140.52,69.72 140.35,69.72 139.16,68.52 138.98,68.52 138.83,68.67 138.83,68.83 140.03,70.04 140.03,70.2 139.87,70.36 139.71,70.36 138.56,69.22 138.4,69.22 138.24,69.38 138.24,69.54 139.39,70.69 139.39,70.85 139.21,71.02 139.05,71.02 138.6,70.56 138.43,70.56 138.27,70.72 138.27,70.88 138.73,71.34 138.73,71.5 136.93,73.3 136.93,78.1 134.21,80.82 134.21,81.1 arc(134.23,81.23) 134.28,81.35 arc(134.34,81.6) 134.28,81.85 134.27,81.85 arc(134.21,82.1) 134.28,82.35 arc(134.34,82.6) 134.28,82.85 134.28,82.85 arc(134.21,83.1) 134.28,83.35 arc(134.34,83.6) 134.28,83.85 arc(134.21,84.1) 134.28,84.35 arc(134.34,84.6) 134.28,84.85 134.27,84.85 arc(134.09,85.03) 133.84,85.1 arc(133.6,85.17) 133.41,85.35 133.41,85.35 arc(133.23,85.53) 132.98,85.6 arc(132.73,85.67) 132.55,85.85 132.54,85.85 arc(132.36,86.03) 132.11,86.1 arc(131.86,86.17) 131.68,86.35 131.68,86.35 arc(131.49,86.53) 131.25,86.6 arc(131,86.67) 130.81,86.85 130.81,86.85 arc(130.63,87.03) 130.38,87.1 arc(130.13,87.17) 129.95,87.35 129.94,87.35 arc(129.76,87.53) 129.51,87.6 arc(129.26,87.67) 129.08,87.85 129.08,87.85 arc(128.65,88.1) 128.22,87.85 128.21,87.85 arc(128.03,87.67) 127.78,87.6 127.78,87.6 arc(127.53,87.53) 127.35,87.35 127.35,87.35 arc(127.16,87.17) 126.92,87.1 126.91,87.1 arc(126.66,87.03) 126.48,86.85 126.48,86.85 arc(126.3,86.67) 126.05,86.6 arc(125.8,86.53) 125.62,86.35 125.61,86.35 arc(125.43,86.17) 125.18,86.1 arc(124.94,86.03) 124.75,85.85 124.75,85.85 124.32,85.42 v2(124.32,85.1)
MEM_DQA18: length 66.2
  TOP w0.109: v2(141.57,52.12) CON1.62
  ART05 w0.114: v2(141.57,52.12) 141.76,52.12 141.89,52.26 141.89,52.49 141.77,52.6 140.34,52.6 140.23,52.72 140.23,52.97 140.34,53.09 143.11,53.09 143.2,53.18 143.2,53.48 143.09,53.59 140.26,53.59 140.13,53.73 140.13,54.04 140.25,54.15 142.24,54.15 142.48,54.39 142.48,54.73 142.23,54.98 142.23,59.7 142.37,59.84 142.63,59.84 142.74,59.72 142.74,55.11 142.88,54.98 143.1,54.98 143.23,55.11 143.23,60.5 142.99,60.74 142.44,60.74 142.26,60.91 142.26,62.49 142.36,62.59 142.36,62.93 142.12,63.17 141.4,63.17 141.1,63.47 141.1,64.22 140.04,65.29 139.77,65.29 137.03,68.03 135.17,68.03 135.05,68.14 135.05,72.34 134.76,72.63 130.93,72.63 130.81,72.74 130.81,81.35 arc(130.88,81.6) 130.81,81.85 130.81,81.85 arc(130.74,82.1) 130.81,82.35 arc(130.88,82.6) 130.81,82.85 130.81,82.85 arc(130.63,83.03) 130.38,83.1 arc(130.13,83.17) 129.95,83.35 129.94,83.35 arc(129.76,83.53) 129.51,83.6 arc(129.26,83.67) 129.08,83.85 129.08,83.85 arc(128.89,84.03) 128.65,84.1 arc(128.4,84.17) 128.22,84.35 128.21,84.35 arc(128.03,84.53) 127.78,84.6 v2(126.92,84.6)
MEM_DQA19: length 65.9
  TOP w0.109: v2(141.23,62.74) 141.32,62.65 CON1.63
  ART05 w0.114: v2(141.23,62.74) 141.23,62.9 140.79,63.34 140.79,64.09 139.9,64.97 139.64,64.97 136.9,67.71 134.85,67.71 134.74,67.83 134.74,70.3 134.57,70.47 129.44,70.47 129.33,70.58 129.33,70.82 129.44,70.94 134.59,70.94 134.71,71.05 134.71,71.28 134.59,71.4 129.44,71.4 129.33,71.51 129.33,71.74 129.44,71.85 134.59,71.85 134.71,71.97 134.71,72.2 134.6,72.31 129.44,72.31 129.33,72.42 129.33,72.62 129.43,72.72 130.37,72.72 130.48,72.83 130.48,72.99 130.39,73.09 129.93,73.09 129.83,73.19 129.83,73.4 129.94,73.52 130.38,73.52 130.49,73.63 130.49,73.86 130.38,73.97 129.94,73.97 129.83,74.09 129.83,74.32 129.94,74.43 130.38,74.43 130.49,74.55 130.49,74.77 130.38,74.89 129.94,74.89 129.83,75 129.83,75.23 129.94,75.35 130.38,75.35 130.49,75.46 130.49,75.69 130.38,75.8 129.94,75.8 129.83,75.92 129.83,76.15 129.94,76.26 130.38,76.26 130.49,76.37 130.49,76.6 130.38,76.72 129.94,76.72 129.83,76.83 129.83,77.06 129.94,77.17 130.38,77.17 130.49,77.29 130.49,77.52 130.38,77.63 129.94,77.63 129.83,77.75 129.83,77.97 129.94,78.09 130.38,78.09 130.49,78.2 130.49,78.43 130.38,78.55 129.94,78.55 129.83,78.66 129.83,78.9 129.94,79.02 130.38,79.02 130.49,79.13 130.49,79.36 130.38,79.47 129.48,79.47 129.36,79.59 129.36,79.82 129.48,79.93 130.38,79.93 130.49,80.04 130.49,80.27 130.38,80.39 129.78,80.39 129.67,80.49 129.67,80.65 129.78,80.76 130.17,80.76 130.25,80.84 130.25,81.02 130.03,81.25 arc(129.98,81.3) 129.95,81.35 arc(129.9,81.45) 129.88,81.56 arc(129.89,81.71) 129.95,81.85 129.95,81.85 arc(130.01,82.1) 129.95,82.35 129.94,82.36 arc(129.76,82.53) 129.51,82.6 arc(129.26,82.67) 129.08,82.85 129.08,82.85 arc(128.89,83.03) 128.65,83.1 arc(128.4,83.17) 128.22,83.35 127.78,84.09 arc(127.78,84.1) v2(127.78,84.1)
