# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
QSFPDD_RXP3: length 53.9
  TOP w0.091: U12.25 57.71,66.34
  ART07 w0.097: 85.13,89.22 85.15,89.22 85.18,89.19 85.31,89.19 arc(85.35,89.2) 85.4,89.21 arc(85.55,89.26) 85.67,89.36 arc(85.96,89.58) 86.3,89.7 arc(86.45,89.77) 86.56,89.89 86.56,89.9 arc(86.78,90.11) 87.08,90.19 87.08,90.19 arc(87.28,90.25) 87.43,90.39 87.43,90.4 arc(87.65,90.61) 87.94,90.69 87.95,90.69 arc(88.15,90.75) 88.29,90.89 88.3,90.9 arc(88.51,91.11) 88.81,91.19 88.81,91.19 arc(89.01,91.25) 89.16,91.39 89.16,91.4 arc(89.38,91.61) 89.67,91.69 89.68,91.69 arc(89.88,91.75) 90.03,91.89 90.03,91.9 arc(90.24,92.11) 90.54,92.19 90.54,92.19 arc(90.74,92.25) 90.89,92.39 90.89,92.4 arc(91.11,92.61) 91.41,92.69 91.41,92.69 arc(91.61,92.75) 91.76,92.89 91.76,92.9 arc(91.98,93.11) 92.27,93.19 92.28,93.19 arc(92.48,93.25) 92.62,93.39 92.63,93.4 arc(92.68,93.6) 92.63,93.8 arc(92.55,94.1) 92.63,94.4 arc(92.68,94.6) 92.63,94.8 92.62,94.81 arc(92.55,95.1) 92.63,95.4 92.63,95.4 arc(92.68,95.6) 92.63,95.8 arc(92.55,96.1) 92.63,96.4 arc(92.84,96.61) 93.14,96.69 93.14,96.69 arc(93.31,96.73) 93.45,96.84 93.43,96.93 93.14,97.1
  ART07 w0.109: 85.13,89.22 84.68,89.22 arc(84.34,89.15) 84.05,88.96 84.05,88.95 arc(83.85,88.82) 83.62,88.77 83.4,88.77 83.28,88.89 83.06,88.89 82.94,88.77 82.5,88.77 82.38,88.89 82.16,88.89 82.04,88.77 79.93,88.77 arc(79.49,88.68) 79.11,88.43 78.44,87.76 arc(78.02,87.13) 77.87,86.39 77.87,85.72 arc(77.75,85.11) 77.4,84.59 66.86,74.05 arc(66.38,73.34) 66.22,72.49 66.22,72.24 arc(66.08,71.58) 65.71,71.02 65.22,70.53 60.56,65.87 60.49,65.8 arc(60.19,65.6) 59.84,65.53 59.33,65.53 arc(59.17,65.56) 59.03,65.66 58.84,65.85 arc(58.6,66) 58.33,66.06 57.99,66.06 57.71,66.34
QSFPDD_RXP4: length 63.8
  TOP w0.091: U12.55 51.05,63.54 51.85,63.54
  ART05 w0.097: U1.BP7 90.83,95.77 90.94,95.74 arc(91.15,95.57) 91.41,95.51 arc(91.61,95.45) 91.76,95.31 91.76,95.3 arc(91.81,95.1) 91.76,94.9 arc(91.68,94.6) 91.76,94.3 arc(91.81,94.12) 91.78,93.93 arc(91.7,93.62) 91.75,93.31 arc(91.79,93.09) 91.75,92.87 arc(91.72,92.81) 91.71,92.74 arc(91.69,92.61) 91.71,92.47 arc(91.72,92.4) 91.74,92.34 91.76,92.29 91.79,92.26 91.79,91.94 91.57,91.72 91.52,91.72 91.41,91.69 arc(91.11,91.58) 90.88,91.37 arc(90.73,91.24) 90.54,91.19 90.47,91.19 arc(90.24,91.13) 90.06,90.96 90.03,90.89 arc(89.88,90.75) 89.68,90.69 89.67,90.69 arc(89.4,90.63) 89.19,90.44 arc(89,90.27) 88.76,90.19 arc(88.51,90.11) 88.32,89.93 arc(88.29,89.89) 88.26,89.86 arc(88.14,89.77) 88,89.71 arc(87.96,89.7) 87.91,89.69 arc(87.65,89.62) 87.46,89.44 arc(87.27,89.27) 87.03,89.19 arc(86.77,89.11) 86.58,88.93 arc(86.55,88.89) 86.52,88.85 arc(86.41,88.76) 86.27,88.71 arc(86.23,88.7) 86.18,88.69 arc(85.9,88.61) 85.7,88.4 85.7,88.39 arc(85.67,88.36) 85.65,88.33 arc(85.51,88.23) 85.35,88.19 arc(85.35,88.19) 85.35,88.19 85.12,88.19 arc(85.09,88.2) 85.08,88.21 85.07,88.22 85.05,88.22
  ART05 w0.109: 51.85,63.54 52.13,63.26 52.32,63.26 arc(52.68,63.11) 52.83,62.75 52.83,62.36 arc(52.9,61.98) 53.12,61.66 53.52,61.26 arc(54.13,60.85) 54.86,60.71 57.43,60.71 arc(58.11,60.84) 58.68,61.23 58.98,61.52 62.47,65.01 arc(62.82,65.53) 62.94,66.14 62.94,66.27 arc(63,66.57) 63.17,66.83 66.37,70.03 arc(67.13,70.54) 68.03,70.72 68.15,70.72 arc(68.64,70.82) 69.06,71.1 70.41,72.44 76.79,78.83 76.98,79.01 arc(77.54,79.81) 77.78,80.76 arc(77.79,80.87) 77.79,80.97 77.79,81.88 77.69,81.99 77.69,82.17 77.79,82.28 77.79,83.52 arc(77.86,83.86) 78.05,84.15 78.87,84.97 arc(79.15,85.15) 79.47,85.22 79.69,85.22 79.81,85.34 80.03,85.34 80.15,85.22 80.59,85.22 80.71,85.34 80.93,85.34 81.05,85.22 81.51,85.22 81.63,85.34 81.85,85.34 81.97,85.22 82.19,85.22 82.31,85.34 82.53,85.34 82.65,85.22 82.89,85.22 arc(83.37,85.31) 83.78,85.59 84.15,85.96 arc(84.33,86.17) 84.48,86.4 arc(84.5,86.45) 84.51,86.51 84.55,87 arc(84.55,87.02) 84.55,87.04 84.55,87.83 arc(84.66,88.1) 84.94,88.22 85.05,88.22
QSFPDD_RXP5: length 56.5
  TOP w0.091: U12.60 54.78,63.94
  ART05 w0.097: 85.28,89.22 85.3,89.22 85.31,89.21 arc(85.33,89.2) 85.35,89.19 85.47,89.19 arc(85.6,89.27) 85.7,89.39 85.7,89.4 arc(85.92,89.62) 86.21,89.69 86.22,89.69 arc(86.42,89.75) 86.56,89.9 86.57,89.9 arc(86.78,90.12) 87.08,90.19 87.08,90.19 arc(87.28,90.25) 87.43,90.4 87.43,90.4 arc(87.65,90.62) 87.95,90.69 87.95,90.69 arc(88.15,90.75) 88.3,90.9 88.3,90.9 arc(88.52,91.12) 88.81,91.19 88.81,91.19 arc(89.01,91.25) 89.16,91.4 89.16,91.4 arc(89.38,91.62) 89.68,91.69 89.68,91.69 arc(89.88,91.75) 90.03,91.9 90.03,91.9 arc(90.25,92.12) 90.54,92.19 90.55,92.19 arc(90.75,92.25) 90.89,92.39 90.89,92.4 arc(90.95,92.6) 90.89,92.8 arc(90.82,93.1) 90.89,93.4 arc(90.95,93.57) 90.92,93.74 90.83,93.77 U1.BV7
  ART05 w0.109: 85.28,89.22 85.04,89.22 arc(84.48,89.1) 84,88.79 83.58,88.37 arc(83.42,88.13) 83.36,87.85 83.36,86.65 arc(83.32,86.55) 83.22,86.51 83.09,86.51 82.97,86.63 82.75,86.63 82.63,86.51 82.41,86.51 82.29,86.63 82.07,86.63 81.95,86.51 81.24,86.51 81.12,86.63 80.9,86.63 80.78,86.51 80.29,86.51 80.16,86.63 79.95,86.63 79.82,86.51 79.5,86.51 arc(79.13,86.44) 78.81,86.22 76.84,84.26 arc(76.62,83.93) 76.55,83.55 76.55,81.13 arc(76.32,79.97) 75.66,78.99 69.44,72.77 arc(68.68,72.26) 67.79,72.08 arc(67.18,71.96) 66.66,71.62 65.24,70.19 62.82,67.78 62.33,67.28 arc(62.12,66.97) 62.04,66.6 62.04,66.37 arc(61.95,65.87) 61.66,65.45 61.11,64.9 58.31,62.1 arc(57.89,61.82) 57.4,61.72 56.63,61.72 arc(56.26,61.79) 55.95,62 arc(55.83,62.19) 55.78,62.42 55.78,63.1 arc(55.62,63.49) 55.22,63.66 55.06,63.66 54.78,63.94
QSFPDD_RXP6: length 66.9
  TOP w0.091: U12.52 51.85,65.94
  ART07 w0.097: 93.14,95.1 93.43,94.93 93.46,94.82 arc(93.45,94.82) 93.45,94.81 arc(93.42,94.55) 93.49,94.3 arc(93.71,94.09) 94,94.01 94.01,94.01 arc(94.21,93.95) 94.36,93.81 94.36,93.8 arc(94.41,93.6) 94.36,93.4 arc(94.28,93.1) 94.36,92.8 arc(94.41,92.6) 94.36,92.4 arc(94.28,92.12) 94.34,91.84 arc(94.36,91.79) 94.37,91.75 arc(94.32,91.42) 94.06,91.21 arc(94.02,91.2) 93.97,91.19 arc(93.72,91.12) 93.53,90.95 arc(93.5,90.92) 93.47,90.89 arc(93.47,90.88) 93.46,90.88 93.35,90.78 arc(93.33,90.77) 93.32,90.76 93.16,90.71 arc(93.11,90.69) 93.06,90.69 arc(92.82,90.61) 92.64,90.44 arc(92.45,90.26) 92.2,90.19 92.17,90.18 arc(91.93,90.1) 91.76,89.92 91.74,89.89 arc(91.59,89.74) 91.39,89.69 91.39,89.69 arc(91.09,89.61) 90.88,89.39 90.88,89.39 arc(90.73,89.24) 90.53,89.19 90.48,89.19 arc(90.22,89.12) 90.04,88.93 90.01,88.89 arc(89.86,88.74) 89.66,88.69 89.66,88.69 arc(89.36,88.61) 89.15,88.39 89.14,88.39 arc(89,88.24) 88.79,88.19 88.79,88.19 arc(88.5,88.11) 88.28,87.89 88.28,87.89 arc(88.13,87.74) 87.93,87.69 87.93,87.69 arc(87.63,87.61) 87.41,87.39 87.41,87.39 arc(87.26,87.24) 87.06,87.19 87.06,87.19 arc(86.76,87.11) 86.55,86.89 86.54,86.89 arc(86.4,86.74) 86.2,86.69 86.19,86.69 arc(85.9,86.61) 85.68,86.39 arc(85.54,86.25) 85.34,86.19 85.15,86.19 85.12,86.22 85.1,86.22
  ART07 w0.109: 85.1,86.22 85.01,86.22 arc(84.79,86.17) 84.6,86.04 arc(84.45,85.82) 84.4,85.56 84.4,84.5 arc(84.34,84.22) 84.18,83.98 83.95,83.74 arc(83.75,83.61) 83.51,83.57 83.29,83.57 83.17,83.69 82.95,83.69 82.83,83.57 82.61,83.57 82.49,83.69 82.27,83.69 82.15,83.57 80,83.57 arc(79.54,83.47) 79.15,83.21 79.08,83.15 arc(78.77,82.68) 78.66,82.13 78.66,81.41 arc(78.47,80.44) 77.93,79.63 65.47,67.17 65.12,66.82 arc(64.85,66.43) 64.76,65.96 64.76,65.86 arc(64.68,65.46) 64.45,65.12 60.71,61.38 arc(60,60.9) 59.15,60.73 54.46,60.73 arc(53.96,60.83) 53.54,61.11 53.27,61.38 arc(52.93,61.9) 52.8,62.51 52.8,65.15 arc(52.66,65.51) 52.3,65.66 52.13,65.66 51.85,65.94
QSFPDD_RXP7: length 58.5
  TOP w0.091: U12.63 54.78,66.34
  ART07 w0.097: 85.05,88.22 85.07,88.22 85.1,88.19 85.35,88.19 arc(85.55,88.25) 85.7,88.4 85.7,88.4 arc(85.91,88.61) 86.21,88.69 86.21,88.69 arc(86.4,88.74) 86.55,88.87 arc(86.55,88.88) 86.56,88.89 86.56,88.9 arc(86.76,89.1) 87.03,89.19 arc(87.05,89.19) 87.07,89.2 arc(87.28,89.27) 87.45,89.41 arc(87.66,89.6) 87.94,89.7 arc(88.15,89.77) 88.32,89.92 arc(88.48,90.08) 88.7,90.17 arc(88.76,90.19) 88.83,90.19 arc(89.01,90.24) 89.14,90.37 arc(89.39,90.59) 89.71,90.7 arc(89.89,90.76) 90.03,90.89 90.1,91.03 arc(90.23,91.15) 90.39,91.19 90.55,91.19 arc(90.75,91.25) 90.9,91.4 90.92,91.44 arc(91.14,91.66) 91.44,91.74 91.44,91.74 arc(91.64,91.79) 91.79,91.93 91.79,91.94 arc(92.01,92.16) 92.3,92.24 92.3,92.24 arc(92.51,92.29) 92.65,92.44 92.66,92.44 arc(92.87,92.66) 93.17,92.74 93.24,92.74 arc(93.36,92.76) 93.45,92.84 93.43,92.93 93.14,93.1
  ART07 w0.109: 85.05,88.22 84.89,88.22 arc(84.65,88.17) 84.46,88.04 84.26,87.85 arc(84.1,87.6) 84.04,87.31 84.04,86.97 arc(84.01,86.82) 83.93,86.7 83.87,86.64 arc(83.7,86.53) 83.51,86.49 83.24,86.49 83.12,86.61 82.9,86.61 82.78,86.49 82.35,86.49 82.23,86.61 82.01,86.61 81.89,86.49 80.04,86.49 arc(79.96,86.49) 79.88,86.47 arc(79.69,86.39) 79.53,86.28 arc(79.47,86.21) 79.41,86.14 79.38,86.07 arc(79.38,86.07) 79.38,86.07 arc(79.38,86.07) 79.38,86.07 arc(79.3,85.87) 79.27,85.65 79.27,84.91 arc(79.26,84.86) 79.25,84.81 arc(79.17,84.68) 79.08,84.57 78.7,84.19 77.75,83.23 arc(77.43,82.76) 77.32,82.19 77.32,81.56 arc(77.11,80.55) 76.54,79.69 64.59,67.75 64.2,67.35 arc(64.06,67.26) 63.9,67.23 63.6,67.23 arc(63.29,67.17) 63.03,66.99 58.1,62.07 arc(57.94,61.96) 57.76,61.92 56.43,61.92 arc(56.25,61.96) 56.09,62.06 55.98,62.18 arc(55.83,62.4) 55.78,62.67 55.78,65.55 arc(55.63,65.91) 55.27,66.06 55.06,66.06 54.78,66.34
QSFPDD_T_INITMODE: length 18.1
  TOP w0.109: U11.C1 54.05,84.7 v2(54.04,84.71) ; v2(55.39,70.99) 55.54,71.14 U12.31
  ART16 w0.114: v2(54.04,84.71) 54.45,84.71 54.81,84.35 54.81,77.47 54.05,76.71 54.05,71.73 54.79,70.99 v2(55.39,70.99)
QSFPDD_T_INTN: length 19.9
  TOP w0.109: U12.28 56.9,68.73 v2(55.83,68.73) ; v2(64.07,81.66) 65.54,83.13 U10.C4
  ART16 w0.114: v2(55.83,68.73) 56.33,68.73 64.08,76.48 64.08,81.65 v2(64.07,81.66)
QSFPDD_T_MODPRSN: length 20.4
  TOP w0.109: v2(64.07,82.68) 65.09,83.7 U10.C3 ; U12.27 57.73,67.94 58.27,68.48 v2(58.27,68.73)
  ART16 w0.114: v2(58.27,68.73) 58.27,70.2 64.51,76.45 64.51,82.24 v2(64.07,82.68)
QSFPDD_T_MODSELN: length 47.1
  TOP w0.109: v2(64.07,85.72) 65.1,84.7 U10.C1 ; U12.8 47.03,70.74 46.66,71.12 v2(45.62,71.12)
  ART16 w0.114: v2(64.07,85.72) 65.06,84.73 66.55,84.73 66.93,84.35 66.93,73.79 62.96,69.82 60.55,69.82 58.34,67.61 50.54,67.61 50.14,67.21 45.77,67.21 44.73,68.25 44.73,69.87 45.62,70.76 v2(45.62,71.12)
QSFPDD_T_RESETN: length 41.4
  TOP w0.109: U12.9 47.3,69.94 46.66,70.59 v2(46.2,70.59) ; U10.C2 64.99,84.2 64.48,83.69 v2(63.27,83.69)
  ART16 w0.114: v2(63.27,83.69) 63.8,83.16 64.5,83.16 64.95,82.72 64.95,72.62 62.56,70.23 60.42,70.23 58.32,68.12 50.57,68.12 50.04,67.59 47.11,67.59 46.94,67.77 46.94,70.31 46.66,70.59 v2(46.2,70.59)
  BOTTOM w0.109: R200.2 R199.1 v2(63.27,83.69)
QSFPDD_T_SCL: length 21
  TOP w0.109: U12.11 47.44,68.34 v2(47.42,68.33) ; U11.C3 54.3,83.7 v2(54.04,83.44)
  ART16 w0.114: v2(54.04,83.44) 54.04,83.22 53.64,82.83 52.78,82.83 51.76,81.81 51.76,77.42 50.7,76.35 50.7,70.15 50.31,69.77 48.87,69.77 v2(47.42,68.33)
QSFPDD_T_SDA: length 19.3
  TOP w0.109: v2(54.04,82.17) 55,83.13 U11.C4 ; v2(49.22,68.05) 49.22,67.82 48.95,67.54 U12.12
  ART16 w0.114: v2(54.04,82.17) 54.04,79.39 52.7,78.05 52.7,71.53 51.32,70.14 51.32,69.7 50.15,68.53 49.71,68.53 v2(49.22,68.05)
QSFPDD_TEMP4N: length 377.5
  TOP w0.254: U31.9 170.7,109.92 170.7,108.66 C1589.2 170.69,108.29 170.69,107.62 v3(170.83,107.48)
  ART03 w0.254: v3(170.83,107.48) 170.55,107.76 170.55,108.12 173.66,111.23 173.66,114.33 175.79,116.46 177.6,116.46 184.35,123.22 187.76,123.22 189.84,121.13 191.77,121.13 192.3,120.6 192.3,119.96 193.44,118.82 193.9,118.82 194.51,118.21 194.51,108.33 205.26,97.58 205.26,37.49 203.66,35.89 198.91,35.89 191.44,28.42 178.31,28.42 174.32,24.43 174.32,19.38 172.63,17.69 170.57,17.69 164.19,11.3 151.26,11.3 149.83,9.88 146.08,9.88 145.08,10.88 145.08,22.28 141.02,26.34 130.2,26.34 128.27,28.27 123.83,28.27 122.1,26.54 122.1,25.27 119.56,22.73 119.56,17.02 114.27,11.73 104.25,11.73 101.45,14.53 97.36,14.53 94.74,17.14 94.74,26.9 90.22,31.42 87.27,31.42 85.22,33.48 85.22,39.01 86.03,39.83 86.03,41.02 84.94,42.11 84.56,42.11 84.25,42.42 84.25,43.51 82.98,44.78 82.98,58.19 82.52,58.65 82.52,64.36 81.76,65.13 73.69,65.13 72.54,66.27 72.54,73.63 70.41,75.77 68.43,75.77 68.17,76.02 v3(68.17,76.2)
  BOTTOM w0.254: v3(68.17,76.2) 67.79,76.2 65.3,78.69 60.66,78.69 58.42,80.92 50.36,80.92 Q6.B 48.64,80.75 Q6.C
QSFPDD_TEMP4P: length 376.9
  TOP w0.254: v3(169.92,107.47) 170.18,107.72 170.18,108.29 C1589.1 170.19,108.68 U31.8
  ART03 w0.254: v3(67.54,75.69) 67.96,75.69 68.27,75.39 70.25,75.39 72.16,73.48 72.16,66.11 73.53,64.74 81.6,64.74 82.14,64.21 82.14,58.49 82.6,58.03 82.6,44.62 83.87,43.35 83.87,42.26 84.4,41.73 84.78,41.73 85.65,40.86 85.65,39.99 84.84,39.17 84.84,33.32 87.12,31.04 90.06,31.04 94.36,26.74 94.36,16.99 97.2,14.15 101.3,14.15 104.09,11.35 114.43,11.35 119.94,16.87 119.94,22.58 122.48,25.12 122.48,26.39 123.98,27.89 128.11,27.89 130.04,25.96 140.86,25.96 144.7,22.12 144.7,10.72 145.92,9.5 149.99,9.5 151.41,10.92 164.34,10.92 170.73,17.31 172.79,17.31 174.7,19.22 174.7,24.28 178.47,28.04 191.6,28.04 199.07,35.51 203.82,35.51 205.64,37.33 205.64,97.74 194.89,108.48 194.89,118.37 194.06,119.2 193.6,119.2 192.68,120.12 192.68,120.76 191.93,121.51 190,121.51 187.91,123.6 184.2,123.6 177.44,116.84 175.64,116.84 173.28,114.48 173.28,111.38 170.17,108.27 170.17,107.72 169.92,107.47 v3(169.92,107.47)
  BOTTOM w0.254: Q6.E 50.33,80.54 58.26,80.54 60.5,78.31 65.15,78.31 67.54,75.92 v3(67.54,75.69)
QSFPDD_TXN0: length 82.5
  TOP w0.091: 57.71,75.94 U12.37
  ART07 w0.097: 85.22,100.19 85.35,100.19 arc(85.61,100.13) 85.82,99.96 85.93,99.93 U1.BE2
  ART07 w0.109: 57.71,75.94 58.03,75.62 58.38,75.62 arc(58.54,75.65) 58.67,75.74 59.06,76.13 arc(59.25,76.26) 59.47,76.3 60.81,76.3 arc(61.07,76.25) 61.29,76.1 61.59,75.8 arc(61.73,75.59) 61.78,75.34 61.78,73.88 61.72,73.58 arc(61.68,73.49) 61.62,73.41 60.18,71.96 58.34,70.13 arc(57.78,69.75) 57.11,69.62 49.27,69.62 arc(48.01,69.87) 46.93,70.59 46.48,71.04 arc(45.8,72.06) 45.57,73.25 45.57,77.12 arc(45.92,78.9) 46.92,80.4 53.21,86.69 arc(54.53,87.57) 56.09,87.88 58.8,87.88 arc(59.81,88.08) 60.66,88.66 60.98,88.98 61.51,89.5 arc(62.25,90) 63.12,90.17 63.46,90.17 arc(64.39,90.35) 65.17,90.88 65.96,91.67 arc(66.27,91.87) 66.64,91.95 67.03,91.95 arc(67.19,91.98) 67.33,92.07 67.71,92.45 arc(67.88,92.71) 67.94,93.01 arc(68.21,93.66) 68.86,93.93 69.61,93.93 arc(69.81,93.97) 69.97,94.08 70.46,94.56 arc(70.59,94.76) 70.63,95 70.63,95.52 arc(70.73,96.02) 71.02,96.44 arc(71.66,96.88) 72.43,97.03 76.3,97.03 arc(76.82,97.08) 77.31,97.25 arc(77.67,97.46) 78,97.73 79.5,99.24 79.67,99.4 arc(80.22,99.77) 80.86,99.9 83.39,99.9 arc(83.41,99.9) 83.44,99.91 83.6,99.99 arc(83.64,100.01) 83.67,100.04 arc(83.87,100.17) 84.1,100.22 85.19,100.22 85.22,100.19
QSFPDD_TXN1: length 52.1
  TOP w0.091: 48.92,75.54 U12.2
  ART07 w0.097: 85.19,98.19 85.35,98.19 arc(85.61,98.13) 85.82,97.96 85.93,97.93 U1.BJ2
  ART07 w0.109: 85.19,98.19 85.17,98.22 84.31,98.22 arc(84.13,98.18) 83.98,98.08 83.25,97.35 arc(83.21,97.32) 83.15,97.31 82.29,97.31 arc(82.01,97.25) 81.78,97.1 80.98,96.3 arc(80.8,96.03) 80.74,95.73 80.74,95.27 arc(80.73,95.17) 80.71,95.08 arc(80.69,95.03) 80.66,94.98 79.93,94.26 arc(79.89,94.22) 79.84,94.19 arc(79.55,94.09) 79.25,94.06 arc(78.54,93.92) 77.94,93.52 77.49,93.07 arc(77.16,92.84) 76.76,92.76 76.46,92.76 arc(75.98,92.66) 75.57,92.39 arc(75.06,92.05) 74.45,91.93 73.42,91.93 arc(72.92,91.83) 72.49,91.54 arc(72.23,91.15) 72.13,90.68 72.13,87.4 arc(71.68,85.12) 70.39,83.2 68.79,81.59 arc(66.62,80.14) 64.06,79.63 53.06,79.63 arc(51.94,79.41) 50.98,78.77 50.11,77.9 arc(49.83,77.47) 49.73,76.97 49.73,75.56 arc(49.64,75.35) 49.43,75.26 49.2,75.26 48.92,75.54
QSFPDD_TXN2: length 71.8
  TOP w0.091: 57.71,73.54 U12.34
  ART07 w0.097: 85.14,99.01 85.35,99.01 arc(85.55,98.95) 85.7,98.81 85.7,98.8 arc(85.92,98.58) 86.21,98.51 86.22,98.51 arc(86.52,98.58) 86.73,98.8 86.75,98.82 arc(86.88,98.96) 87.07,99.01 87.12,99.01 arc(87.29,98.96) 87.41,98.84 87.41,98.82 87.43,98.8 arc(87.43,98.8) 87.43,98.8 87.43,98.79 arc(87.45,98.77) 87.47,98.74 arc(87.65,98.58) 87.89,98.51 arc(87.92,98.5) 87.94,98.5 87.95,98.51 arc(88.21,98.57) 88.41,98.74 88.52,98.77 U1.BH5
  ART07 w0.109: 57.71,73.54 57.43,73.26 57.02,73.26 arc(56.74,73.2) 56.51,73.05 55.05,71.59 arc(54.53,71.24) 53.92,71.12 53.7,71.12 53.58,71.24 53.36,71.24 53.24,71.12 53.02,71.12 52.9,71.24 52.68,71.24 52.56,71.12 51.69,71.12 51.57,71.24 51.35,71.24 51.23,71.12 48.89,71.12 arc(48.8,71.13) 48.72,71.15 arc(48.67,71.18) 48.63,71.21 47.14,72.7 arc(46.91,73.03) 46.84,73.43 46.84,74.17 46.96,74.29 46.96,74.51 46.84,74.63 46.84,74.85 46.96,74.97 46.96,75.19 46.84,75.31 46.84,76.69 arc(46.95,77.29) 47.29,77.8 49.65,80.15 arc(50.22,80.53) 50.9,80.67 57.46,80.67 arc(58.88,80.95) 60.09,81.76 60.32,81.99 arc(60.74,82.61) 60.89,83.35 60.89,83.74 arc(61.08,84.71) 61.63,85.53 61.99,85.89 62.11,86.02 arc(63.34,86.83) 64.78,87.12 68.12,87.12 arc(69.25,87.35) 70.2,87.98 arc(70.64,88.63) 70.79,89.39 70.79,90.39 arc(70.91,91.17) 71.28,91.87 arc(71.29,91.91) 71.31,91.93 71.63,92.26 arc(72.27,92.69) 73.02,92.84 73.3,92.84 arc(74.05,92.99) 74.69,93.41 74.86,93.58 arc(75.44,93.97) 76.13,94.11 76.48,94.11 arc(76.95,94.2) 77.34,94.47 79.35,96.47 arc(79.74,96.73) 80.2,96.82 arc(80.59,96.99) 80.75,97.38 80.75,97.72 arc(80.8,98) 80.96,98.23 81.04,98.31 arc(81.25,98.45) 81.5,98.5 83.16,98.5 arc(83.5,98.56) 83.78,98.74 arc(83.81,98.77) 83.84,98.79 arc(84.1,98.93) 84.4,98.98 85.12,98.98 85.14,99.01
QSFPDD_TXN3: length 58.2
  TOP w0.091: U12.5 48.92,73.14
  ART05 w0.097: U1.BM5 88.52,96.77 88.49,96.88 arc(88.5,96.88) 88.5,96.89 arc(88.54,97.15) 88.46,97.4 88.42,97.46 arc(88.25,97.63) 88.02,97.69 87.86,97.69 arc(87.66,97.64) 87.5,97.51 87.46,97.44 arc(87.28,97.27) 87.06,97.19 arc(86.78,97.08) 86.55,96.88 arc(86.2,96.71) 85.85,96.91 arc(85.64,97.12) 85.35,97.19 84.99,97.19 84.97,97.22 84.95,97.22
  ART05 w0.109: 48.92,73.14 49.21,72.85 49.38,72.85 arc(49.59,72.94) 49.67,73.15 49.67,76.26 arc(49.89,77.35) 50.51,78.27 51.02,78.78 arc(52.52,79.79) 54.3,80.14 65.55,80.14 arc(67.3,80.49) 68.77,81.47 69.67,82.37 arc(70.14,83.07) 70.3,83.9 70.3,89.88 arc(70.52,90.95) 71.13,91.86 71.96,92.7 arc(72.97,93.37) 74.16,93.61 74.5,93.61 arc(75.89,93.89) 77.08,94.68 77.75,95.35 arc(78.51,95.86) 79.4,96.04 79.55,96.04 arc(79.78,96.06) 80,96.13 arc(80.05,96.16) 80.09,96.19 80.8,96.91 arc(81.15,97.14) 81.55,97.22 84.95,97.22
QSFPDD_TXN4: length 45
  TOP w0.091: 54.78,75.94 U12.75
  ART05 w0.097: 85,96.22 85.02,96.22 85.04,96.19 85.35,96.19 arc(85.6,96.14) 85.8,95.98 arc(85.81,95.97) 85.82,95.96 85.93,95.93 U1.BN2
  ART05 w0.109: 54.78,75.94 54.8,75.94 55.08,75.66 55.22,75.66 arc(55.43,75.75) 55.52,75.96 55.52,76.33 arc(55.62,76.86) 55.93,77.32 56.27,77.66 arc(56.27,77.66) 56.27,77.66 56.51,77.9 arc(57.84,78.79) 59.41,79.1 65.66,79.1 arc(67.63,79.49) 69.3,80.61 70.33,81.63 arc(71.01,82.65) 71.24,83.84 71.24,89.05 arc(71.48,90.25) 72.16,91.26 72.55,91.66 arc(73.78,92.47) 75.22,92.76 76.21,92.76 arc(76.81,92.88) 77.32,93.22 77.91,93.82 arc(78.61,94.28) 79.42,94.44 79.66,94.44 arc(79.81,94.45) 79.96,94.46 arc(80.04,94.48) 80.1,94.53 80.66,95.08 arc(80.98,95.3) 81.36,95.38 81.85,95.38 arc(81.91,95.38) 81.96,95.39 arc(82.14,95.44) 82.31,95.53 arc(82.35,95.56) 82.39,95.6 82.8,96.01 arc(83.03,96.16) 83.3,96.22 85,96.22
QSFPDD_TXN5: length 46.9
  TOP w0.091: 51.85,75.54 U12.40
  ART07 w0.097: 85.04,94.19 85.35,94.19 arc(85.61,94.13) 85.82,93.96 85.93,93.93 U1.BU2
  ART07 w0.109: 51.85,75.54 52.13,75.26 52.37,75.26 arc(52.53,75.33) 52.6,75.49 52.6,77.05 arc(52.72,77.67) 53.07,78.19 53.11,78.23 arc(53.4,78.42) 53.73,78.49 64.36,78.49 arc(67.65,79.14) 70.44,81.01 70.98,81.55 73.73,84.3 74.02,84.59 arc(74.84,85.82) 75.13,87.27 75.13,90.15 arc(75.2,90.5) 75.38,90.8 arc(75.64,90.97) 75.94,91.03 77.09,91.03 arc(77.39,91.09) 77.65,91.27 78.16,91.77 arc(78.72,92.15) 79.37,92.28 79.91,92.28 arc(80.39,92.47) 80.62,92.94 arc(80.72,93.34) 80.96,93.69 81.35,94.08 arc(81.44,94.15) 81.55,94.19 arc(81.64,94.21) 81.74,94.22 85.02,94.22 85.04,94.19
QSFPDD_TXN6: length 51.9
  TOP w0.091: 54.78,73.54 U12.72
  ART05 w0.097: U1.BT5 88.52,94.77 88.49,94.88 arc(88.5,94.88) 88.5,94.89 arc(88.54,95.15) 88.46,95.4 88.46,95.4 arc(88.24,95.62) 87.95,95.69 87.94,95.69 arc(87.65,95.62) 87.43,95.4 87.43,95.4 arc(87.28,95.25) 87.08,95.19 87.08,95.19 arc(86.78,95.12) 86.56,94.9 86.56,94.9 arc(86.41,94.75) 86.21,94.69 arc(86.01,94.75) 85.86,94.9 85.85,94.92 85.75,95.02 85.66,95.09 85.58,95.17 85.11,95.17 85.07,95.17
  ART05 w0.109: 54.78,73.54 55.07,73.25 55.27,73.25 arc(55.63,73.11) 55.78,72.75 55.78,72.14 arc(55.84,71.83) 56.01,71.57 56.19,71.39 arc(56.38,71.26) 56.59,71.22 57.96,71.22 arc(59.02,71.43) 59.91,72.03 60.46,72.58 61.06,73.18 arc(61.39,73.68) 61.51,74.27 61.51,74.5 arc(61.72,75.57) 62.33,76.48 62.92,77.07 arc(64.18,77.91) 65.66,78.21 66.26,78.21 arc(68,78.55) 69.48,79.54 70.77,80.83 71.25,81.31 arc(71.99,82.41) 72.25,83.72 72.25,88.24 arc(72.4,89) 72.83,89.65 arc(73.19,89.89) 73.61,89.97 73.94,89.97 arc(74.65,90.11) 75.24,90.51 arc(75.74,90.84) 76.32,90.96 76.73,90.96 arc(77.2,91.05) 77.6,91.32 78.32,92.04 arc(78.68,92.28) 79.1,92.36 79.68,92.36 arc(79.99,92.42) 80.25,92.6 arc(80.39,92.8) 80.44,93.04 80.44,93.16 arc(80.52,93.58) 80.76,93.94 arc(81.03,94.12) 81.34,94.18 83.6,94.18 arc(83.64,94.19) 83.67,94.22 84.52,95.07 arc(84.64,95.14) 84.77,95.17 85.07,95.17
QSFPDD_TXN7: length 51.9
  TOP w0.091: 51.85,73.14 51.05,73.14 U12.43
  ART05 w0.097: 85.35,92.19 85.12,92.19 85.1,92.22 85.07,92.22 ; 85.35,92.19 85.35,92.19 ; 85.35,92.19 85.35,92.19 ; U1.BY5 88.52,92.77 88.49,92.88 arc(88.54,93.14) 88.46,93.4 arc(88.24,93.61) 87.95,93.69 87.94,93.69 arc(87.65,93.61) 87.43,93.4 87.43,93.39 arc(87.28,93.25) 87.08,93.19 87.08,93.19 arc(86.78,93.11) 86.56,92.9 86.56,92.89 arc(86.41,92.75) 86.21,92.69 86.21,92.69 arc(85.91,92.61) 85.7,92.4 85.7,92.39 arc(85.55,92.25) 85.35,92.19
  ART05 w0.109: 51.85,73.14 52.14,72.85 52.37,72.85 arc(52.7,72.72) 52.83,72.39 52.83,72.11 arc(52.93,71.64) 53.2,71.23 53.6,70.83 arc(54.33,70.35) 55.19,70.18 57.75,70.18 arc(59.28,70.48) 60.58,71.35 61.26,72.03 62.06,72.83 arc(62.45,73.41) 62.58,74.09 62.58,74.22 arc(62.74,74.99) 63.18,75.65 63.81,76.29 arc(64.87,76.99) 66.11,77.24 67.29,77.24 arc(68.83,77.55) 70.14,78.42 71.63,79.91 73.07,81.35 arc(73.54,82.05) 73.7,82.88 73.7,83.44 arc(73.87,84.3) 74.36,85.03 74.88,85.55 76.79,87.46 77.52,88.19 arc(77.79,88.6) 77.89,89.08 77.89,89.45 arc(77.97,89.84) 78.19,90.18 78.24,90.23 arc(78.51,90.41) 78.82,90.47 79.33,90.47 arc(79.67,90.54) 79.96,90.73 80.22,90.99 81.18,91.95 arc(81.47,92.15) 81.82,92.22 85.07,92.22
QSFPDD_TXP0: length 82.5
  TOP w0.091: 57.71,75.14 U12.36
  ART07 w0.097: U1.BF1 85.63,99.77 85.66,99.86 arc(85.52,99.97) 85.35,100.01 85.19,100.01
  ART07 w0.109: 85.19,100.01 85.17,99.98 84.1,99.98 arc(83.96,99.96) 83.84,99.88 arc(83.78,99.82) 83.7,99.78 83.54,99.7 arc(83.47,99.67) 83.39,99.66 82.9,99.66 82.78,99.54 82.56,99.54 82.44,99.66 82.22,99.66 82.1,99.54 81.88,99.54 81.76,99.66 81.54,99.66 81.42,99.54 81.2,99.54 81.08,99.66 80.86,99.66 arc(80.3,99.55) 79.83,99.24 78.16,97.57 arc(77.81,97.27) 77.41,97.04 arc(76.87,96.86) 76.3,96.79 72.43,96.79 arc(71.75,96.66) 71.18,96.28 arc(70.95,95.93) 70.87,95.52 70.87,95 arc(70.8,94.67) 70.62,94.4 70.14,93.92 arc(69.9,93.75) 69.61,93.69 68.86,93.69 arc(68.38,93.5) 68.18,93.01 arc(68.1,92.62) 67.87,92.28 67.5,91.91 arc(67.28,91.76) 67.03,91.71 66.64,91.71 arc(66.36,91.66) 66.13,91.5 65.34,90.71 arc(64.48,90.14) 63.46,89.94 63.12,89.94 arc(62.34,89.78) 61.68,89.34 60.83,88.49 arc(59.9,87.87) 58.8,87.65 56.09,87.65 arc(54.62,87.36) 53.38,86.52 48.68,81.82 48.68,81.65 48.52,81.5 48.35,81.5 48.19,81.34 48.19,81.17 48.04,81.02 47.87,81.02 47.7,80.85 47.7,80.67 47.54,80.52 47.37,80.52 47.09,80.24 arc(46.13,78.81) 45.8,77.12 45.8,75.29 45.92,75.17 45.92,74.95 45.8,74.83 45.8,74.61 45.92,74.49 45.92,74.27 45.8,74.15 45.8,73.93 45.92,73.81 45.92,73.59 45.8,73.47 45.8,73.25 arc(46.02,72.15) 46.64,71.21 47.1,70.76 arc(48.1,70.09) 49.27,69.85 55.07,69.85 55.19,69.98 55.41,69.98 55.53,69.85 55.75,69.85 55.87,69.98 56.09,69.98 56.21,69.85 56.43,69.85 56.55,69.98 56.77,69.98 56.89,69.85 57.11,69.85 arc(57.69,69.97) 58.18,70.3 60.01,72.13 60.01,72.3 60.17,72.46 60.34,72.46 60.49,72.61 60.49,72.78 60.65,72.94 60.82,72.94 60.97,73.09 60.97,73.26 61.13,73.42 61.3,73.42 61.45,73.57 arc(61.48,73.61) 61.5,73.64 arc(61.5,73.65) 61.5,73.65 arc(61.5,73.66) 61.5,73.66 arc(61.53,73.77) 61.54,73.88 61.54,74.66 61.42,74.79 61.42,75 61.54,75.13 61.54,75.34 arc(61.51,75.5) 61.42,75.64 61.12,75.94 arc(60.98,76.03) 60.81,76.07 60.59,76.07 60.47,75.95 60.25,75.95 60.13,76.07 59.47,76.07 arc(59.34,76.04) 59.23,75.97 58.84,75.58 arc(58.63,75.44) 58.38,75.39 57.95,75.39 57.71,75.14
QSFPDD_TXP1: length 52.1
  TOP w0.091: 48.92,74.74 U12.3
  ART07 w0.097: 85.19,98.01 85.35,98.01 arc(85.52,97.97) 85.66,97.86 85.63,97.77 U1.BK1
  ART07 w0.109: 85.19,98.01 85.17,97.98 84.31,97.98 arc(84.22,97.97) 84.15,97.91 83.99,97.76 83.99,97.59 83.84,97.43 83.67,97.43 83.42,97.18 arc(83.3,97.1) 83.15,97.07 82.29,97.07 arc(82.1,97.04) 81.95,96.93 81.79,96.77 81.79,96.6 81.63,96.45 81.46,96.45 81.14,96.13 arc(81.02,95.94) 80.98,95.73 80.98,95.27 arc(80.97,95.14) 80.94,95.01 arc(80.89,94.91) 80.82,94.82 80.1,94.09 arc(80.03,94.03) 79.95,93.99 arc(79.61,93.86) 79.25,93.82 arc(78.63,93.7) 78.11,93.35 77.66,92.9 arc(77.24,92.62) 76.76,92.53 76.46,92.53 arc(76.07,92.45) 75.74,92.23 arc(75.15,91.83) 74.45,91.69 73.42,91.69 arc(73.01,91.61) 72.65,91.38 arc(72.44,91.06) 72.37,90.68 72.37,87.4 arc(71.9,85.03) 70.56,83.03 69.57,82.04 68.96,81.43 arc(66.71,79.93) 64.06,79.4 53.06,79.4 arc(52.03,79.19) 51.15,78.61 50.27,77.73 arc(50.04,77.38) 49.96,76.97 49.96,75.56 arc(49.8,75.18) 49.43,75.03 49.2,75.03 48.92,74.74
QSFPDD_TXP2: length 71.8
  TOP w0.091: 57.71,72.74 U12.33
  ART07 w0.097: 87.94,99.1 88.23,98.93 88.26,98.84 arc(88.12,98.73) 87.95,98.69 87.91,98.69 87.91,98.69 arc(87.75,98.75) 87.62,98.86 87.6,98.89 arc(87.6,98.89) 87.6,98.89 87.57,98.93 arc(87.38,99.12) 87.12,99.19 87.07,99.19 arc(86.79,99.12) 86.58,98.91 86.57,98.89 arc(86.42,98.75) 86.22,98.69 86.21,98.69 arc(86.01,98.75) 85.86,98.89 85.86,98.9 arc(85.65,99.11) 85.35,99.19 85.14,99.19
  ART07 w0.109: 57.71,72.74 57.43,73.03 57.02,73.03 arc(56.83,72.99) 56.68,72.88 56.23,72.44 55.48,71.69 55.21,71.42 arc(54.62,71.02) 53.92,70.89 48.89,70.89 arc(48.76,70.9) 48.63,70.93 arc(48.54,70.98) 48.46,71.05 46.97,72.54 arc(46.7,72.95) 46.6,73.43 46.6,76.69 arc(46.74,77.38) 47.13,77.96 49.48,80.32 arc(50.13,80.75) 50.9,80.9 57.46,80.9 arc(58.79,81.17) 59.93,81.93 60.16,82.16 arc(60.52,82.7) 60.65,83.35 60.65,83.74 arc(60.86,84.8) 61.46,85.69 61.95,86.18 arc(63.25,87.05) 64.78,87.35 68.12,87.35 arc(69.16,87.56) 70.04,88.15 arc(70.42,88.72) 70.55,89.39 70.55,90.39 arc(70.76,91.43) 71.35,92.3 71.47,92.43 arc(72.18,92.9) 73.02,93.07 73.3,93.07 arc(73.96,93.2) 74.52,93.58 74.69,93.74 arc(75.35,94.18) 76.13,94.34 76.48,94.34 arc(76.86,94.42) 77.18,94.63 79.19,96.64 arc(79.65,96.95) 80.2,97.06 arc(80.42,97.15) 80.52,97.38 80.52,97.72 arc(80.59,98.09) 80.79,98.4 80.87,98.47 arc(81.16,98.67) 81.5,98.73 82.99,98.73 arc(83.36,98.8) 83.69,98.98 arc(84.02,99.15) 84.4,99.22 85.12,99.22 85.14,99.19
QSFPDD_TXP3: length 58.2
  TOP w0.091: U12.6 48.92,72.34
  ART05 w0.097: 84.95,96.98 84.97,96.98 84.99,97.01 85.35,97.01 arc(85.55,96.95) 85.69,96.81 arc(86.19,96.52) 86.7,96.77 arc(86.87,96.92) 87.09,97 arc(87.38,97.11) 87.61,97.33 87.66,97.4 arc(87.75,97.48) 87.86,97.51 88.02,97.51 arc(88.16,97.47) 88.26,97.36 88.3,97.3 arc(88.35,97.13) 88.33,96.96 88.23,96.93 87.94,97.1
  ART05 w0.109: 84.95,96.98 84.41,96.98 84.28,96.86 84.07,96.86 83.94,96.98 83.73,96.98 83.6,96.86 83.39,96.86 83.26,96.98 83.05,96.98 82.92,96.86 82.7,96.86 82.58,96.98 82.36,96.98 82.24,96.86 82.02,96.86 81.9,96.98 81.55,96.98 arc(81.24,96.92) 80.97,96.74 80.26,96.03 arc(80.18,95.97) 80.1,95.92 arc(79.83,95.83) 79.55,95.8 79.4,95.8 arc(78.6,95.64) 77.91,95.19 77.86,95.13 77.24,94.51 arc(75.98,93.67) 74.5,93.38 74.16,93.38 arc(73.06,93.16) 72.13,92.54 71.29,91.7 arc(70.73,90.86) 70.54,89.88 70.54,83.9 arc(70.36,82.99) 69.83,82.21 69.43,81.8 68.94,81.31 arc(67.39,80.27) 65.55,79.91 54.3,79.91 arc(52.61,79.57) 51.18,78.61 50.67,78.1 arc(50.11,77.26) 49.91,76.26 49.91,73.15 arc(49.75,72.78) 49.38,72.62 49.2,72.62 48.92,72.34
QSFPDD_TXP4: length 45
  TOP w0.091: 54.78,75.14 U12.74
  ART05 w0.097: U1.BP1 85.63,95.77 85.66,95.86 arc(85.52,95.97) 85.35,96.01 85.04,96.01 85.02,95.98 85,95.98
  ART05 w0.109: 54.78,75.14 54.8,75.14 55.09,75.43 55.22,75.43 arc(55.59,75.59) 55.75,75.96 55.75,76.33 arc(55.84,76.77) 56.09,77.15 56.68,77.74 arc(57.93,78.57) 59.41,78.87 65.66,78.87 arc(67.72,79.28) 69.47,80.44 70.49,81.47 arc(71.22,82.56) 71.48,83.84 71.48,89.05 arc(71.7,90.16) 72.32,91.1 72.72,91.49 arc(73.87,92.26) 75.22,92.53 76.21,92.53 arc(76.9,92.66) 77.48,93.05 78.08,93.65 arc(78.7,94.06) 79.42,94.21 79.66,94.21 arc(79.83,94.21) 79.99,94.23 arc(80.14,94.27) 80.27,94.36 80.82,94.92 arc(81.07,95.08) 81.36,95.14 81.85,95.14 arc(81.93,95.15) 82,95.15 arc(82.23,95.22) 82.44,95.34 arc(82.5,95.38) 82.56,95.43 82.97,95.84 arc(83.12,95.95) 83.3,95.98 83.64,95.98 83.76,95.86 83.98,95.86 84.1,95.98 84.32,95.98 84.44,95.86 84.66,95.86 84.78,95.98 85,95.98
QSFPDD_TXP5: length 46.9
  TOP w0.091: 51.85,74.74 U12.41
  ART07 w0.097: 85.06,94.01 85.35,94.01 arc(85.52,93.97) 85.66,93.86 85.63,93.77 U1.BV1
  ART07 w0.109: 85.06,94.01 85.04,93.98 84.32,93.98 84.2,93.86 83.98,93.86 83.86,93.98 83.64,93.98 83.52,93.86 83.3,93.86 83.18,93.98 81.74,93.98 arc(81.67,93.98) 81.61,93.97 arc(81.56,93.95) 81.52,93.91 81.13,93.52 arc(80.93,93.25) 80.85,92.92 arc(80.55,92.3) 79.91,92.04 79.37,92.04 arc(78.8,91.93) 78.32,91.61 77.82,91.1 arc(77.48,90.88) 77.09,90.8 75.94,90.8 arc(75.73,90.76) 75.55,90.64 arc(75.41,90.43) 75.36,90.19 75.36,87.27 arc(75.06,85.73) 74.18,84.42 73.9,84.14 71.14,81.38 70.61,80.84 arc(67.74,78.93) 64.36,78.26 53.73,78.26 arc(53.48,78.21) 53.27,78.07 53.24,78.03 arc(52.94,77.58) 52.83,77.05 52.83,75.49 arc(52.69,75.16) 52.37,75.03 52.13,75.03 51.85,74.74
QSFPDD_TXP6: length 51.9
  TOP w0.091: 54.78,72.74 U12.71
  ART05 w0.097: 87.94,95.1 88.23,94.93 88.33,94.96 arc(88.35,95.13) 88.3,95.3 88.29,95.31 arc(88.15,95.45) 87.94,95.51 arc(87.74,95.45) 87.6,95.31 87.59,95.3 arc(87.38,95.09) 87.08,95.01 87.08,95.01 arc(86.88,94.95) 86.73,94.81 86.72,94.8 arc(86.51,94.59) 86.21,94.51 arc(85.91,94.59) 85.7,94.8 85.62,94.88 85.54,94.95 85.5,94.98 85.19,94.98 85.17,94.96 85.12,94.96 85.1,94.93 85.07,94.93
  ART05 w0.109: 54.78,72.74 55.06,73.02 55.27,73.02 arc(55.46,72.94) 55.54,72.75 55.54,72.13 arc(55.62,71.74) 55.84,71.41 56.03,71.22 arc(56.29,71.05) 56.59,70.99 57.96,70.99 arc(59.11,71.21) 60.08,71.86 60.6,72.39 61.22,73.01 arc(61.61,73.59) 61.74,74.27 61.74,74.5 arc(61.94,75.48) 62.5,76.32 62.98,76.8 63.09,76.91 arc(64.27,77.7) 65.66,77.97 66.26,77.97 arc(68.09,78.34) 69.64,79.37 71.19,80.92 71.42,81.15 arc(72.2,82.33) 72.48,83.72 72.48,88.24 arc(72.62,88.91) 73,89.48 arc(73.28,89.67) 73.61,89.74 73.94,89.74 arc(74.73,89.9) 75.41,90.35 arc(75.83,90.63) 76.32,90.72 76.73,90.72 arc(77.29,90.83) 77.77,91.15 78.49,91.87 arc(78.77,92.06) 79.1,92.13 79.68,92.13 arc(80.08,92.21) 80.42,92.43 arc(80.6,92.71) 80.67,93.04 80.67,93.16 arc(80.74,93.49) 80.93,93.78 arc(81.12,93.9) 81.34,93.95 81.55,93.95 81.68,93.83 81.9,93.83 82.02,93.95 82.24,93.95 82.36,93.83 82.58,93.83 82.7,93.95 82.92,93.95 83.04,93.83 83.26,93.83 83.38,93.95 83.6,93.95 arc(83.73,93.98) 83.84,94.05 84.2,94.41 84.38,94.41 84.53,94.57 84.53,94.74 84.69,94.9 arc(84.73,94.92) 84.77,94.93 85.07,94.93
QSFPDD_TXP7: length 51.9
  TOP w0.091: U12.44 51.85,72.34
  ART05 w0.097: 87.94,93.1 88.23,92.93 88.33,92.96 arc(88.35,93.13) 88.3,93.3 88.29,93.31 arc(88.15,93.45) 87.94,93.51 arc(87.74,93.45) 87.6,93.31 87.59,93.3 arc(87.38,93.09) 87.08,93.01 87.08,93.01 arc(86.88,92.95) 86.73,92.81 86.73,92.8 arc(86.51,92.59) 86.22,92.51 86.21,92.51 arc(86.01,92.45) 85.86,92.31 85.86,92.3 arc(85.65,92.09) 85.35,92.01 85.12,92.01 85.1,91.98 85.07,91.98
  ART05 w0.109: 51.85,72.34 52.13,72.62 52.37,72.62 arc(52.53,72.55) 52.6,72.39 52.6,72.11 arc(52.71,71.55) 53.03,71.07 53.43,70.67 arc(54.24,70.13) 55.19,69.94 57.75,69.94 arc(59.37,70.26) 60.74,71.18 62.23,72.67 arc(62.66,73.32) 62.82,74.09 62.82,74.22 arc(62.95,74.9) 63.34,75.48 63.98,76.12 arc(64.96,76.78) 66.11,77.01 67.29,77.01 arc(68.92,77.33) 70.3,78.26 73.24,81.19 arc(73.75,81.96) 73.94,82.88 73.94,83.44 arc(74.09,84.21) 74.53,84.87 77.68,88.02 arc(78.01,88.51) 78.12,89.08 78.12,89.45 arc(78.18,89.75) 78.36,90.02 78.41,90.07 arc(78.6,90.2) 78.82,90.24 79.34,90.24 arc(79.76,90.33) 80.13,90.57 80.45,90.89 81.34,91.78 arc(81.56,91.93) 81.82,91.98 82.06,91.98 82.19,91.86 82.41,91.86 82.53,91.98 83.03,91.98 83.15,91.86 83.37,91.86 83.49,91.98 83.71,91.98 83.83,91.86 84.05,91.86 84.17,91.98 84.39,91.98 84.51,91.86 84.73,91.86 84.85,91.98 85.07,91.98
QSFPDD_VCCRX: length 2
  TOP w0.254: U12.48 49.48,69.14 v3(49.48,69.14)
  BOTTOM w0.254: C556.1 46.19,68.64 v3(46.45,68.91)
  vias: v3(45.51,69.75) v3(45.49,68.88) v3(46.43,69.8)
REFCLK_GXEN0: length 75.7
  ART07 w0.094: v2(95.74,105.6) 95.74,105.27 95.82,105.2 arc(95.83,105.19) 95.84,105.19 arc(96.28,104.86) 96.26,104.3 arc(96.21,104.1) 96.26,103.9 arc(96.34,103.6) 96.26,103.3 arc(96.21,103.1) 96.26,102.9 arc(96.34,102.6) 96.26,102.3 arc(96.21,102.1) 96.26,101.9 arc(96.34,101.6) 96.26,101.3 arc(96.21,101.1) 96.26,100.9 arc(96.34,100.6) 96.26,100.3 arc(96.21,100.1) 96.26,99.9 arc(96.34,99.6) 96.26,99.3 arc(96.21,99.1) 96.26,98.9 arc(96.34,98.6) 96.26,98.3 arc(96.21,98.1) 96.26,97.9 arc(96.34,97.6) 96.26,97.3 arc(96.21,97.1) 96.26,96.9 arc(96.34,96.6) 96.26,96.3 arc(96.21,96.1) 96.26,95.9 96.26,95.9 arc(96.34,95.6) 96.26,95.3 arc(96.21,95.1) 96.26,94.9 arc(96.34,94.6) 96.26,94.3 96.26,94.3 arc(96.21,94.1) 96.26,93.9 arc(96.34,93.6) 96.26,93.3 arc(96.21,93.1) 96.26,92.9 arc(96.34,92.6) 96.26,92.3 arc(96.21,92.1) 96.26,91.9 arc(96.34,91.6) 96.26,91.3 arc(96.21,91.1) 96.26,90.9 arc(96.34,90.6) 96.26,90.3 arc(96.21,90.1) 96.26,89.9 arc(96.34,89.6) 96.26,89.3 arc(96.21,89.1) 96.26,88.9 arc(96.34,88.6) 96.26,88.3 arc(96.21,88.1) 96.26,87.9 arc(96.34,87.6) 96.26,87.3 arc(96.21,87.1) 96.26,86.9 arc(96.34,86.6) 96.26,86.3 arc(96.21,86.1) 96.26,85.9 arc(96.34,85.6) 96.26,85.3 arc(96.21,85.1) 96.26,84.9 arc(96.34,84.6) 96.26,84.3 arc(96.21,84.1) 96.26,83.9 arc(96.34,83.6) 96.26,83.3 arc(96.21,83.1) 96.26,82.9 96.26,82.9 arc(96.34,82.6) 96.26,82.3 arc(96.21,82.1) 96.26,81.9 arc(96.34,81.6) 96.26,81.3 96.26,81.3 arc(96.22,81.19) 96.21,81.08 arc(96.22,80.99) 96.26,80.9 arc(96.32,80.76) 96.34,80.6 96.34,80.19 95.32,79.17 93.47,79.17 91.82,77.52 91.82,72.64 83.28,64.1 83.28,46.86 85.77,44.37 85.77,41.02 86.08,40.72 86.63,40.72 86.88,40.97 86.88,41.37 86.79,41.47 v2(86.47,41.47)
REFCLK_GXEN1: length 102.3
  ART07 w0.094: v2(96.6,106.1) 96.6,105.77 96.68,105.7 arc(96.69,105.69) 96.71,105.69 arc(96.95,105.59) 97.13,105.4 arc(97.21,105.1) 97.13,104.8 arc(97.07,104.6) 97.13,104.4 arc(97.21,104.1) 97.13,103.8 arc(97.07,103.6) 97.13,103.4 arc(97.21,103.1) 97.13,102.8 arc(97.07,102.6) 97.13,102.4 arc(97.21,102.1) 97.13,101.8 arc(97.07,101.6) 97.13,101.4 arc(97.21,101.1) 97.13,100.8 arc(97.07,100.6) 97.13,100.4 arc(97.21,100.1) 97.13,99.8 arc(97.07,99.6) 97.13,99.4 arc(97.21,99.1) 97.13,98.8 arc(97.07,98.6) 97.13,98.4 arc(97.21,98.1) 97.13,97.8 arc(97.07,97.6) 97.13,97.4 arc(97.21,97.1) 97.13,96.8 arc(97.07,96.6) 97.13,96.4 arc(97.21,96.1) 97.13,95.8 arc(97.07,95.6) 97.13,95.4 arc(97.21,95.1) 97.13,94.8 97.13,94.8 arc(97.07,94.6) 97.13,94.4 97.13,94.4 arc(97.21,94.1) 97.13,93.8 arc(97.07,93.6) 97.13,93.4 arc(97.21,93.1) 97.13,92.8 97.13,92.8 arc(97.07,92.6) 97.13,92.4 arc(97.21,92.1) 97.13,91.8 arc(97.07,91.6) 97.13,91.4 97.13,91.4 arc(97.21,91.1) 97.13,90.8 arc(97.07,90.6) 97.13,90.4 97.13,90.4 arc(97.21,90.1) 97.13,89.8 arc(97.07,89.6) 97.13,89.4 arc(97.21,89.1) 97.13,88.8 arc(97.07,88.6) 97.13,88.4 arc(97.21,88.1) 97.13,87.8 97.13,87.8 arc(97.07,87.6) 97.13,87.4 arc(97.21,87.1) 97.13,86.8 97.13,86.8 arc(97.07,86.6) 97.13,86.4 97.13,86.4 arc(97.21,86.1) 97.13,85.8 arc(97.07,85.6) 97.13,85.4 97.13,85.4 arc(97.21,85.1) 97.13,84.8 arc(97.07,84.6) 97.13,84.4 arc(97.21,84.1) 97.13,83.8 97.13,83.8 arc(97.07,83.6) 97.13,83.4 arc(97.21,83.1) 97.13,82.8 97.12,82.8 arc(97.07,82.6) 97.13,82.4 arc(97.21,82.1) 97.13,81.8 97.12,81.8 arc(97.07,81.6) 97.13,81.4 arc(97.21,81.1) 97.13,80.8 97.13,80.8 arc(97.07,80.6) 97.13,80.4 arc(97.16,80.33) 97.19,80.26 97.21,80.24 97.21,79.73 95.64,78.16 93.7,78.16 92.73,77.19 92.73,72.41 86.21,65.88 86.21,50.2 88.44,47.96 88.44,40.05 87.69,39.29 76.26,39.29 73.21,36.24 63.64,36.24 63.17,36.72 63.17,37.29 63.02,37.43 v2(62.74,37.43)
REFCLK_GXEN2: length 123.6
  TOP w0.089: C870.2 173.94,51.99 173.2,51.99 170.48,54.71 170.48,58.53 167.83,61.18 158.96,61.18 v2(158.75,60.97)
  ART16 w0.094: v2(94.01,108.6) 94.29,108.44 94.4,108.47 arc(94.4,108.47) 94.41,108.48 arc(94.62,108.64) 94.87,108.7 94.87,108.7 arc(95.07,108.75) 95.22,108.9 95.22,108.9 arc(95.44,109.12) 95.74,109.2 95.74,109.2 arc(95.94,109.25) 96.08,109.4 96.08,109.4 arc(96.6,109.7) 97.13,109.4 97.13,109.4 arc(97.27,109.25) 97.47,109.2 97.47,109.2 arc(97.77,109.12) 97.99,108.9 97.99,108.9 arc(98.14,108.75) 98.34,108.7 98.34,108.7 arc(98.64,108.62) 98.86,108.4 98.86,108.4 arc(99.01,108.25) 99.2,108.2 arc(99.5,108.12) 99.72,107.91 arc(99.72,107.91) 99.72,107.9 99.73,107.9 arc(99.87,107.75) 100.07,107.7 arc(100.37,107.62) 100.59,107.4 100.59,107.4 arc(100.73,107.26) 100.93,107.2 100.94,107.2 arc(101.23,107.12) 101.45,106.9 101.46,106.89 arc(101.61,106.75) 101.8,106.7 101.8,106.7 arc(102.1,106.62) 102.32,106.4 102.32,106.4 arc(102.47,106.25) 102.67,106.2 102.67,106.2 arc(102.97,106.12) 103.19,105.9 103.19,105.9 arc(103.34,105.75) 103.53,105.7 103.54,105.7 arc(103.84,105.62) 104.05,105.4 104.06,105.4 arc(104.2,105.25) 104.4,105.2 104.4,105.2 arc(104.7,105.12) 104.92,104.9 104.92,104.9 arc(105.07,104.75) 105.26,104.7 105.27,104.7 arc(105.57,104.62) 105.79,104.4 arc(105.87,104.1) 105.79,103.8 arc(105.73,103.6) 105.79,103.4 arc(105.87,103.1) 105.79,102.8 arc(105.73,102.6) 105.79,102.4 arc(105.87,102.1) 105.79,101.8 arc(105.73,101.6) 105.79,101.4 arc(105.87,101.1) 105.79,100.8 arc(105.73,100.6) 105.79,100.4 arc(105.87,100.1) 105.79,99.8 arc(105.73,99.6) 105.79,99.4 arc(105.87,99.1) 105.79,98.8 arc(105.73,98.6) 105.79,98.4 arc(105.87,98.1) 105.79,97.8 arc(105.73,97.6) 105.79,97.4 arc(105.87,97.1) 105.79,96.8 arc(105.73,96.6) 105.79,96.4 arc(105.87,96.1) 105.79,95.8 arc(105.73,95.6) 105.79,95.4 105.79,95.4 arc(105.93,95.25) 106.13,95.2 arc(106.43,95.12) 106.65,94.9 106.65,94.9 arc(106.8,94.75) 107,94.7 107,94.7 arc(107.3,94.62) 107.52,94.4 107.52,94.4 arc(107.67,94.25) 107.86,94.2 107.87,94.2 arc(108.17,94.12) 108.38,93.9 108.39,93.9 arc(108.53,93.75) 108.73,93.7 108.73,93.7 arc(109.03,93.62) 109.25,93.4 109.25,93.4 arc(109.4,93.25) 109.6,93.2 109.6,93.2 arc(110.11,92.9) 110.12,92.31 arc(110.12,92.3) 110.12,92.3 110.11,92.29 arc(110.12,91.9) 110.46,91.7 110.46,91.7 arc(110.76,91.62) 110.98,91.4 110.98,91.4 arc(111.13,91.25) 111.33,91.2 111.33,91.2 arc(111.63,91.12) 111.84,90.91 arc(111.85,90.9) 111.85,90.9 arc(111.93,90.6) 111.85,90.3 arc(111.79,90.1) 111.85,89.9 arc(111.93,89.6) 111.85,89.3 arc(111.79,89.1) 111.85,88.9 arc(111.93,88.6) 111.85,88.3 arc(111.79,88.1) 111.85,87.9 arc(111.93,87.6) 111.85,87.3 arc(111.79,87.1) 111.85,86.9 arc(111.93,86.6) 111.85,86.3 arc(111.79,86.1) 111.85,85.9 arc(111.93,85.6) 111.85,85.3 arc(111.79,85.1) 111.85,84.9 arc(111.93,84.6) 111.85,84.3 arc(111.79,84.1) 111.85,83.9 arc(111.93,83.6) 111.85,83.3 arc(111.79,83.1) 111.85,82.9 111.85,82.9 arc(111.93,82.6) 111.85,82.3 arc(111.79,82.1) 111.85,81.9 arc(111.93,81.6) 111.85,81.3 arc(111.79,81.1) 111.85,80.9 arc(111.88,80.86) 111.91,80.82 122.28,70.45 129.9,70.45 137.11,63.23 137.11,62.43 137.88,61.66 157.54,61.66 158.52,62.64 159.6,62.64 159.82,62.42 159.82,61.39 159.6,61.18 158.97,61.18 158.76,60.97 v2(158.75,60.97)
REFCLK_GXEN3: length 151.5
  ART16 w0.094: v2(193.52,52.83) 193.11,52.42 192.98,52.42 192.66,52.75 192.66,53.07 194.53,54.94 194.53,60.22 188.08,66.66 179.37,66.66 179.15,66.43 176.85,66.43 176.05,65.63 176.05,64.03 173.53,61.52 161.62,61.52 159.27,59.17 155.33,59.17 154.42,58.27 134.4,58.27 133.12,59.55 133.12,60.76 132.04,61.84 132.04,63.37 131.25,64.16 131.25,65.84 128.6,68.5 123.02,68.5 110.93,80.6 arc(110.94,80.7) 110.98,80.8 110.98,80.8 arc(111.06,81.1) 110.98,81.4 arc(110.93,81.6) 110.98,81.8 110.98,81.8 arc(111.06,82.1) 110.98,82.4 arc(110.93,82.6) 110.98,82.8 arc(111.06,83.1) 110.98,83.4 arc(110.93,83.6) 110.98,83.8 arc(111.06,84.1) 110.98,84.4 arc(110.93,84.6) 110.98,84.8 arc(111.06,85.1) 110.98,85.4 arc(110.93,85.6) 110.98,85.8 arc(111.06,86.1) 110.98,86.4 arc(110.93,86.6) 110.98,86.8 arc(111.06,87.1) 110.98,87.4 arc(110.93,87.6) 110.98,87.8 arc(111.06,88.1) 110.98,88.4 arc(110.93,88.6) 110.98,88.8 arc(111.06,89.1) 110.98,89.4 arc(110.93,89.6) 110.98,89.8 arc(111.06,90.1) 110.98,90.4 arc(110.76,90.62) 110.46,90.7 110.46,90.7 arc(110.26,90.75) 110.12,90.9 110.12,90.9 arc(109.9,91.12) 109.6,91.2 109.6,91.2 arc(109.4,91.25) 109.25,91.4 109.25,91.4 arc(109.03,91.62) 108.73,91.7 108.73,91.7 arc(108.53,91.75) 108.39,91.9 108.38,91.9 arc(108.17,92.12) 107.87,92.2 107.86,92.2 arc(107.52,92.4) 107.52,92.8 107.52,92.8 arc(107.52,93.4) 107,93.7 107,93.7 arc(106.8,93.75) 106.65,93.9 106.65,93.9 arc(106.43,94.12) 106.13,94.2 106.13,94.2 arc(105.93,94.25) 105.79,94.4 105.79,94.4 arc(105.57,94.62) 105.27,94.7 105.26,94.7 arc(105.07,94.75) 104.92,94.9 104.92,94.9 arc(104.87,95.1) 104.92,95.3 arc(105,95.6) 104.92,95.9 104.92,95.9 arc(104.87,96.1) 104.92,96.3 arc(105,96.6) 104.92,96.9 arc(104.87,97.1) 104.92,97.3 arc(105,97.6) 104.92,97.9 arc(104.87,98.1) 104.92,98.3 arc(105,98.6) 104.92,98.9 arc(104.87,99.1) 104.92,99.3 arc(105,99.6) 104.92,99.9 arc(104.87,100.1) 104.92,100.3 arc(105,100.6) 104.92,100.9 arc(104.87,101.1) 104.92,101.3 arc(105,101.6) 104.92,101.9 arc(104.87,102.1) 104.92,102.3 arc(105,102.6) 104.92,102.9 arc(104.87,103.1) 104.92,103.3 arc(105,103.6) 104.92,103.9 arc(104.92,103.9) 104.92,103.91 arc(104.7,104.12) 104.4,104.2 104.4,104.2 arc(104.2,104.25) 104.06,104.4 104.05,104.4 arc(103.84,104.62) 103.54,104.7 103.53,104.7 arc(103.34,104.75) 103.19,104.9 103.19,104.9 arc(102.97,105.12) 102.67,105.2 102.67,105.2 arc(102.47,105.25) 102.32,105.4 102.32,105.4 arc(102.1,105.62) 101.8,105.7 101.8,105.7 arc(101.6,105.75) 101.46,105.9 101.46,105.9 arc(101.24,106.12) 100.94,106.2 100.93,106.2 arc(100.74,106.25) 100.59,106.4 100.59,106.4 arc(100.37,106.62) 100.07,106.7 100.07,106.7 arc(99.87,106.75) 99.73,106.9 99.72,106.9 arc(99.51,107.12) 99.21,107.2 99.2,107.2 arc(99.01,107.25) 98.86,107.4 98.86,107.4 arc(98.34,107.7) 97.82,107.4 97.81,107.4 arc(97.47,107.2) 97.13,107.4 97.12,107.4 arc(96.9,107.62) 96.6,107.7 arc(96.41,107.75) 96.26,107.9 96.26,107.9 arc(96.26,107.91) 96.26,107.91 arc(96.08,108.1) 95.84,108.19 arc(95.83,108.19) 95.82,108.2 95.74,108.27 v2(95.74,108.6)
REFCLK_GXEP0: length 76.1
  ART07 w0.094: v2(87.49,41.47) 87.18,41.47 87.08,41.37 87.08,40.88 86.71,40.51 86,40.51 85.57,40.94 85.57,44.29 83.08,46.78 83.08,64.18 91.62,72.72 91.62,77.6 93.39,79.38 95.24,79.38 96.14,80.27 96.14,80.6 arc(96.12,80.7) 96.08,80.8 arc(96.08,80.82) 96.07,80.83 arc(96,81.12) 96.08,81.4 96.08,81.4 arc(96.14,81.6) 96.08,81.8 96.08,81.8 arc(96,82.1) 96.08,82.4 arc(96.14,82.6) 96.08,82.8 arc(96,83.1) 96.08,83.4 arc(96.14,83.6) 96.08,83.8 arc(96,84.1) 96.08,84.4 arc(96.14,84.6) 96.08,84.8 arc(96,85.1) 96.08,85.4 arc(96.14,85.6) 96.08,85.8 arc(96,86.1) 96.08,86.4 arc(96.14,86.6) 96.08,86.8 arc(96,87.1) 96.08,87.4 arc(96.14,87.6) 96.08,87.8 arc(96,88.1) 96.08,88.4 arc(96.14,88.6) 96.08,88.8 arc(96,89.1) 96.08,89.4 arc(96.14,89.6) 96.08,89.8 arc(96,90.1) 96.08,90.4 arc(96.14,90.6) 96.08,90.8 arc(96,91.1) 96.08,91.4 arc(96.14,91.6) 96.08,91.8 arc(96,92.1) 96.08,92.4 arc(96.14,92.6) 96.08,92.8 arc(96,93.1) 96.08,93.4 arc(96.14,93.6) 96.08,93.8 arc(96,94.1) 96.08,94.4 arc(96.14,94.6) 96.08,94.8 96.08,94.8 arc(96,95.1) 96.08,95.4 arc(96.14,95.6) 96.08,95.8 arc(96,96.1) 96.08,96.4 arc(96.14,96.6) 96.08,96.8 arc(96,97.1) 96.08,97.4 arc(96.14,97.6) 96.08,97.8 arc(96,98.1) 96.08,98.4 arc(96.14,98.6) 96.08,98.8 arc(96,99.1) 96.08,99.4 arc(96.14,99.6) 96.08,99.8 arc(96,100.1) 96.08,100.4 arc(96.14,100.6) 96.08,100.8 arc(96,101.1) 96.08,101.4 arc(96.14,101.6) 96.08,101.8 arc(96,102.1) 96.08,102.4 arc(96.14,102.6) 96.08,102.8 arc(96,103.1) 96.08,103.4 arc(96.14,103.6) 96.08,103.8 arc(96,104.1) 96.08,104.4 arc(96.1,104.77) 95.81,104.99 95.74,104.93 v2(95.74,104.6)
REFCLK_GXEP1: length 102.2
  ART07 w0.094: v2(63.75,37.43) 63.55,37.43 63.37,37.26 63.37,36.8 63.73,36.45 64.32,36.45 64.42,36.55 64.61,36.55 64.72,36.45 64.9,36.45 65.01,36.55 65.2,36.55 65.31,36.45 65.49,36.45 65.6,36.55 65.79,36.55 65.9,36.45 73.12,36.45 76.17,39.5 87.6,39.5 88.24,40.13 88.24,40.46 88.13,40.57 88.13,40.76 88.24,40.87 88.24,41.05 88.13,41.16 88.13,41.35 88.24,41.46 88.24,41.64 88.14,41.74 88.14,41.95 88.24,42.04 88.24,42.23 88.14,42.33 88.14,42.53 88.24,42.63 88.24,47.88 86,50.11 86,65.96 92.53,72.49 92.53,77.27 93.61,78.36 94.37,78.36 94.48,78.47 94.67,78.47 94.78,78.36 94.96,78.36 95.07,78.47 95.26,78.47 95.37,78.36 95.55,78.36 95.74,78.55 95.74,78.7 95.88,78.83 96.03,78.83 96.17,78.98 96.17,79.13 96.3,79.26 96.45,79.26 96.59,79.39 96.59,79.54 96.72,79.68 96.87,79.68 97,79.81 97,80.1 arc(96.99,80.2) 96.95,80.3 arc(96.87,80.6) 96.95,80.9 96.95,80.9 arc(97,81.1) 96.95,81.3 arc(96.87,81.6) 96.95,81.9 96.95,81.9 arc(97,82.1) 96.95,82.3 arc(96.87,82.6) 96.95,82.9 96.95,82.9 arc(97,83.1) 96.95,83.3 arc(96.87,83.6) 96.95,83.9 96.95,83.9 arc(97,84.1) 96.95,84.3 arc(96.87,84.6) 96.95,84.9 96.95,84.9 arc(97,85.1) 96.95,85.3 96.95,85.3 arc(96.87,85.6) 96.95,85.9 arc(97,86.1) 96.95,86.3 arc(96.87,86.6) 96.95,86.9 96.95,86.9 arc(97,87.1) 96.95,87.3 arc(96.87,87.6) 96.95,87.9 96.95,87.9 arc(97,88.1) 96.95,88.3 arc(96.87,88.6) 96.95,88.9 96.95,88.9 arc(97,89.1) 96.95,89.3 arc(96.87,89.6) 96.95,89.9 arc(97,90.1) 96.95,90.3 96.95,90.3 arc(96.87,90.6) 96.95,90.9 arc(97,91.1) 96.95,91.3 arc(96.87,91.6) 96.95,91.9 arc(97,92.1) 96.95,92.3 arc(96.87,92.6) 96.95,92.9 96.95,92.9 arc(97,93.1) 96.95,93.3 arc(96.87,93.6) 96.95,93.9 96.95,93.9 arc(97,94.1) 96.95,94.3 96.95,94.3 arc(96.87,94.6) 96.95,94.9 arc(97,95.1) 96.95,95.3 arc(96.87,95.6) 96.95,95.9 96.95,95.9 arc(97,96.1) 96.95,96.3 arc(96.87,96.6) 96.95,96.9 arc(97,97.1) 96.95,97.3 arc(96.87,97.6) 96.95,97.9 arc(97,98.1) 96.95,98.3 arc(96.87,98.6) 96.95,98.9 arc(97,99.1) 96.95,99.3 arc(96.87,99.6) 96.95,99.9 arc(97,100.1) 96.95,100.3 arc(96.87,100.6) 96.95,100.9 arc(97,101.1) 96.95,101.3 arc(96.87,101.6) 96.95,101.9 arc(97,102.1) 96.95,102.3 arc(96.87,102.6) 96.95,102.9 arc(97,103.1) 96.95,103.3 arc(96.87,103.6) 96.95,103.9 arc(97,104.1) 96.95,104.3 arc(96.87,104.6) 96.95,104.9 arc(97,105.1) 96.95,105.3 96.95,105.3 arc(96.83,105.43) 96.67,105.49 96.6,105.43 v2(96.6,105.1)
REFCLK_GXEP2: length 123.9
  TOP w0.089: C869.2 173.94,52.27 173.32,52.27 170.76,54.83 170.76,58.65 167.94,61.47 158.98,61.47 v2(158.76,61.68)
  ART16 w0.094: v2(94.87,108.1) 94.59,108.26 94.57,108.35 arc(94.7,108.46) 94.87,108.5 94.88,108.5 arc(95.18,108.58) 95.39,108.8 95.4,108.8 arc(95.54,108.95) 95.74,109 95.74,109 arc(96.04,109.08) 96.26,109.29 arc(96.26,109.3) 96.26,109.3 96.26,109.3 arc(96.61,109.5) 96.95,109.3 arc(97.17,109.08) 97.47,109 97.47,109 arc(97.67,108.95) 97.81,108.8 97.82,108.8 arc(98.03,108.58) 98.33,108.5 98.34,108.5 arc(98.53,108.45) 98.68,108.3 98.68,108.3 arc(98.9,108.08) 99.2,108 arc(99.4,107.95) 99.55,107.8 99.55,107.8 arc(99.77,107.58) 100.07,107.5 arc(100.27,107.45) 100.41,107.3 100.41,107.3 arc(100.63,107.08) 100.93,107 100.94,107 arc(101.13,106.95) 101.28,106.8 101.28,106.8 arc(101.5,106.58) 101.8,106.5 arc(102,106.45) 102.14,106.3 102.15,106.3 arc(102.36,106.08) 102.66,106 102.67,106 arc(102.86,105.95) 103.01,105.8 103.01,105.8 arc(103.23,105.58) 103.53,105.5 103.53,105.5 arc(103.73,105.45) 103.88,105.3 103.88,105.3 arc(104.1,105.08) 104.4,105 104.4,105 arc(104.6,104.95) 104.74,104.8 104.74,104.8 arc(104.96,104.58) 105.26,104.5 105.26,104.5 arc(105.46,104.45) 105.61,104.3 105.61,104.3 arc(105.66,104.1) 105.61,103.9 arc(105.53,103.6) 105.61,103.3 arc(105.66,103.1) 105.61,102.9 arc(105.53,102.6) 105.61,102.3 arc(105.66,102.1) 105.61,101.9 arc(105.53,101.6) 105.61,101.3 arc(105.66,101.1) 105.61,100.9 arc(105.53,100.6) 105.61,100.3 arc(105.66,100.1) 105.61,99.9 arc(105.53,99.6) 105.61,99.3 arc(105.66,99.1) 105.61,98.9 arc(105.53,98.6) 105.61,98.3 arc(105.66,98.1) 105.61,97.9 arc(105.53,97.6) 105.61,97.3 arc(105.66,97.1) 105.61,96.9 arc(105.53,96.6) 105.61,96.3 arc(105.66,96.1) 105.61,95.9 105.61,95.9 arc(105.53,95.6) 105.61,95.3 105.61,95.3 arc(105.83,95.08) 106.13,95 arc(106.33,94.95) 106.47,94.8 106.48,94.8 arc(106.48,94.8) 106.48,94.79 arc(106.7,94.58) 106.99,94.5 107,94.5 arc(107.19,94.45) 107.34,94.3 107.34,94.3 arc(107.56,94.08) 107.86,94 107.86,94 arc(108.06,93.95) 108.21,93.8 108.21,93.8 arc(108.43,93.58) 108.73,93.5 108.73,93.5 arc(108.93,93.45) 109.07,93.3 109.07,93.3 arc(109.29,93.08) 109.59,93 109.6,93 arc(109.94,92.8) 109.94,92.41 109.94,92.4 arc(109.94,92.4) 109.94,92.39 arc(109.94,91.8) 110.46,91.5 110.46,91.5 arc(110.66,91.45) 110.8,91.3 110.81,91.3 arc(111.02,91.08) 111.32,91 111.33,91 arc(111.52,90.95) 111.67,90.8 111.67,90.8 arc(111.73,90.6) 111.67,90.4 arc(111.59,90.1) 111.67,89.8 arc(111.73,89.6) 111.67,89.4 arc(111.59,89.1) 111.67,88.8 arc(111.73,88.6) 111.67,88.4 arc(111.59,88.1) 111.67,87.8 arc(111.73,87.6) 111.67,87.4 arc(111.59,87.1) 111.67,86.8 arc(111.73,86.6) 111.67,86.4 arc(111.59,86.1) 111.67,85.8 arc(111.73,85.6) 111.67,85.4 arc(111.59,85.1) 111.67,84.8 arc(111.73,84.6) 111.67,84.4 arc(111.59,84.1) 111.67,83.8 arc(111.73,83.6) 111.67,83.4 arc(111.59,83.1) 111.67,82.8 arc(111.73,82.6) 111.67,82.4 arc(111.59,82.1) 111.67,81.8 111.67,81.8 arc(111.73,81.6) 111.67,81.4 arc(111.59,81.1) 111.67,80.8 111.67,80.8 arc(111.71,80.75) 111.75,80.7 arc(111.76,80.69) 111.77,80.67 122.2,70.24 122.72,70.24 122.83,70.14 123.02,70.14 123.12,70.24 123.31,70.24 123.42,70.14 123.61,70.14 123.71,70.24 129.81,70.24 134.53,65.53 134.53,65.38 134.66,65.24 134.81,65.24 134.94,65.11 134.94,64.96 135.08,64.83 135.23,64.83 136.91,63.15 136.91,62.35 137.8,61.46 153.53,61.46 153.64,61.34 153.9,61.34 154.01,61.46 154.27,61.46 154.38,61.34 154.58,61.34 154.7,61.46 154.9,61.46 155.02,61.34 155.24,61.34 155.36,61.46 155.66,61.46 155.78,61.34 155.96,61.34 156.07,61.46 156.28,61.46 156.39,61.35 156.58,61.35 156.68,61.46 156.87,61.46 156.98,61.35 157.17,61.35 157.27,61.46 157.63,61.46 157.76,61.59 157.91,61.59 158.04,61.73 158.04,61.87 158.61,62.43 159.52,62.43 159.61,62.34 159.61,62.15 159.51,62.04 159.51,61.86 159.61,61.75 159.61,61.47 159.52,61.38 158.86,61.38 158.76,61.47 v2(158.76,61.68)
