# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MEM_DQA20: length 69.2
  TOP w0.109: v2(145.57,52.12) 145.57,53.3
  ART05 w0.114: v2(145.57,52.12) 145.98,52.54 148.58,52.54 148.78,52.73 148.78,60.66 148.34,61.1 148.34,63.67 145.88,66.13 145.88,66.29 146.21,66.62 146.21,66.78 146.05,66.94 145.89,66.94 145.56,66.61 145.4,66.61 145.24,66.77 145.24,66.94 145.56,67.26 145.56,67.42 145.4,67.59 145.24,67.59 144.91,67.26 144.75,67.26 144.59,67.42 144.59,67.58 144.92,67.91 144.92,68.07 144.76,68.23 144.59,68.23 144.27,67.91 144.1,67.91 142.12,69.89 142.12,73.58 138.66,77.04 138.66,78.2 136.87,79.99 136.87,80.85 arc(136.94,81.1) 136.87,81.35 arc(136.81,81.6) 136.87,81.85 136.88,81.85 arc(136.94,82.1) 136.87,82.35 arc(136.81,82.6) 136.87,82.85 136.87,82.85 arc(136.94,83.1) 136.87,83.35 arc(136.81,83.6) 136.87,83.85 arc(136.94,84.1) 136.87,84.35 arc(136.81,84.6) 136.87,84.85 arc(136.94,85.1) 136.87,85.35 arc(136.81,85.6) 136.87,85.85 arc(136.94,86.1) 136.87,86.35 136.87,86.35 arc(136.69,86.53) 136.44,86.6 arc(136.19,86.67) 136.01,86.85 136.01,86.85 arc(135.83,87.03) 135.58,87.1 135.57,87.1 arc(135.33,87.17) 135.14,87.35 135.14,87.35 arc(134.96,87.53) 134.71,87.6 134.71,87.6 arc(134.46,87.67) 134.28,87.85 arc(134.1,88.03) 133.85,88.1 133.84,88.1 arc(133.6,88.17) 133.41,88.35 133.41,88.35 arc(133.23,88.53) 132.98,88.6 arc(132.73,88.67) 132.55,88.85 132.54,88.85 arc(132.36,89.03) 132.11,89.1 132.11,89.1 arc(131.86,89.17) 131.68,89.35 131.68,89.35 arc(131.49,89.53) 131.25,89.6 131.24,89.6 arc(130.99,89.67) 130.81,89.85 130.81,89.85 arc(130.63,90.03) 130.38,90.1 arc(130.13,90.17) 129.95,90.35 129.94,90.35 arc(129.76,90.53) 129.51,90.6 arc(129.26,90.67) 129.08,90.85 129.08,90.85 arc(128.65,91.1) 128.22,90.85 128.21,90.85 arc(128.03,90.67) 127.78,90.6 127.78,90.6 arc(127.53,90.53) 127.35,90.35 127.35,90.35 arc(127.16,90.17) 126.92,90.1 126.91,90.1 arc(126.66,90.03) 126.48,89.85 126.48,89.85 arc(126.3,89.67) 126.05,89.6 arc(125.8,89.53) 125.62,89.35 125.61,89.35 arc(125.43,89.17) 125.18,89.1 arc(124.94,89.03) 124.75,88.85 124.75,88.85 arc(124.57,88.67) 124.32,88.6 124.32,88.6 arc(124.07,88.53) 123.89,88.35 123.88,88.35 arc(123.7,88.17) 123.45,88.1 123.45,88.1 arc(123.2,88.03) 123.02,87.85 123.02,87.85 arc(122.83,87.67) 122.58,87.6 arc(122.34,87.53) 122.15,87.35 122.15,87.35 arc(122.09,87.1) 122.15,86.85 arc(122.22,86.6) 122.15,86.35 arc(122.09,86.1) 122.15,85.85 arc(122.22,85.6) 122.15,85.35 arc(122.09,85.1) 122.15,84.85 122.15,84.85 arc(122.34,84.67) 122.58,84.6 122.74,84.6 123.45,83.89 v2(123.45,83.6)
MEM_DQA21: length 69.3
  TOP w0.109: v2(145.82,62.68) CON1.45
  ART05 w0.114: v2(124.32,84.1) 123.88,84.53 123.88,85.85 arc(123.82,86.1) 123.88,86.35 123.89,86.35 arc(124.07,86.53) 124.32,86.6 124.32,86.6 arc(124.57,86.67) 124.75,86.85 124.75,86.85 arc(124.94,87.03) 125.18,87.1 arc(125.43,87.17) 125.61,87.35 125.62,87.35 arc(125.8,87.53) 126.05,87.6 arc(126.3,87.67) 126.48,87.85 126.48,87.85 arc(126.66,88.03) 126.91,88.1 126.92,88.1 arc(127.16,88.17) 127.35,88.35 127.35,88.35 arc(127.53,88.53) 127.78,88.6 127.78,88.6 arc(128.03,88.67) 128.21,88.85 128.22,88.85 arc(128.65,89.1) 129.08,88.85 129.08,88.85 arc(129.26,88.67) 129.51,88.6 arc(129.76,88.53) 129.94,88.35 129.95,88.35 arc(130.13,88.17) 130.38,88.1 arc(130.63,88.03) 130.81,87.85 130.81,87.85 arc(131,87.67) 131.25,87.6 131.25,87.6 arc(131.5,87.53) 131.68,87.35 131.68,87.35 arc(131.86,87.17) 132.11,87.1 132.11,87.1 arc(132.36,87.03) 132.54,86.85 132.55,86.85 arc(132.73,86.67) 132.98,86.6 132.98,86.6 arc(133.23,86.53) 133.41,86.35 133.41,86.35 arc(133.6,86.17) 133.84,86.1 arc(134.09,86.03) 134.27,85.85 134.28,85.85 arc(134.46,85.67) 134.71,85.6 134.71,85.6 arc(134.96,85.53) 135.14,85.35 135.14,85.35 arc(135.21,85.1) 135.14,84.85 arc(135.08,84.6) 135.14,84.35 arc(135.21,84.1) 135.14,83.85 arc(135.08,83.6) 135.14,83.35 arc(135.21,83.1) 135.14,82.85 135.14,82.85 arc(135.08,82.6) 135.14,82.35 arc(135.21,82.1) 135.14,81.85 135.14,81.85 arc(135.07,81.6) 135.14,81.35 arc(135.19,81.23) 135.21,81.1 135.21,80.35 137.25,78.31 137.25,73.69 137.74,73.2 137.91,73.2 139.6,74.89 139.76,74.89 139.92,74.73 139.92,74.57 138.23,72.88 138.23,72.71 138.39,72.55 138.55,72.55 140.24,74.24 140.41,74.24 140.57,74.08 140.57,73.92 138.88,72.23 138.88,72.07 139.04,71.91 139.2,71.91 140.89,73.6 141.05,73.6 141.21,73.44 141.21,73.27 139.52,71.58 139.52,71.42 139.68,71.26 139.85,71.26 141.09,72.5 141.25,72.5 141.41,72.34 141.41,72.17 140.17,70.94 140.17,70.77 140.34,70.6 140.5,70.6 141.11,71.22 141.28,71.22 141.43,71.06 141.43,70.89 140.82,70.28 140.82,70.12 146.39,64.56 146.39,61.02 146.27,60.91 145.93,60.91 145.82,61.02 v2(145.82,62.68)
MEM_DQA22: length 66.1
  TOP w0.109: v2(142.57,52.12) CON1.58
  ART05 w0.114: v2(142.57,52.12) 142.31,52.12 142.14,51.96 142.14,51.04 142.26,50.93 142.97,50.93 143.08,51.04 143.08,52.26 143.59,52.77 143.59,53.46 143.7,53.57 143.94,53.57 144.06,53.69 144.06,53.92 143.94,54.03 143.7,54.03 143.59,54.14 143.59,54.98 143.7,55.09 146.18,55.09 146.29,55.2 146.29,55.43 146.18,55.55 143.7,55.55 143.59,55.66 143.59,55.89 143.7,56 146.16,56 146.28,56.12 146.28,56.35 146.16,56.46 143.7,56.46 143.59,56.58 143.59,56.8 143.7,56.92 146.18,56.92 146.3,57.03 146.3,57.26 146.18,57.38 143.7,57.38 143.59,57.49 143.59,60.94 143.47,61.05 142.7,61.05 142.58,61.17 142.58,62.36 142.68,62.46 142.68,63.06 142.12,63.62 142.12,63.8 140.31,65.6 139.91,65.6 137.16,68.35 135.49,68.35 135.37,68.46 135.37,72.47 134.89,72.95 131.32,72.95 131.13,73.13 131.13,80.25 131.74,80.87 131.74,81.1 arc(131.73,81.23) 131.68,81.35 arc(131.61,81.6) 131.68,81.85 131.68,81.85 arc(131.74,82.1) 131.68,82.35 arc(131.61,82.6) 131.68,82.85 131.68,82.85 arc(131.74,83.1) 131.68,83.35 131.68,83.35 arc(131.49,83.53) 131.25,83.6 131.24,83.6 arc(130.99,83.67) 130.81,83.85 130.81,83.85 arc(130.63,84.03) 130.38,84.1 arc(130.13,84.17) 129.95,84.35 129.94,84.35 arc(129.76,84.53) 129.51,84.6 arc(129.26,84.67) 129.08,84.85 129.08,84.85 arc(128.9,85.03) 128.67,85.09 127.81,85.09 arc(127.79,85.09) v2(127.78,85.1)
MEM_DQA23: length 66.2
  TOP w0.109: CON1.59 142.32,62.39 v2(141.95,62.76)
  ART05 w0.114: v2(141.95,62.76) 141.87,62.76 141.55,62.44 141.55,62.19 141.66,62.08 141.83,62.08 141.95,61.96 141.95,60.78 142.23,60.5 142.23,60.15 141.92,59.84 141.92,55.23 141.7,55.01 140.25,55.01 140.14,55.13 140.14,55.54 140.27,55.67 141.42,55.67 141.54,55.78 141.54,56.06 141.42,56.18 140.24,56.18 140.12,56.29 140.12,56.5 140.25,56.63 141.42,56.63 141.54,56.75 141.54,56.98 141.42,57.09 140.24,57.09 140.12,57.2 140.12,57.42 140.25,57.55 141.42,57.55 141.54,57.66 141.54,57.89 141.42,58.01 140.24,58.01 140.12,58.12 140.12,58.33 140.25,58.46 141.42,58.46 141.54,58.58 141.54,58.79 141.42,58.9 140.24,58.9 140.12,59.02 140.12,59.25 140.24,59.36 141.21,59.36 141.33,59.48 141.33,60.75 141.21,60.86 140.46,60.86 140.3,61.02 140.3,61.2 140.39,61.29 141.43,61.29 141.56,61.42 141.56,61.62 141.45,61.74 140.27,61.74 140.16,61.85 140.16,62.07 140.27,62.18 140.84,62.18 140.92,62.27 140.92,62.43 140.75,62.6 140.75,62.93 140.47,63.21 140.47,63.96 139.77,64.65 139.51,64.65 136.77,67.4 134.53,67.4 134.42,67.51 134.42,69.79 134.06,70.15 129.13,70.15 129.01,70.27 129.01,72.93 129.51,73.43 129.51,78.91 129.01,79.41 129.01,81.1 arc(129.03,81.23) 129.08,81.35 arc(129.15,81.6) 129.08,81.85 129.08,81.85 arc(128.9,82.03) 128.65,82.1 arc(128.4,82.17) 128.22,82.34 128.21,82.35 arc(128.03,82.53) 127.78,82.6 arc(127.53,82.67) 127.35,82.85 126.92,83.59 arc(126.92,83.6) v2(126.92,83.6)
MEM_DQA24: length 67
  TOP w0.109: v2(139.57,52.12) CON1.70
  ART05 w0.114: v2(124.32,82.1) 123.89,81.67 123.89,79.26 124.59,78.56 124.59,74.24 124.33,73.99 124.03,73.99 123.8,73.76 123.8,64.94 123.45,64.59 123.45,62.33 123.34,62.23 123,62.23 122.88,62.11 122.88,61.88 123,61.77 123.68,61.77 123.8,61.65 123.8,61.43 123.68,61.31 123,61.31 122.88,61.2 122.88,60.97 123,60.85 123.8,60.85 123.95,60.71 123.95,59.9 123.84,59.79 123.45,59.79 123.34,59.67 123.34,59.47 123.48,59.33 123.78,59.33 123.9,59.22 123.9,58.55 123.72,58.37 123.21,58.37 123.14,58.29 123.14,56.08 124.08,55.14 125.07,55.14 125.19,55.03 125.19,54.32 125.36,54.15 130.07,54.15 130.18,54.04 130.18,52.99 130.3,52.88 130.52,52.88 130.64,52.99 130.64,54.04 130.75,54.15 130.98,54.15 131.1,54.04 131.1,52.99 131.21,52.88 131.44,52.88 131.55,52.99 131.55,54.04 131.67,54.15 131.9,54.15 132.01,54.04 132.01,52.99 132.12,52.88 132.35,52.88 132.47,52.99 132.47,54.04 132.58,54.15 132.81,54.15 132.92,54.04 132.92,52.99 133.04,52.88 133.27,52.88 133.38,52.99 133.38,54.04 133.5,54.15 133.72,54.15 133.84,54.04 133.84,52.99 133.95,52.88 134.18,52.88 134.3,52.99 134.3,54.04 134.41,54.15 134.65,54.15 134.83,53.97 134.83,53.03 134.96,52.9 135.25,52.9 135.36,53 135.36,53.54 135.53,53.71 136.36,53.71 136.53,53.55 136.53,51.08 136.78,50.82 138.84,50.82 139.16,51.14 139.16,51.71 v2(139.57,52.12)
MEM_DQA25: length 64.7
  TOP w0.109: v2(139.32,62.68) CON1.71
  ART05 w0.114: v2(126.92,81.6) 127.02,81.49 127.02,79.91 128.46,78.47 128.46,74.01 128.27,73.82 127.59,73.82 126.99,73.22 126.99,72.66 127.11,72.55 127.84,72.55 127.95,72.43 127.95,66.25 128.06,66.13 129.1,66.13 129.68,65.55 137.12,65.55 138.83,63.85 138.83,61.13 138.37,60.67 138.37,59.92 138.63,59.65 138.63,59.33 138.5,59.19 136.56,59.19 136.44,59.08 136.44,58.84 136.56,58.72 138.79,58.72 138.9,58.61 138.9,58.38 138.79,58.27 136.56,58.27 136.44,58.15 136.44,57.92 136.56,57.81 138.79,57.81 138.9,57.7 138.9,57.47 138.79,57.35 136.56,57.35 136.44,57.24 136.44,57.01 136.56,56.9 138.81,56.9 138.92,56.78 138.92,56.55 138.81,56.44 136.56,56.44 136.44,56.32 136.44,56.03 136.56,55.92 139.23,55.92 139.34,56.03 139.34,62.66 v2(139.32,62.68)
MEM_DQA26: length 67.9
  TOP w0.109: CON1.83 136.32,62.87 136.08,63.11 v2(136.08,63.2)
  ART05 w0.114: v2(123.45,82.6) 124.32,82.6 arc(124.57,82.53) 124.75,82.35 124.75,82.35 arc(124.82,82.1) 124.75,81.85 124.75,81.85 arc(124.68,81.6) 124.75,81.35 124.75,79.54 125.24,79.04 125.24,65.03 124.92,64.71 124.92,62.6 124.64,62.31 124.64,61.94 124.75,61.83 125.06,61.83 125.17,61.71 125.17,61.49 125.06,61.37 124.75,61.37 124.64,61.26 124.64,61.03 124.75,60.91 125.06,60.91 125.17,60.8 125.17,60.57 125.06,60.46 124.75,60.46 124.64,60.34 124.64,59.54 124.75,59.42 126.7,59.42 126.81,59.31 126.81,59.08 126.7,58.97 124.75,58.97 124.64,58.85 124.64,58.62 124.75,58.51 127.62,58.51 127.73,58.39 127.73,58.17 127.62,58.05 124.75,58.05 124.64,57.94 124.64,56.72 124.75,56.61 126.31,56.61 126.43,56.72 126.43,57.58 126.54,57.7 126.77,57.7 126.88,57.58 126.88,56.72 127,56.61 127.23,56.61 127.34,56.72 127.34,57.58 127.45,57.7 127.68,57.7 127.8,57.58 127.8,56.72 127.91,56.61 128.14,56.61 128.25,56.72 128.25,57.58 128.37,57.7 128.6,57.7 128.71,57.58 128.71,56.72 128.83,56.61 132.03,56.61 132.7,55.94 133.43,55.94 133.55,56.05 133.55,56.62 133.66,56.73 133.89,56.73 134,56.62 134,56.05 134.12,55.94 134.35,55.94 134.46,56.05 134.46,56.62 134.57,56.73 134.8,56.73 134.92,56.62 134.92,56.05 135.03,55.94 135.27,55.94 135.39,56.05 135.39,62.03 136.08,62.73 v2(136.08,63.2)
MEM_DQA27: length 67.6
  TOP w0.109: v2(136.07,52.12) CON1.84
  ART05 w0.114: v2(136.07,52.12) 136.07,52.44 135.95,52.56 129.86,52.56 129.75,52.67 129.75,53.7 129.64,53.82 129.41,53.82 129.29,53.7 129.29,52.67 129.18,52.56 128.95,52.56 128.83,52.67 128.83,53.7 128.72,53.82 128.49,53.82 128.38,53.7 128.38,52.67 128.26,52.56 128.03,52.56 127.92,52.67 127.92,53.7 127.81,53.82 127.58,53.82 127.46,53.7 127.46,52.67 127.35,52.56 127.12,52.56 127.01,52.67 127.01,53.54 126.89,53.66 121.55,53.66 121.43,53.77 121.43,54.04 121.55,54.15 123.14,54.15 123.25,54.27 123.25,55.18 123.11,55.33 121.52,55.33 121.42,55.43 121.42,55.67 121.53,55.78 122.62,55.78 122.74,55.9 122.74,56.13 122.62,56.24 121.55,56.24 121.43,56.36 121.43,56.58 121.55,56.7 122.62,56.7 122.74,56.81 122.74,57.04 122.62,57.16 121.57,57.16 121.46,57.27 121.46,57.5 121.57,57.61 122.62,57.61 122.74,57.73 122.74,57.96 122.62,58.07 121.57,58.07 121.46,58.18 121.46,60.14 121.64,60.33 122.38,60.33 122.51,60.45 122.51,60.85 122.4,60.97 121.45,60.97 121.33,61.08 121.33,61.31 121.45,61.42 122.4,61.42 122.51,61.54 122.51,61.77 122.4,61.88 121.45,61.88 121.33,61.99 121.33,62.22 121.45,62.34 122.4,62.34 122.51,62.45 122.51,64.12 123.47,65.07 123.47,80.85 123.45,80.86 v2(123.45,81.6)
MEM_DQA28: length 62.4
  TOP w0.109: v2(140.57,52.12) CON1.66
  ART05 w0.114: v2(140.57,52.12) 140.19,52.12 139.78,52.54 139.74,52.54 138.97,52.54 138.84,52.66 138.84,53.99 138.96,54.1 139.14,54.1 139.25,54 139.25,52.98 139.37,52.86 139.53,52.86 139.66,52.98 139.66,54.39 139.66,55.89 139.66,55.9 139.66,59.79 139.77,59.89 140.26,59.89 140.38,60.01 140.38,60.35 139.73,61 139.73,63.65 139.46,63.92 139.21,63.92 137.25,65.87 129.85,65.87 129.73,65.99 129.73,66.16 129.84,66.27 136.37,66.27 136.48,66.38 136.48,66.54 136.37,66.66 128.45,66.66 128.27,66.84 128.27,72.73 128.13,72.86 127.46,72.86 127.35,72.97 127.35,73.13 127.53,73.31 128.35,73.31 128.78,73.74 128.78,78.61 127.34,80.04 127.34,81.66 v2(127.78,82.1)
MEM_DQA29: length 62.3
  TOP w0.109: v2(140.32,62.68) CON1.67
  ART05 w0.114: v2(140.32,62.68) 140.05,62.95 140.05,63.78 139.6,64.23 139.34,64.23 136.59,66.98 128.7,66.98 128.58,67.09 128.58,67.33 128.7,67.45 133.89,67.45 134,67.56 134,67.79 133.89,67.9 128.7,67.9 128.58,68.02 128.58,68.25 128.7,68.36 133.89,68.36 134,68.47 134,68.7 133.89,68.82 128.7,68.82 128.58,68.93 128.58,69.16 128.7,69.27 133.89,69.27 134,69.39 134,69.62 133.89,69.73 128.7,69.73 128.58,69.85 128.58,73.1 129.09,73.6 129.09,78.74 128.27,79.56 128.27,79.72 128.37,79.82 128.37,79.98 128.21,80.14 128.05,80.14 127.95,80.04 127.79,80.04 127.62,80.21 127.62,80.94 v2(127.78,81.1)
MEM_DQA30: length 64.6
  TOP w0.109: CON1.79 137.32,62.37 137.69,62.74 v2(137.68,62.74)
  ART05 w0.114: v2(126.92,82.6) 126.92,82.3 126.41,81.8 126.41,81.41 126.64,81.18 126.64,79.84 128.14,78.34 128.14,74.28 128,74.14 127.46,74.14 126.62,73.3 126.62,72.23 126.73,72.11 127.51,72.11 127.62,72 127.62,71.77 127.51,71.66 126.73,71.66 126.62,71.54 126.62,71.31 126.73,71.2 127.51,71.2 127.62,71.09 127.62,70.86 127.51,70.74 126.73,70.74 126.62,70.63 126.62,70.4 126.73,70.29 127.51,70.29 127.62,70.17 127.62,69.94 127.51,69.83 126.73,69.83 126.62,69.71 126.62,69.49 126.73,69.37 127.51,69.37 127.62,69.26 127.62,69.03 127.51,68.91 126.73,68.91 126.62,68.8 126.62,68.57 126.73,68.46 127.51,68.46 127.62,68.34 127.62,68.11 127.51,68 126.73,68 126.62,67.89 126.62,67.66 126.73,67.54 127.51,67.54 127.62,67.43 127.62,67.2 127.51,67.09 126.73,67.09 126.62,66.97 126.62,66.74 126.73,66.63 127.51,66.63 127.62,66.51 127.62,66.29 127.51,66.17 126.73,66.17 126.62,66.06 126.62,65.26 126.77,65.11 126.98,65.11 127.13,65.26 127.13,65.64 127.32,65.82 128.92,65.82 128.92,65.82 128.97,65.82 129.55,65.24 131.14,65.24 131.26,65.12 131.26,64.89 131.14,64.78 129.5,64.78 129.39,64.66 129.39,64.48 129.55,64.32 131.14,64.32 131.26,64.21 131.26,63.98 131.14,63.86 130.07,63.86 129.95,63.74 129.95,60.83 130.07,60.72 130.82,60.72 130.93,60.83 130.93,62.24 131.04,62.36 131.27,62.36 131.39,62.24 131.39,60.83 131.5,60.72 131.79,60.72 131.9,60.83 131.9,63.17 131.6,63.46 131.6,64.78 131.98,65.15 137.07,65.15 137.49,64.73 137.49,62.93 v2(137.68,62.74)
MEM_DQA31: length 66.9
  TOP w0.109: v2(137.07,52.12) CON1.80
  ART05 w0.114: v2(124.32,81.1) 124.32,79.44 124.9,78.85 124.9,73.79 124.79,73.67 124.22,73.67 124.11,73.57 124.11,73.33 124.23,73.21 124.81,73.21 124.93,73.1 124.93,72.87 124.81,72.76 124.23,72.76 124.11,72.64 124.11,72.41 124.23,72.3 124.81,72.3 124.93,72.19 124.93,71.96 124.81,71.84 124.23,71.84 124.11,71.73 124.11,71.5 124.23,71.39 124.81,71.39 124.93,71.27 124.93,71.04 124.81,70.93 124.23,70.93 124.11,70.81 124.11,70.59 124.23,70.47 124.81,70.47 124.93,70.36 124.93,70.13 124.81,70.01 124.23,70.01 124.11,69.9 124.11,69.67 124.23,69.56 124.81,69.56 124.93,69.44 124.93,69.21 124.81,69.1 124.23,69.1 124.11,68.99 124.11,68.76 124.23,68.64 124.81,68.64 124.93,68.53 124.93,68.3 124.81,68.19 124.23,68.19 124.11,68.07 124.11,67.84 124.23,67.73 124.81,67.73 124.93,67.61 124.93,67.39 124.81,67.27 124.23,67.27 124.11,67.16 124.11,66.93 124.23,66.81 124.81,66.81 124.93,66.7 124.93,66.47 124.81,66.36 124.23,66.36 124.11,66.24 124.11,66.01 124.23,65.9 124.81,65.9 124.93,65.79 124.93,65.56 124.81,65.44 124.23,65.44 124.11,65.33 124.11,65.09 124.23,64.97 124.47,64.97 124.58,64.86 124.58,64.63 124.47,64.52 123.88,64.52 123.77,64.4 123.77,63.75 123.88,63.64 123.98,63.64 124.09,63.52 124.09,63.3 123.98,63.18 123.88,63.18 123.77,63.07 123.77,62.35 123.89,62.23 124.17,62.23 124.28,62.12 124.28,58.08 124.13,57.93 123.58,57.93 123.47,57.82 123.47,57.58 123.58,57.46 124.14,57.46 124.25,57.35 124.25,57.12 124.14,57 123.58,57 123.47,56.89 123.47,56.66 123.58,56.55 124.14,56.55 124.52,56.16 126.57,56.16 126.73,56 126.73,55.33 126.92,55.14 127.66,55.14 127.81,55.28 127.81,56.03 127.94,56.16 128.92,56.16 129.05,56.02 129.05,55.24 129.2,55.09 130.21,55.09 130.38,55.26 130.38,55.94 130.52,56.08 130.82,56.08 130.97,55.93 130.97,55.17 131.09,55.05 131.32,55.05 131.43,55.17 131.43,56.03 131.55,56.14 131.8,56.14 131.91,56.03 131.91,55.65 132.11,55.45 134.89,55.45 135.11,55.23 135.11,54.23 135.22,54.12 137.46,54.12 137.61,53.97 137.61,53.73 137.5,53.61 137.07,53.61 136.96,53.5 136.96,53.27 137.07,53.15 137.5,53.15 137.61,53.04 137.61,52.66 v2(137.07,52.12)
MEM_DQA32: length 57.8
  TOP w0.109: v2(122.32,51.92) 122.32,52.04 122.07,52.3 CON1.140
  ART07 w0.114: v2(122.32,51.92) 122.78,51.46 124.91,51.46 125.73,50.64 135.35,50.64 135.55,50.84 135.55,52.37 135.14,52.78 135.14,55.94 135.02,56.06 134.6,56.06 134.48,56.17 134.48,56.4 134.6,56.51 135.02,56.51 135.14,56.63 135.14,56.86 135.02,56.97 134.6,56.97 134.48,57.09 134.48,57.31 134.6,57.43 136.67,57.43 137.23,57.99 137.23,65.13 129.23,73.13 129.23,78.87 129.08,79.02 129.08,82.37 129.36,82.65 129.74,82.65 130.15,83.06 130.66,83.06 131.11,82.6 v2(132.11,82.6)
MEM_DQA33: length 64.6
  TOP w0.109: v2(122.37,54.69) 122.57,54.49 CON1.138
  ART05 w0.114: v2(126.05,82.1) 126.05,82.46 125.37,83.13 124.99,83.13 124.56,83.57 124.18,83.57 123.67,83.06 123.29,83.06 123.04,82.8 123.04,65.59 121,63.56 121,55.43 120.37,54.8 120.37,51.58 120.49,51.46 123.45,51.46 123.55,51.37 125.37,51.37 125.86,51.85 125.86,52.28 125.74,52.4 120.86,52.4 120.75,52.51 120.75,52.74 120.86,52.86 126.55,52.86 126.67,52.98 126.67,53.22 126.56,53.34 120.88,53.34 120.75,53.47 120.75,54.57 120.86,54.69 v2(122.37,54.69)
MEM_DQB0: length 73
  TOP w0.109: v2(111.57,52.12) CON1.174
  ART05 w0.114: v2(120.85,84.1) 121.12,83.94 121.15,83.83 arc(121.11,83.56) 121.19,83.3 arc(121.25,83.1) 121.19,82.9 121.19,82.9 arc(121.11,82.6) 121.19,82.3 arc(121.25,82.1) 121.19,81.9 arc(121.11,81.6) 121.19,81.3 arc(121.22,81.23) 121.24,81.15 121.24,80.25 120.69,79.7 120.69,66.09 119.78,65.18 113.95,65.18 113.3,64.52 111.81,64.52 111.57,64.27 111.57,63.08 111.44,62.95 111.44,62.6 111.97,62.08 111.97,61.83 111.85,61.72 110.44,61.72 110.33,61.61 110.33,61.38 110.44,61.26 111.85,61.26 111.97,61.15 111.97,59.34 112.08,59.22 113.28,59.22 113.44,59.06 113.44,58.88 113.32,58.76 111.68,58.76 111.57,58.65 111.57,58.42 111.7,58.29 115.25,58.29 115.37,58.18 115.37,57.95 115.25,57.83 111.68,57.83 111.57,57.72 111.57,57.51 111.7,57.38 115.96,57.38 116.09,57.25 116.09,57.03 115.97,56.92 111.68,56.92 111.57,56.81 111.57,56.59 111.7,56.46 116.02,56.46 116.13,56.35 116.13,52.89 116.01,52.76 111.68,52.76 111.57,52.65 v2(111.57,52.12)
MEM_DQB1: length 71
  TOP w0.109: v2(111.85,62.78) 111.82,62.74 CON1.173
  ART05 w0.114: v2(121.72,83.6) 121.45,83.76 121.35,83.73 arc(121.33,83.56) 121.38,83.4 arc(121.46,83.1) 121.38,82.8 arc(121.33,82.6) 121.38,82.4 arc(121.46,82.1) 121.38,81.8 121.38,81.8 arc(121.32,81.52) 121.44,81.27 arc(121.53,81.14) 121.56,80.97 121.56,79.93 121.01,79.38 121.01,65.92 120.71,65.61 120.71,65.45 120.89,65.27 120.89,65.11 120.73,64.95 120.56,64.95 120.38,65.13 120.22,65.13 119.86,64.77 114.04,64.77 113.93,64.66 113.93,64.42 114.05,64.31 119.38,64.31 119.49,64.19 119.49,62.6 119.39,62.5 119.14,62.5 119.02,62.63 119.02,63.87 118.9,63.98 118.27,63.98 118.14,63.85 118.14,62.65 117.98,62.49 117.42,62.49 117.3,62.61 117.3,63.28 117.19,63.39 116.55,63.39 116.43,63.51 116.43,63.81 116.34,63.9 116.1,63.9 116,63.79 116,63.5 115.89,63.39 115.68,63.39 115.56,63.51 115.56,63.8 115.45,63.91 115.21,63.91 115.1,63.79 115.1,63.51 114.98,63.4 114.75,63.4 114.64,63.51 114.64,63.79 114.53,63.91 114.31,63.91 114.18,63.78 114.18,63.36 114.44,63.09 116.88,63.09 116.99,62.98 116.99,62.77 116.87,62.65 114.59,62.65 114.48,62.53 114.48,62.31 114.6,62.19 119.38,62.19 119.49,62.07 119.49,61.83 119.38,61.72 113.9,61.72 113.78,61.83 113.78,62.08 113.9,62.2 114.08,62.2 114.15,62.27 114.15,62.93 113.81,63.28 113.81,63.94 113.55,64.2 113,64.2 112.83,64.04 112.83,63.6 112.72,63.49 112.44,63.49 112.34,63.59 112.34,64.09 112.23,64.2 112.02,64.2 111.9,64.08 111.9,62.82 v2(111.85,62.78)
MEM_DQB2: length 74
  TOP w0.109: v2(108.34,62.71) 108.32,62.69 CON1.187
  ART05 w0.114: v2(118.26,84.6) 117.83,84.17 117.83,80.43 117.99,80.27 118.89,80.27 119,80.16 119,79.92 118.89,79.8 117.66,79.8 117.55,79.69 117.55,79.46 117.66,79.34 118.89,79.34 119,79.23 119,79 118.89,78.89 117.66,78.89 117.55,78.77 117.55,78.54 117.66,78.43 118.89,78.43 119,78.31 119,78.09 118.89,77.97 117.66,77.97 117.55,77.86 117.55,77.63 117.66,77.51 118.89,77.51 119,77.4 119,77.17 118.89,77.06 117.66,77.06 117.55,76.94 117.55,76.71 117.66,76.6 118.89,76.6 119,76.49 119,76.26 118.89,76.14 117.66,76.14 117.55,76.03 117.55,75.8 117.66,75.69 118.89,75.69 119,75.57 119,75.34 118.89,75.23 117.66,75.23 117.55,75.11 117.55,74.89 117.66,74.77 118.89,74.77 119,74.66 119,74.43 118.89,74.31 117.66,74.31 117.55,74.2 117.55,73.97 117.66,73.86 118.89,73.86 119,73.74 119,73.51 118.89,73.4 117.66,73.4 117.55,73.29 117.55,73.06 117.66,72.94 118.89,72.94 119,72.83 119,72.39 118.89,72.27 114.71,72.27 114.59,72.15 114.59,71.03 114.47,70.92 109.61,70.92 108.55,69.86 108.55,63.62 107.93,63 107.93,61.64 107.81,61.53 106.8,61.53 106.68,61.42 106.68,61.19 106.8,61.07 107.81,61.07 107.93,60.96 107.93,60.72 107.83,60.62 107.42,60.62 107.29,60.5 107.29,60.14 107.75,59.68 107.75,55.14 107.86,55.03 108.12,55.03 108.23,55.14 108.23,59.62 108.34,59.73 v2(108.34,62.71)
MEM_DQB3: length 73.8
  TOP w0.109: v2(108.57,52.12) CON1.186
  ART05 w0.114: v2(108.57,52.12) 108.27,52.12 107.86,52.54 105.06,52.54 104.95,52.65 104.95,53.14 105.06,53.25 105.23,53.25 105.35,53.37 105.35,53.59 105.23,53.71 105.06,53.71 104.9,53.87 104.9,54.15 105.03,54.28 105.23,54.28 105.35,54.39 105.35,62.2 105.42,62.27 106.6,62.27 106.77,62.44 106.77,63.69 106.65,63.8 106.34,63.8 106.23,63.92 106.23,64.16 106.32,64.25 107.78,64.25 107.89,64.37 107.89,64.61 107.78,64.72 105.88,64.72 105.77,64.61 105.77,64.03 105.64,63.91 105.41,63.91 105.31,64.01 105.31,65.07 105.42,65.18 107.78,65.18 107.89,65.3 107.89,65.52 107.78,65.64 105.42,65.64 105.31,65.75 105.31,65.98 105.42,66.1 107.78,66.1 107.89,66.21 107.89,66.44 107.78,66.55 105.42,66.55 105.31,66.67 105.31,66.9 105.42,67.01 107.78,67.01 107.89,67.12 107.89,67.37 107.78,67.48 105.65,67.48 105.51,67.63 105.51,67.82 105.62,67.94 107.78,67.94 107.89,68.05 107.89,68.29 107.78,68.41 106.51,68.41 106.4,68.52 106.4,68.72 106.54,68.86 107.78,68.86 107.89,68.98 107.89,69.22 107.78,69.33 107.43,69.33 107.31,69.46 107.31,69.63 109.23,71.55 113.84,71.55 113.95,71.67 113.95,72.74 114.12,72.91 116.59,72.91 116.78,73.1 116.78,81.1 arc(116.8,81.26) 116.86,81.4 arc(116.92,81.6) 116.86,81.8 116.86,81.8 arc(116.78,82.1) 116.86,82.4 arc(116.92,82.6) 116.86,82.8 arc(116.78,83.1) 116.86,83.4 arc(116.92,83.6) 116.86,83.8 arc(116.78,84.06) 116.83,84.34 arc(116.86,84.39) 116.89,84.43 117.35,84.89 arc(117.38,84.93) 117.39,84.99 v2(117.39,85.1)
MEM_DQB4: length 73
  TOP w0.109: v2(112.57,52.12) CON1.170
  ART05 w0.114: v2(120.85,85.1) 121.12,84.94 121.15,84.83 arc(121.11,84.56) 121.19,84.3 arc(121.41,84.07) 121.71,83.99 121.72,83.99 arc(121.91,83.94) 122.06,83.8 122.06,83.8 arc(122.11,83.6) 122.06,83.4 arc(121.98,83.1) 122.06,82.8 arc(122.11,82.6) 122.06,82.4 arc(121.98,82.1) 122.06,81.8 122.06,81.8 arc(122.11,81.6) 122.06,81.4 arc(121.98,81.1) 122.06,80.8 122.06,80.8 122.06,79.74 121.33,79.01 121.33,77.99 121.33,77.99 121.33,64.93 120.43,64.03 120.14,64.03 119.84,63.73 119.84,61.61 119.63,61.4 113.7,61.4 113.33,61.78 113.33,62.95 113.1,63.18 112.67,63.18 112.41,62.91 112.41,60.96 112.6,60.77 119.71,60.77 119.83,60.65 119.83,59.02 119.71,58.91 118.79,58.91 118.79,58.91 116.74,58.91 116.54,58.71 116.54,58.57 116.66,58.45 119.7,58.45 119.83,58.32 119.83,58.11 119.71,57.99 116.66,57.99 116.54,57.88 116.54,57.65 116.66,57.54 119.7,57.54 119.83,57.41 119.83,57.17 119.68,57.02 116.57,57.02 116.45,56.91 116.45,52.73 116.08,52.36 112.81,52.36 v2(112.57,52.12)
MEM_DQB5: length 71
  TOP w0.109: v2(112.82,62.74) CON1.169
  ART05 w0.114: v2(121.72,84.6) 121.45,84.76 121.35,84.73 arc(121.33,84.56) 121.38,84.4 121.38,84.4 arc(121.53,84.26) 121.72,84.21 arc(122.02,84.13) 122.25,83.9 arc(122.33,83.6) 122.25,83.3 arc(122.19,83.1) 122.25,82.9 122.25,82.9 arc(122.33,82.6) 122.25,82.3 arc(122.19,82.1) 122.25,81.9 arc(122.33,81.6) 122.25,81.3 arc(122.2,81.04) 122.31,80.81 122.57,80.55 arc(122.6,80.5) 122.62,80.45 122.62,79.05 122.46,78.9 121.77,78.9 121.66,78.78 121.66,78.56 121.77,78.44 122.5,78.44 122.62,78.33 122.62,78.09 122.5,77.97 121.76,77.97 121.65,77.86 121.65,74.01 121.76,73.9 122.5,73.9 122.62,73.79 122.62,73.56 122.5,73.44 121.76,73.44 121.65,73.33 121.65,73.1 121.76,72.98 122.5,72.98 122.62,72.87 122.62,72.64 122.5,72.53 121.76,72.53 121.65,72.41 121.65,72.18 121.76,72.07 122.5,72.07 122.62,71.96 122.62,71.73 122.5,71.61 121.76,71.61 121.65,71.5 121.65,71.27 121.76,71.16 122.5,71.16 122.62,71.04 122.62,70.81 122.5,70.7 121.76,70.7 121.65,70.58 121.65,70.36 121.76,70.24 122.5,70.24 122.62,70.13 122.62,69.9 122.5,69.78 121.76,69.78 121.65,69.67 121.65,69.44 121.76,69.33 122.5,69.33 122.62,69.21 122.62,68.98 122.5,68.87 121.76,68.87 121.65,68.76 121.65,68.53 121.76,68.41 122.5,68.41 122.62,68.3 122.62,68.07 122.5,67.96 121.76,67.96 121.65,67.84 121.65,67.61 121.76,67.5 122.5,67.5 122.62,67.38 122.62,67.16 122.5,67.04 121.76,67.04 121.65,66.93 121.65,66.7 121.76,66.58 122.5,66.58 122.62,66.47 122.62,66.24 122.5,66.13 121.76,66.13 121.65,66.01 121.65,65.82 121.77,65.7 121.99,65.7 122.1,65.59 122.1,65.25 120.56,63.71 120.27,63.71 120.16,63.59 120.16,63.12 120.58,62.7 120.58,55.61 119.95,54.97 119.95,53.07 119.83,52.95 119.53,52.95 119.42,53.07 119.42,55.05 120.14,55.78 120.14,60.93 119.99,61.08 113.21,61.08 112.82,61.47 v2(112.82,62.74)
MEM_DQB6: length 74
  TOP w0.109: v2(109.23,62.74) 109.32,62.65 CON1.183
  ART05 w0.114: v2(109.23,62.74) 109.28,62.7 109.28,60.91 109.62,60.57 110.48,60.57 110.68,60.37 110.68,59.37 110.57,59.25 109.18,59.25 109.07,59.14 109.07,58.91 109.18,58.79 110.57,58.79 110.68,58.68 110.68,58.45 110.57,58.34 109.18,58.34 109.07,58.22 109.07,57.99 109.18,57.88 110.57,57.88 110.68,57.76 110.68,57.54 110.57,57.42 109.18,57.42 109.07,57.31 109.07,57.08 109.18,56.96 110.57,56.96 110.68,56.85 110.68,56.62 110.57,56.51 109.18,56.51 109.07,56.39 109.07,56.16 109.18,56.05 110.57,56.05 110.68,55.94 110.68,55.71 110.57,55.59 109.18,55.59 109.07,55.48 109.07,55.25 109.18,55.14 110.57,55.14 110.68,55.02 110.68,53.9 110.57,53.78 109.03,53.78 108.92,53.67 108.92,53.44 109.03,53.33 110.57,53.33 110.68,53.21 110.68,52.98 110.57,52.87 108.72,52.87 108.61,52.98 108.61,59.34 109.28,60.02 109.28,60.35 108.82,60.82 108.82,63.02 108.87,63.07 108.87,69.7 109.77,70.6 114.79,70.6 114.9,70.71 114.9,71.58 115.28,71.96 119.21,71.96 119.32,72.07 119.32,80.58 119.23,80.67 118.77,80.67 118.68,80.76 118.68,83.49 118.56,83.6 v2(118.26,83.6)
MEM_DQB7: length 73.8
  TOP w0.109: v2(109.57,52.12) CON1.182
  ART05 w0.114: v2(109.57,52.12) 109.57,51.96 109.68,51.85 110.04,51.85 110.15,51.96 110.15,52.45 110.05,52.55 108.43,52.55 108.12,52.86 105.79,52.86 105.66,52.99 105.66,53.18 105.78,53.29 108.19,53.29 108.29,53.39 108.29,53.58 108.18,53.69 105.8,53.69 105.66,53.82 105.66,54.02 105.79,54.15 107.49,54.15 107.6,54.26 107.6,54.77 107.3,55.07 105.81,55.07 105.67,55.2 105.67,55.46 105.79,55.58 107.32,55.58 107.43,55.69 107.43,55.88 107.32,56 105.78,56 105.66,56.11 105.66,56.34 105.78,56.45 107.32,56.45 107.43,56.57 107.43,56.8 107.32,56.91 105.78,56.91 105.66,57.02 105.66,57.25 105.78,57.37 107.32,57.37 107.43,57.48 107.43,57.71 107.32,57.82 105.78,57.82 105.66,57.94 105.66,58.17 105.78,58.28 107.32,58.28 107.43,58.4 107.43,58.62 107.32,58.74 105.78,58.74 105.66,58.85 105.66,59.08 105.78,59.2 107.23,59.2 107.35,59.31 107.35,59.58 107.23,59.69 106.53,59.69 106.37,59.85 106.37,60.52 106.27,60.62 105.88,60.62 105.77,60.73 105.77,61.74 105.88,61.86 107.38,61.86 107.52,61.99 107.52,62.23 107.38,62.37 107.21,62.37 107.09,62.49 107.09,63.7 107.33,63.94 108.12,63.94 108.24,64.05 108.24,69.99 109.48,71.23 114.16,71.23 114.27,71.35 114.27,72.4 114.46,72.59 117.07,72.59 117.19,72.71 117.19,80.7 117,80.89 117,81.1 arc(117.01,81.2) 117.05,81.3 arc(117.13,81.6) 117.05,81.9 arc(117,82.1) 117.05,82.3 arc(117.13,82.6) 117.05,82.9 117.05,82.9 arc(117,83.1) 117.05,83.3 arc(117.1,83.41) 117.13,83.54 117.13,83.84 v2(117.39,84.1)
MEM_DQB8: length 67.4
  TOP w0.109: v2(106.32,62.68) CON1.195
  ART07 w0.114: v2(106.32,62.68) 106.4,62.76 106.4,64.61 106.79,65 110.54,65 110.76,65.23 111,65.23 111.22,65 111.45,65 111.57,65.12 112.02,65.12 112.14,65 112.57,65 112.69,65.12 112.69,65.27 112.8,65.38 113.03,65.38 113.14,65.27 113.14,65.12 113.26,65 113.62,65 113.73,65.12 113.73,66.16 113.85,66.28 114.1,66.28 114.21,66.16 114.21,65 114.33,64.88 114.53,64.88 114.65,65 114.65,66.21 114.76,66.33 115,66.33 115.14,66.19 115.14,64.32 115.25,64.21 115.45,64.21 115.56,64.32 115.56,66.16 115.68,66.28 115.91,66.28 116.02,66.16 116.02,64.63 116.13,64.52 116.36,64.52 116.48,64.63 116.48,66.23 116.59,66.35 116.82,66.35 116.93,66.23 116.93,64.79 117.05,64.68 117.28,64.68 117.39,64.79 117.39,66.26 117.51,66.37 117.73,66.37 117.85,66.26 117.85,65.12 117.96,65.01 118.19,65.01 118.31,65.12 118.31,66.03 118.42,66.14 118.65,66.14 118.76,66.03 118.76,65.15 118.88,65.03 119.2,65.03 119.31,65.15 119.31,65.81 119.43,65.92 120.23,65.92 120.34,66.04 120.34,66.29 120.23,66.41 119.74,66.41 119.63,66.52 119.63,66.75 119.74,66.86 120.23,66.86 120.34,66.98 120.34,67.21 120.23,67.32 119.74,67.32 119.63,67.43 119.63,67.66 119.74,67.78 120.23,67.78 120.34,67.89 120.34,68.12 120.23,68.23 119.74,68.23 119.63,68.35 119.63,68.58 119.74,68.69 120.23,68.69 120.34,68.81 120.34,69.03 120.23,69.15 119.74,69.15 119.63,69.26 119.63,69.49 119.74,69.61 120.23,69.61 120.34,69.72 120.34,69.95 120.23,70.06 119.74,70.06 119.63,70.18 119.63,70.41 119.74,70.52 120.23,70.52 120.34,70.63 120.34,70.86 120.23,70.98 119.74,70.98 119.63,71.09 119.63,71.32 119.74,71.43 120.23,71.43 120.34,71.55 120.34,71.78 120.23,71.89 119.74,71.89 119.63,72.01 119.63,72.23 119.74,72.35 120.23,72.35 120.34,72.46 120.34,72.69 120.23,72.81 119.74,72.81 119.63,72.92 119.63,73.15 119.74,73.26 120.23,73.26 120.34,73.38 120.34,73.61 120.23,73.72 119.74,73.72 119.63,73.83 119.63,74.06 119.74,74.18 120.23,74.18 120.34,74.29 120.34,74.52 120.23,74.63 119.74,74.63 119.63,74.75 119.63,74.98 119.74,75.09 120.23,75.09 120.34,75.21 120.34,75.43 120.23,75.55 119.74,75.55 119.63,75.66 119.63,75.89 119.74,76.01 120.23,76.01 120.34,76.12 120.34,76.35 120.23,76.46 119.74,76.46 119.63,76.58 119.63,76.81 119.74,76.92 120.23,76.92 120.34,77.04 120.34,77.26 120.23,77.38 119.74,77.38 119.63,77.49 119.63,77.72 119.74,77.84 120.23,77.84 120.34,77.95 120.34,78.38 120.43,78.47 120.43,81.68 v2(120.85,82.1)
MEM_DQB9: length 67.2
  TOP w0.109: v2(106.57,52.12) CON1.194
  ART07 w0.114: v2(120.85,81.1) 120.85,77.88 120.69,77.72 120.69,65.7 119.63,64.63 118.12,64.63 118,64.52 118,64.44 117.88,64.31 116.63,64.31 116.06,63.74 114.8,63.74 113.91,64.63 106.89,64.63 106.75,64.5 106.75,62.27 106.64,62.16 106.43,62.16 106.32,62.04 106.32,61.81 106.43,61.7 106.64,61.7 106.75,61.59 106.75,60.87 106.27,60.38 106.27,59.56 106.66,59.18 112.92,59.18 114.3,57.79 114.46,57.79 114.88,58.21 115.04,58.21 115.2,58.05 115.2,57.89 114.79,57.47 114.79,57.31 114.95,57.15 115.11,57.15 115.53,57.56 115.69,57.56 115.85,57.4 115.85,57.24 115.43,56.82 115.43,56.66 115.84,56.25 115.84,55.91 115.73,55.8 115.54,55.8 115.43,55.68 115.43,55.45 115.54,55.34 115.73,55.34 115.84,55.23 115.84,55 115.73,54.88 115.54,54.88 115.43,54.77 115.43,54.54 115.54,54.43 115.73,54.43 115.84,54.31 115.84,53.12 115.73,53.01 115.44,53.01 115.32,53.12 115.32,53.81 115.21,53.92 114.98,53.92 114.87,53.81 114.87,53.12 114.75,53.01 106.68,53.01 106.57,52.89 v2(106.57,52.12)
MEM_DQB10: length 70.3
  TOP w0.109: v2(103.61,62.72) 103.32,62.43 CON1.207
  ART07 w0.114: v2(103.61,62.72) 103.74,62.72 103.92,62.9 103.92,63.64 103.78,63.78 103.78,66.47 108.83,71.52 109.88,71.52 109.99,71.64 109.99,74.15 110.11,74.27 110.33,74.27 110.45,74.15 110.45,71.64 110.56,71.52 110.79,71.52 110.91,71.64 110.91,74.15 111.02,74.27 111.25,74.27 111.36,74.15 111.36,71.64 111.48,71.52 111.71,71.52 111.82,71.64 111.82,74.15 111.93,74.27 112.16,74.27 112.28,74.15 112.28,71.64 112.39,71.52 112.62,71.52 112.73,71.64 112.73,74.15 112.85,74.27 113.08,74.27 113.19,74.15 113.19,71.64 113.31,71.52 113.53,71.52 113.65,71.64 113.65,74.15 113.76,74.27 113.99,74.27 114.11,74.15 114.11,71.64 114.22,71.52 114.45,71.52 114.56,71.64 114.56,74.15 114.68,74.27 114.91,74.27 115.02,74.15 115.02,71.64 115.13,71.52 115.36,71.52 115.48,71.64 115.48,74.15 115.59,74.27 115.82,74.27 115.93,74.15 115.93,71.64 116.05,71.52 116.35,71.52 116.46,71.64 116.46,75.05 116.35,75.16 116,75.16 115.89,75.27 115.89,75.5 116,75.62 116.35,75.62 116.46,75.73 116.46,75.96 116.35,76.08 116,76.08 115.89,76.19 115.89,76.42 116,76.53 116.35,76.53 116.46,76.65 116.46,76.88 116.35,76.99 116,76.99 115.89,77.1 115.89,77.33 116,77.45 116.35,77.45 116.46,77.56 116.46,77.85 117.34,78.73 117.8,78.73 118.26,79.18 v2(118.26,81.6)
MEM_DQB11: length 70.2
  TOP w0.109: v2(103.07,52.12) CON1.208
  ART07 w0.114: v2(103.07,52.12) 102.55,51.61 102.55,50.95 102.67,50.83 103.41,50.83 103.6,51.03 103.6,52.39 104.01,52.8 104.01,55.36 104.12,55.48 104.91,55.48 105.03,55.59 105.03,56.09 105.14,56.21 105.37,56.21 105.48,56.09 105.48,55.59 105.6,55.48 105.83,55.48 105.94,55.59 105.94,56.09 106.06,56.21 106.29,56.21 106.4,56.09 106.4,55.59 106.51,55.48 106.74,55.48 106.86,55.59 106.86,56.09 106.97,56.21 107.2,56.21 107.31,56.09 107.31,55.59 107.43,55.48 107.66,55.48 107.77,55.59 107.77,56.09 107.89,56.21 108.11,56.21 108.23,56.09 108.23,55.59 108.34,55.48 108.57,55.48 108.69,55.59 108.69,56.09 108.8,56.21 109.03,56.21 109.14,56.09 109.14,55.59 109.26,55.48 109.49,55.48 109.6,55.59 109.6,56.09 109.71,56.21 109.94,56.21 110.06,56.09 110.06,55.59 110.17,55.48 110.4,55.48 110.51,55.59 110.51,56.09 110.63,56.21 110.86,56.21 110.97,56.09 110.97,55.59 111.09,55.48 111.48,55.48 111.59,55.59 111.59,56.36 111.43,56.52 105.86,56.52 105.28,57.09 105.28,57.25 105.6,57.57 105.6,57.73 105.43,57.89 105.27,57.89 104.96,57.58 104.8,57.58 104.64,57.74 104.64,57.9 104.95,58.21 104.95,58.38 104.79,58.54 104.63,58.54 104.31,58.22 104.15,58.22 103.99,58.39 103.99,58.55 104.3,58.86 104.3,59.02 104.14,59.18 103.98,59.18 103.67,58.87 103.5,58.87 102.33,60.04 102.33,60.85 102.45,60.96 102.53,60.96 102.65,61.08 102.65,61.3 102.53,61.42 102.45,61.42 102.33,61.53 102.33,61.89 102.74,62.29 102.74,66.44 108.63,72.32 109.18,72.32 109.29,72.44 109.29,74.62 109.74,75.07 115.06,75.07 115.17,75.18 115.17,77.56 117.45,79.83 117.45,81.04 v2(117.39,81.1)
MEM_DQB12: length 67
  TOP w0.109: v2(107.5,62.81) 107.49,62.81 107.32,62.64 CON1.191
  ART07 w0.114: v2(107.5,62.81) 107.5,62.34 107.61,62.23 107.85,62.23 107.97,62.11 107.97,60.75 108.08,60.63 108.31,60.63 108.43,60.75 108.43,62.11 108.54,62.23 108.77,62.23 108.88,62.11 108.88,60.75 109,60.63 109.23,60.63 109.34,60.75 109.34,62.11 109.45,62.23 109.68,62.23 109.8,62.11 109.8,60.75 109.91,60.63 110.14,60.63 110.25,60.75 110.25,62.11 110.37,62.23 110.6,62.23 110.71,62.11 110.71,60.75 110.83,60.63 111.06,60.63 111.17,60.75 111.17,62.11 111.28,62.23 111.8,62.23 111.91,62.11 111.91,60.78 112.03,60.67 113.2,60.67 113.32,60.78 113.32,61.03 113.2,61.14 112.66,61.14 112.55,61.25 112.55,61.48 112.66,61.6 113.2,61.6 113.32,61.71 113.32,63.03 113.5,63.21 113.55,63.21 113.56,63.22 114.13,63.22 114.24,63.11 114.24,62.01 114.36,61.89 114.7,61.89 114.81,62.01 114.81,62.92 114.93,63.03 115.16,63.03 115.27,62.92 115.27,62.08 115.39,61.96 115.61,61.96 115.73,62.08 115.73,62.92 115.84,63.03 116.07,63.03 116.19,62.92 116.19,62.11 116.3,62 116.53,62 116.64,62.11 116.64,62.92 116.76,63.03 116.99,63.03 117.1,62.92 117.1,62.57 117.21,62.45 117.5,62.45 117.62,62.34 117.62,61.87 117.73,61.76 117.96,61.76 118.07,61.87 118.07,62.34 118.19,62.45 119.01,62.45 119.13,62.57 119.13,63.49 119.24,63.61 119.47,63.61 119.58,63.49 119.58,62.57 119.7,62.45 119.95,62.45 120.06,62.34 120.06,61.81 120.18,61.7 120.41,61.7 120.52,61.81 120.52,62.34 120.63,62.45 121.26,62.45 121.37,62.57 121.37,67.13 121.49,67.25 121.67,67.25 121.79,67.36 121.79,67.59 121.67,67.7 121.49,67.7 121.37,67.82 121.37,68.05 121.49,68.16 121.67,68.16 121.79,68.27 121.79,68.5 121.67,68.62 121.49,68.62 121.37,68.73 121.37,68.96 121.49,69.07 121.67,69.07 121.79,69.19 121.79,69.42 121.67,69.53 121.49,69.53 121.37,69.65 121.37,69.88 121.49,69.99 121.67,69.99 121.79,70.1 121.79,70.33 121.67,70.45 121.49,70.45 121.37,70.56 121.37,70.79 121.49,70.9 121.67,70.9 121.79,71.02 121.79,71.25 121.67,71.36 121.49,71.36 121.37,71.48 121.37,71.7 121.49,71.82 121.67,71.82 121.79,71.93 121.79,72.16 121.67,72.28 121.49,72.28 121.37,72.39 121.37,72.62 121.49,72.73 121.67,72.73 121.79,72.85 121.79,73.08 121.67,73.19 121.49,73.19 121.37,73.3 121.37,73.53 121.49,73.65 121.67,73.65 121.79,73.76 121.79,73.99 121.67,74.1 121.49,74.1 121.37,74.22 121.37,77.35 121.72,77.69 v2(121.72,81.6)
MEM_DQB13: length 67.9
  TOP w0.109: v2(107.57,52.12) CON1.190
  ART07 w0.114: v2(107.57,52.12) 107.57,52.49 107.68,52.61 115.95,52.61 116.35,53.01 116.35,58.35 116,58.69 115.63,58.69 115.05,59.27 115.05,59.99 114.48,60.57 113.88,60.57 113.58,60.26 113.58,59.99 113.19,59.61 107.4,59.61 107.29,59.72 107.29,61.59 107.07,61.81 107.07,63.97 107.31,64.21 107.94,64.21 108.06,64.1 108.06,63.48 108.17,63.37 108.4,63.37 108.52,63.48 108.52,64.1 108.63,64.21 108.86,64.21 108.97,64.1 108.97,63.86 109.09,63.75 109.32,63.75 109.43,63.86 109.43,64.1 109.54,64.21 109.86,64.21 109.97,64.1 109.97,64.03 110.09,63.92 110.32,63.92 110.43,64.03 110.43,64.1 110.55,64.21 110.77,64.21 110.89,64.1 110.89,64.03 111,63.92 111.23,63.92 111.35,64.03 111.35,64.1 111.46,64.21 111.91,64.21 112.1,64.02 112.1,63.84 112.21,63.73 112.44,63.73 112.55,63.84 112.55,64.1 112.67,64.21 113.7,64.21 114.56,63.35 118,63.35 118.6,63.95 120.46,63.95 121.06,64.54 121.06,77.48 121.28,77.71 121.28,82.17 v2(121.72,82.6)
MEM_DQB14: length 71
  TOP w0.109: v2(104.32,62.68) CON1.203
  ART07 w0.114: v2(118.26,82.6) 118.67,82.19 118.67,78.78 118.17,78.28 118.17,78.01 118.05,77.89 116.97,77.89 116.86,77.78 116.86,77.55 116.97,77.44 118.05,77.44 118.17,77.32 118.17,77.09 118.05,76.98 116.97,76.98 116.86,76.87 116.86,76.64 116.97,76.52 118.05,76.52 118.17,76.41 118.17,76.18 118.05,76.07 116.97,76.07 116.86,75.95 116.86,75.72 116.97,75.61 118.05,75.61 118.17,75.49 118.17,75.27 118.05,75.15 116.97,75.15 116.86,75.04 116.86,74.81 116.97,74.69 118.05,74.69 118.17,74.58 118.17,74.35 118.05,74.24 116.97,74.24 116.86,74.12 116.86,73.89 116.97,73.78 118.05,73.78 118.17,73.66 118.17,73.44 118.05,73.32 116.97,73.32 116.86,73.21 116.86,72.98 116.97,72.86 118.05,72.86 118.17,72.75 118.17,72.52 118.05,72.41 116.97,72.41 116.86,72.29 116.86,72.06 116.97,71.95 118.05,71.95 118.17,71.84 118.17,71.59 118.05,71.48 117.6,71.48 117.49,71.37 117.49,71.14 117.6,71.02 118.05,71.02 118.17,70.91 118.17,70.64 118.19,70.61 118.19,70.01 118.08,69.9 117.82,69.9 117.71,69.78 117.71,69.5 117.6,69.38 117.37,69.38 117.25,69.5 117.25,70.82 117.14,70.94 116.91,70.94 116.8,70.82 116.8,69.47 116.68,69.36 116.45,69.36 116.34,69.47 116.34,70.82 116.22,70.94 116,70.94 115.88,70.82 115.88,69.48 115.77,69.36 115.54,69.36 115.42,69.48 115.42,70.82 115.31,70.94 115.08,70.94 114.97,70.82 114.97,70.14 114.85,70.02 114.62,70.02 114.51,70.14 114.51,70.82 114.16,71.17 110.12,71.17 109.69,70.74 109.53,70.74 109.11,71.16 108.95,71.16 108.79,71 108.79,70.83 109.2,70.42 109.2,70.26 109.04,70.09 108.88,70.09 108.46,70.51 108.3,70.51 108.14,70.35 108.14,70.19 108.56,69.77 108.56,69.61 108.4,69.45 108.23,69.45 107.82,69.86 107.66,69.86 107.49,69.7 107.49,69.54 107.91,69.13 107.91,68.96 107.75,68.8 107.59,68.8 107.17,69.22 107.01,69.22 106.85,69.06 106.85,68.89 107.26,68.48 107.26,68.32 107.1,68.16 106.94,68.16 106.52,68.57 106.36,68.57 106.2,68.41 106.2,68.25 106.62,67.83 106.62,67.67 106.46,67.51 106.29,67.51 105.88,67.92 105.72,67.92 105.55,67.76 105.55,67.6 105.97,67.19 105.97,67.02 105.81,66.86 105.65,66.86 105.23,67.28 105.07,67.28 104.91,67.12 104.91,66.95 105.32,66.54 105.32,66.38 105.16,66.22 105,66.22 104.58,66.63 104.42,66.63 104.26,66.47 104.26,66.31 104.68,65.89 104.68,65.73 104.16,65.21 104.16,63.85 104.23,63.78 104.23,62.77 v2(104.32,62.68)
MEM_DQB15: length 70.3
  TOP w0.109: v2(104.07,52.12) CON1.204
  ART07 w0.114: v2(104.07,52.12) 104.73,52.78 104.73,54.01 105.8,55.09 111.89,55.09 112,55.2 112,55.79 112.12,55.9 112.66,55.9 112.78,56.02 112.78,56.25 112.66,56.36 112.12,56.36 112,56.47 112,57.89 111.82,58.07 111.35,58.07 111.23,57.96 111.23,57.02 111.12,56.91 110.89,56.91 110.77,57.02 110.77,57.96 110.66,58.07 110.43,58.07 110.32,57.96 110.32,57.02 110.2,56.91 109.97,56.91 109.86,57.02 109.86,57.96 109.75,58.07 109.52,58.07 109.4,57.96 109.4,57.02 109.29,56.91 109.06,56.91 108.95,57.02 108.95,57.96 108.83,58.07 108.6,58.07 108.49,57.96 108.49,57.02 108.37,56.91 108.15,56.91 108.03,57.02 108.03,57.96 107.92,58.07 107.69,58.07 107.57,57.96 107.57,57.02 107.46,56.91 107.23,56.91 107.12,57.02 107.12,57.96 107,58.07 106.77,58.07 106.66,57.96 106.66,57.02 106.55,56.91 106.32,56.91 106.2,57.02 106.2,57.96 106.09,58.07 105.8,58.07 104.21,59.66 103.72,59.66 103.35,60.03 103.35,61.2 103.07,61.48 103.07,64.36 103.18,64.48 103.34,64.48 103.46,64.59 103.46,64.82 103.34,64.94 103.18,64.94 103.07,65.05 103.07,65.28 103.18,65.39 103.34,65.39 103.46,65.51 103.46,65.74 103.34,65.85 103.18,65.85 103.07,65.96 103.07,66.3 108.62,71.84 109.5,71.84 109.61,71.96 109.61,74.48 109.85,74.73 115.45,74.73 115.57,74.84 115.57,77.48 117.86,79.77 117.86,81.63 v2(117.39,82.1)
MEM_DQB16: length 74.9
  TOP w0.109: v2(101.07,52.12) CON1.216
  ART07 w0.114: v2(114.79,83.6) 115.06,83.44 115.09,83.33 arc(115.05,83.06) 115.13,82.8 arc(115.18,82.6) 115.13,82.4 arc(115.05,82.1) 115.13,81.8 115.13,81.8 arc(115.18,81.6) 115.13,81.4 arc(115.07,81.25) 115.05,81.09 115.05,80.76 113.93,79.64 107.01,79.64 106.78,79.41 106.78,79.07 107.56,78.29 107.56,77.38 107.51,77.27 107.28,77.04 107.08,77.13 106.92,77.08 106.83,76.87 106.89,76.72 107.08,76.63 107.14,76.47 106.85,75.85 106.03,75.03 105.87,75.03 105.34,75.56 105.18,75.56 105.02,75.4 105.02,75.24 105.55,74.71 105.55,74.54 105.25,74.25 104.73,73.73 101.04,70.04 101.04,63.22 100.89,63.07 100.89,62.4 100.3,61.81 100.3,61.57 100.19,61.46 99.5,61.46 99.39,61.34 99.39,61.11 99.5,61 100.19,61 100.41,60.78 100.41,60.15 100.74,59.82 100.74,55.31 100.16,54.73 100.16,54.39 101.62,52.93 101.62,50.48 101.75,50.35 105.8,50.35 105.92,50.24 105.92,48.97 105.8,48.86 105.18,48.86 105.07,48.97 105.07,49.9 104.96,50.01 104.73,50.01 104.61,49.9 104.61,48.97 104.5,48.86 104.27,48.86 104.16,48.97 104.16,49.9 104.04,50.01 103.81,50.01 103.7,49.9 103.7,48.97 103.58,48.86 103.36,48.86 103.24,48.97 103.24,49.9 103.13,50.01 102.9,50.01 102.78,49.9 102.78,48.97 102.67,48.86 102.44,48.86 102.33,48.97 102.33,49.9 102.21,50.01 101.98,50.01 101.87,49.9 101.87,48.97 101.75,48.86 101.53,48.86 101.41,48.97 101.41,49.9 101.3,50.01 101.07,50.01 100.95,49.9 100.95,48.97 100.84,48.86 100.6,48.86 100.48,48.97 100.48,51.59 101.02,52.12 v2(101.07,52.12)
MEM_DQB17: length 75.4
  TOP w0.109: v2(101.32,62.68) CON1.215
  ART07 w0.114: v2(112.19,85.1) 112.61,85.1 112.71,85.2 113.93,85.2 114.3,84.84 114.3,84.45 114.68,84.07 114.87,84.07 115.16,83.78 115.18,83.76 115.19,83.74 115.19,83.63 115.29,83.53 115.29,83.23 arc(115.27,83.06) 115.32,82.9 115.32,82.9 arc(115.4,82.6) 115.32,82.3 arc(115.26,82.1) 115.32,81.9 arc(115.4,81.6) 115.32,81.3 arc(115.26,81.1) 115.32,80.9 115.32,80.19 115.2,80.07 114.82,80.07 114.74,79.99 114.74,79.74 114.85,79.63 115.26,79.63 115.38,79.51 115.38,79.29 115.01,78.93 114.83,78.93 114.73,79.02 114.73,79.13 114.58,79.29 114.42,79.29 114.27,79.14 114.27,78.19 113.92,77.83 113.92,76.62 113.5,76.21 113.16,76.21 113.04,76.32 113.04,77.04 113.16,77.15 113.56,77.15 113.68,77.26 113.68,77.49 113.56,77.61 113.16,77.61 113.04,77.72 113.04,78.14 113.16,78.26 113.76,78.26 113.88,78.37 113.88,78.6 113.76,78.72 113.16,78.72 113.04,78.83 113.04,79.12 112.93,79.24 112.7,79.24 112.59,79.12 112.59,76.32 112.47,76.21 112.24,76.21 112.13,76.32 112.13,79.12 112.01,79.24 111.79,79.24 111.67,79.12 111.67,76.32 111.56,76.21 111.33,76.21 111.21,76.32 111.21,79.15 111.1,79.26 110.87,79.26 110.76,79.15 110.76,76.32 110.64,76.21 110.41,76.21 110.3,76.32 110.3,79.13 110.19,79.25 109.96,79.25 109.84,79.13 109.84,76.32 109.73,76.21 109.5,76.21 109.39,76.32 109.39,79.07 109.27,79.19 109.04,79.19 108.93,79.07 108.93,76.32 108.81,76.21 108.59,76.21 108.47,76.32 108.47,79.21 108.36,79.32 107.66,79.32 107.55,79.21 107.55,78.84 108.01,78.37 108.01,76.32 107.9,76.21 107.66,76.21 101.46,70.01 101.46,69.9 101.45,69.89 101.45,62.81 v2(101.32,62.68)
MEM_DQB18: length 75
  TOP w0.109: v2(98.07,52.12) CON1.228
  ART07 w0.114: v2(98.07,52.12) 96.99,53.2 96.99,55.04 96.88,55.15 94.67,55.15 94.56,55.27 94.56,55.5 94.67,55.61 96.88,55.61 96.99,55.73 96.99,55.95 96.88,56.07 94.67,56.07 94.56,56.18 94.56,56.41 94.67,56.53 96.88,56.53 96.99,56.64 96.99,56.87 96.88,56.98 94.67,56.98 94.56,57.1 94.56,57.33 94.67,57.44 96.88,57.44 96.99,57.55 96.99,57.78 96.88,57.9 94.67,57.9 94.56,58.01 94.56,58.24 94.67,58.35 96.88,58.35 96.99,58.47 96.99,58.7 96.88,58.81 94.67,58.81 94.56,58.93 94.56,59.15 94.67,59.27 96.88,59.27 96.99,59.38 96.99,59.69 96.88,59.81 93.25,59.81 92.91,60.15 92.91,60.33 92.28,60.96 92.28,63.17 93.68,64.57 93.68,70.61 96.38,73.31 96.38,74.18 102.95,80.75 102.95,83.21 103.94,84.19 104.69,84.19 105.16,84.66 105.38,84.66 105.71,84.99 105.71,85.76 106.05,86.09 109.74,86.09 110.32,85.51 110.78,85.51 111.33,84.96 v2(111.33,84.6)
MEM_DQB19: length 74.3
  TOP w0.109: v2(97.82,62.74) CON1.229
  ART07 w0.114: v2(115.66,84.1) 115.66,84.42 115.23,84.85 115.22,84.85 arc(115.04,85.03) 114.79,85.1 arc(114.54,85.17) 114.36,85.35 114.36,85.35 arc(114.18,85.53) 113.93,85.6 113.92,85.6 arc(113.68,85.67) 113.49,85.85 113.49,85.85 arc(113.34,86) 113.14,86.06 112.98,86.06 arc(112.78,86) 112.63,85.85 112.62,85.85 arc(112.44,85.67) 112.19,85.6 arc(111.94,85.53) 111.76,85.35 111.76,85.35 arc(111.69,85.1) 111.76,84.85 arc(111.83,84.6) 111.76,84.35 111.76,84.35 arc(111.57,84.17) 111.33,84.1 111.11,84.1 110.63,84.58 110.08,84.58 109.96,84.46 109.96,83.93 109.85,83.81 109.62,83.81 109.51,83.93 109.51,84.84 109.39,84.96 109.16,84.96 109.05,84.84 109.05,83.93 108.94,83.81 108.71,83.81 108.59,83.93 108.59,84.84 108.48,84.96 108.25,84.96 108.14,84.84 108.14,83.93 108.02,83.81 107.79,83.81 107.68,83.93 107.68,84.84 107.56,84.96 107.34,84.96 107.22,84.84 107.22,83.93 107.11,83.81 106.88,83.81 106.76,83.93 106.76,84.84 106.65,84.96 106.41,84.96 106.19,84.74 106.19,84.12 106.08,84 105.8,84 105.68,83.89 105.68,83.66 105.8,83.54 106.08,83.54 106.19,83.43 106.19,82.75 105.67,82.23 105.51,82.23 105.29,82.46 105.13,82.46 104.96,82.3 104.96,82.13 105.19,81.91 105.19,81.75 103.41,79.97 103.25,79.97 103.02,80.21 102.86,80.21 102.7,80.04 102.7,79.88 102.93,79.65 102.93,79.49 102.77,79.33 102.6,79.33 102.37,79.56 102.21,79.56 102.05,79.4 102.05,79.24 102.28,79 102.28,78.84 102.12,78.68 101.96,78.68 101.73,78.91 101.56,78.91 101.4,78.75 101.4,78.59 101.63,78.36 101.63,78.19 101.47,78.03 101.31,78.03 101.08,78.27 100.92,78.27 100.76,78.1 100.76,77.94 100.99,77.71 100.99,77.55 100.79,77.35 100.79,76.98 100.62,76.81 100.46,76.81 100.05,77.23 99.89,77.23 99.72,77.06 99.72,76.9 100.14,76.49 100.14,76.33 97.33,73.53 97.17,73.53 94.21,70.56 94.21,70.51 94.02,70.33 94.02,64.1 94.21,63.91 94.21,62.46 94.07,62.32 93.04,62.32 92.82,62.1 92.82,60.88 92.94,60.76 93.18,60.76 93.29,60.87 93.29,61.91 93.41,62.02 93.63,62.02 93.75,61.91 93.75,60.87 93.86,60.76 94.09,60.76 94.21,60.87 94.21,61.91 94.32,62.02 94.55,62.02 94.66,61.91 94.66,60.87 94.78,60.76 95.01,60.76 95.12,60.87 95.12,62.13 95.23,62.24 95.46,62.24 95.58,62.13 95.58,60.87 95.69,60.76 95.92,60.76 96.03,60.87 96.03,62.16 96.15,62.28 96.38,62.28 96.49,62.16 96.49,60.87 96.61,60.76 97.01,60.76 97.11,60.85 97.11,62.1 97.22,62.21 97.48,62.21 97.82,62.56 v2(97.82,62.74)
MEM_DQB20: length 74.4
  TOP w0.109: v2(102.32,62.68) CON1.211
  ART07 w0.114: v2(115.66,85.1) 116.1,84.65 116.1,84.4 116.48,84.02 116.76,84.02 116.93,83.86 116.93,81.06 116.81,80.95 116.48,80.95 116.37,80.83 116.37,80.6 116.48,80.49 116.85,80.49 116.97,80.37 116.97,79.96 116.8,79.79 116.63,79.79 116.51,79.91 116.35,79.91 116.18,79.75 116.18,79.59 116.31,79.46 116.31,79.3 114.67,77.65 114.67,76.38 114.48,76.19 114.48,76.03 114.67,75.83 114.67,75.67 114.51,75.51 114.35,75.51 114.15,75.7 113.99,75.7 113.86,75.57 109.6,75.57 108.84,74.82 108.84,74.23 108.73,74.12 108.4,74.12 108.29,74 108.29,73.78 108.4,73.66 108.73,73.66 108.84,73.55 108.84,73.14 108.59,72.88 108.43,72.88 107.57,73.74 107.57,73.9 108.34,74.67 108.34,74.84 108.18,75 108.02,75 107.25,74.23 107.09,74.23 106.92,74.4 106.76,74.4 106.59,74.24 106.59,74.07 108.11,72.56 108.11,72.4 107.95,72.24 107.78,72.24 106.27,73.75 106.11,73.75 105.95,73.59 105.95,73.43 107.46,71.91 107.46,71.75 107.3,71.59 107.14,71.59 105.62,73.1 105.46,73.1 105.3,72.94 105.3,72.78 106.81,71.27 106.81,71.11 106.65,70.94 106.49,70.94 104.98,72.46 104.82,72.46 104.65,72.3 104.65,72.13 106.17,70.62 106.17,70.46 106.01,70.3 105.84,70.3 104.33,71.81 104.17,71.81 104.01,71.65 104.01,71.49 105.52,69.97 105.52,69.81 105.36,69.65 105.2,69.65 103.68,71.16 103.52,71.16 103.36,71 103.36,70.84 104.87,69.33 104.87,69.17 104.71,69 104.55,69 103.04,70.52 102.88,70.52 102.71,70.36 102.71,70.19 103.56,69.35 103.56,69.19 103.23,68.85 103.07,68.85 102.79,69.13 102.63,69.13 102.47,68.97 102.47,68.81 102.75,68.53 102.75,68.37 102.25,67.88 102.25,67.72 102.42,67.55 102.58,67.55 103.89,68.86 104.05,68.86 104.23,68.68 104.23,68.52 102.32,66.61 v2(102.32,62.68)
