# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
16-LEAD_PLASTIC_DFN
  oval 0.254x0.813 smd: 1(-1.75,-1.5) 2(-1.25,-1.5) 3(-0.75,-1.5) 4(-0.25,-1.5) 5(0.25,-1.5) 6(0.75,-1.5) 7(1.25,-1.5) 8(1.75,-1.5) 9(1.75,1.5) 10(1.25,1.5) 11(0.75,1.5) 12(0.25,1.5) 13(-0.25,1.5) 14(-0.75,1.5) 15(-1.25,1.5) 16(-1.75,1.5)
  custom 0.412x0.412 smd: 17(0,0)
24TQFN-EP
  rect 0.3x0.8 smd: 1(-1.25,-1.955) 2(-0.75,-1.955) 3(-0.25,-1.955) 4(0.25,-1.955) 5(0.75,-1.955) 6(1.25,-1.955) 13(1.25,1.955) 14(0.75,1.955) 15(0.25,1.955) 16(-0.25,1.955) 17(-0.75,1.955) 18(-1.25,1.955)
  rect 0.8x0.3 smd: 7(1.955,-1.25) 8(1.955,-0.75) 9(1.955,-0.25) 10(1.955,0.25) 11(1.955,0.75) 12(1.955,1.25) 19(-1.955,1.25) 20(-1.955,0.75) 21(-1.955,0.25) 22(-1.955,-0.25) 23(-1.955,-0.75) 24(-1.955,-1.25)
  rect 2.6x2.6 smd: 25(0,0)
0201
  rect 0.45x0.4 smd: 1(-0.35,0) 2(0.35,0)
0402
  rect 0.508x0.508 smd: 1(0,0.445) 2(0,-0.445)
0603
  rect 1.016x1.016 smd: 1(-0.762,0) 2(0.762,0)
0805
  rect 1.6x1.321 smd: 1(0,0.95) 2(0,-0.95)
805
  rect 1.6x1.321 smd: 1(0,0.95) 2(0,-0.95)
1206
  rect 1.27x1.778 smd: 1(-1.524,0) 2(1.524,0)
1210
  rect 1.27x2.794 smd: 1(-1.524,0) 2(1.524,0)
1411
  rect 1.524x2.464 smd: 1(-1.612,0) 2(1.612,0)
2012
  rect 1.27x1.27 smd: 1(1.016,0) 2(-1.016,0)
2917
  rect 2.311x2.489 smd: 1(3.2,0) 2(-3.2,0)
7343-V_LOW-PROFILE
  rect 3.353x2.438 smd: 1(-2.6,0) 2(2.6,0)
7343P
  rect 2.54x3.556 smd: 1(-3.3,0) 2(3.3,0)
170432-0002
  round 1.549 hole 1.549 unplated: (-8.4,-3.325) (8.4,-3.325)
  oval 0.356x1.803 smd: 1(-7,4.045) 2(-6.2,4.045) 3(-5.4,4.045) 4(-4.6,4.045) 5(-3.8,4.045) 6(-3,4.045) 7(-2.2,4.045) 8(-1.4,4.045) 9(-0.6,4.045) 10(0.2,4.045) 11(1,4.045) 12(1.8,4.045) 13(2.6,4.045) 14(3.4,4.045) 15(4.2,4.045) 16(5,4.045) 17(5.8,4.045) 18(6.6,4.045) 19(7.4,4.045) 20(7,6.555) 21(6.2,6.555) 22(5.4,6.555) 23(4.6,6.555) 24(3.8,6.555) 25(3,6.555) 26(2.2,6.555) 27(1.4,6.555) 28(0.6,6.555) 29(-0.2,6.555) 30(-1,6.555) 31(-1.8,6.555) 32(-2.6,6.555) 33(-3.4,6.555) 34(-4.2,6.555) 35(-5,6.555) 36(-5.8,6.555) 37(-6.6,6.555) 38(-7.4,6.555)
202718
  round 1.549 hole 1.549 unplated: (-8.4,-11.5) (8.4,-11.5)
  oval 0.356x1.6 smd: 1(-7,0) 2(-6.2,0) 3(-5.4,0) 4(-4.6,0) 5(-3.8,0) 6(-3,0) 7(-2.2,0) 8(-1.4,0) 9(-0.6,0) 10(0.2,0) 11(1,0) 12(1.8,0) 13(2.6,0) 14(3.4,0) 15(4.2,0) 16(5,0) 17(5.8,0) 18(6.6,0) 19(7.4,0) 20(7,8.79) 21(6.2,8.79) 22(5.4,8.79) 23(4.6,8.79) 24(3.8,8.79) 25(3,8.79) 26(2.2,8.79) 27(1.4,8.79) 28(0.6,8.79) 29(-0.2,8.79) 30(-1,8.79) 31(-1.8,8.79) 32(-2.6,8.79) 33(-3.4,8.79) 34(-4.2,8.79) 35(-5,8.79) 36(-5.8,8.79) 37(-6.6,8.79) 38(-7.4,8.79) 39(-7,2.93) 40(-6.2,2.93) 41(-5.4,2.93) 42(-4.6,2.93) 43(-3.8,2.93) 44(-3,2.93) 45(-2.2,2.93) 46(-1.4,2.93) 47(-0.6,2.93) 48(0.2,2.93) 49(1,2.93) 50(1.8,2.93) 51(2.6,2.93) 52(3.4,2.93) 53(4.2,2.93) 54(5,2.93) 55(5.8,2.93) 56(6.6,2.93) 57(7.4,2.93) 58(7,5.86) 59(6.2,5.86) 60(5.4,5.86) 61(4.6,5.86) 62(3.8,5.86) 63(3,5.86) 64(2.2,5.86) 65(1.4,5.86) 66(0.6,5.86) 67(-0.2,5.86) 68(-1,5.86) 69(-1.8,5.86) 70(-2.6,5.86) 71(-3.4,5.86) 72(-4.2,5.86) 73(-5,5.86) 74(-5.8,5.86) 75(-6.6,5.86) 76(-7.4,5.86)
  round 1.803 hole 1.041: 77(-5,11.6) 78(2.2,11.6)
  rect 2.007x3.988 hole 1.041: 79(9.5,-3.9) 80(9.5,-14.6) 81(9.5,-23.6) 82(9.5,-32.6) 83(9.5,-41.6) 84(-9.5,-46.1) 85(-9.5,-37.1) 86(-9.5,-28.1) 87(-9.5,-19.1) 88(-9.5,-8.4)
10146065-113A0LF
  rect 2.997x5.004 smd: (-44.5,0)
  round 1.194 hole 1.194 unplated: (-29.85,0) (43.3,0)
  custom 0.75x0.75 smd: (44.5,0)
  rect 0.711x2.007 smd: A1(-41.5,3.6) A2(-40.5,3.6) A3(-39.5,3.6) A4(-38.5,3.6) A5(-37.5,3.6) A6(-36.5,3.6) A7(-35.5,3.6) A8(-34.5,3.6) A9(-33.5,3.6) A10(-32.5,3.6) A11(-31.5,3.6) A12(-28.5,3.6) A13(-27.5,3.6) A14(-26.5,3.6) A15(-25.5,3.6) A16(-24.5,3.6) A17(-23.5,3.6) A18(-22.5,3.6) A19(-21.5,3.6) A20(-20.5,3.6) A21(-19.5,3.6) A22(-18.5,3.6) A23(-17.5,3.6) A24(-16.5,3.6) A25(-15.5,3.6) A26(-14.5,3.6) A27(-13.5,3.6) A28(-12.5,3.6) A29(-11.5,3.6) A30(-10.5,3.6) A31(-9.5,3.6) A32(-8.5,3.6) A33(-7.5,3.6) A34(-6.5,3.6) A35(-5.5,3.6) A36(-4.5,3.6) A37(-3.5,3.6) A38(-2.5,3.6) A39(-1.5,3.6) A40(-0.5,3.6) A41(0.5,3.6) A42(1.5,3.6) A43(2.5,3.6) A44(3.5,3.6) A45(4.5,3.6) A46(5.5,3.6) A47(6.5,3.6) A48(7.5,3.6) A49(8.5,3.6) A50(9.5,3.6) A51(10.5,3.6) A52(11.5,3.6) A53(12.5,3.6) A54(13.5,3.6) A55(14.5,3.6) A56(15.5,3.6) A57(16.5,3.6) A58(17.5,3.6) A59(18.5,3.6) A60(19.5,3.6) A61(20.5,3.6) A62(21.5,3.6) A63(22.5,3.6) A64(23.5,3.6) A65(24.5,3.6) A66(25.5,3.6) A67(26.5,3.6) A68(27.5,3.6) A69(28.5,3.6) A70(29.5,3.6) A71(30.5,3.6) A72(31.5,3.6) A73(32.5,3.6) A74(33.5,3.6) A75(34.5,3.6) A76(35.5,3.6) A77(36.5,3.6) A78(37.5,3.6) A79(38.5,3.6) A80(39.5,3.6) A81(40.5,3.6) A82(41.5,3.6) B1(-41.5,-3.6) B2(-40.5,-3.6) B3(-39.5,-3.6) B4(-38.5,-3.6) B5(-37.5,-3.6) B6(-36.5,-3.6) B7(-35.5,-3.6) B8(-34.5,-3.6) B9(-33.5,-3.6) B10(-32.5,-3.6) B11(-31.5,-3.6) B12(-28.5,-3.6) B13(-27.5,-3.6) B14(-26.5,-3.6) B15(-25.5,-3.6) B16(-24.5,-3.6) B17(-23.5,-3.6) B18(-22.5,-3.6) B19(-21.5,-3.6) B20(-20.5,-3.6) B21(-19.5,-3.6) B22(-18.5,-3.6) B23(-17.5,-3.6) B24(-16.5,-3.6) B25(-15.5,-3.6) B26(-14.5,-3.6) B27(-13.5,-3.6) B28(-12.5,-3.6) B29(-11.5,-3.6) B30(-10.5,-3.6) B31(-9.5,-3.6) B32(-8.5,-3.6) B33(-7.5,-3.6) B34(-6.5,-3.6) B35(-5.5,-3.6) B36(-4.5,-3.6) B37(-3.5,-3.6) B38(-2.5,-3.6) B39(-1.5,-3.6) B40(-0.5,-3.6) B41(0.5,-3.6) B42(1.5,-3.6) B43(2.5,-3.6) B44(3.5,-3.6) B45(4.5,-3.6) B46(5.5,-3.6) B47(6.5,-3.6) B48(7.5,-3.6) B49(8.5,-3.6) B50(9.5,-3.6) B51(10.5,-3.6) B52(11.5,-3.6) B53(12.5,-3.6) B54(13.5,-3.6) B55(14.5,-3.6) B56(15.5,-3.6) B57(16.5,-3.6) B58(17.5,-3.6) B59(18.5,-3.6) B60(19.5,-3.6) B61(20.5,-3.6) B62(21.5,-3.6) B63(22.5,-3.6) B64(23.5,-3.6) B65(24.5,-3.6) B66(25.5,-3.6) B67(26.5,-3.6) B68(27.5,-3.6) B69(28.5,-3.6) B70(29.5,-3.6) B71(30.5,-3.6) B72(31.5,-3.6) B73(32.5,-3.6) B74(33.5,-3.6) B75(34.5,-3.6) B76(35.5,-3.6) B77(36.5,-3.6) B78(37.5,-3.6) B79(38.5,-3.6) B80(39.5,-3.6) B81(40.5,-3.6) B82(41.5,-3.6)
BCC96
  rect 0.406x0.305 smd: 1(-4.1,3.6) 2(-3.5,3.3) 3(-4.1,3) 4(-3.5,2.7) 5(-4.1,2.4) 6(-3.5,2.1) 7(-4.1,1.8) 8(-3.5,1.5) 9(-4.1,1.2) 10(-3.5,0.9) 11(-4.1,0.6) 12(-3.5,0.3) 13(-4.1,0) 14(-3.5,-0.3) 15(-4.1,-0.6) 16(-3.5,-0.9) 17(-4.1,-1.2) 18(-3.5,-1.5) 19(-4.1,-1.8) 20(-3.5,-2.1) 21(-4.1,-2.4) 22(-3.5,-2.7) 23(-4.1,-3) 24(-4.1,-3.6) 50(4.1,-3.6) 51(4.1,-3) 52(3.5,-2.7) 53(4.1,-2.4) 54(3.5,-2.1) 55(4.1,-1.8) 56(3.5,-1.5) 57(4.1,-1.2) 58(3.5,-0.9) 59(4.1,-0.6) 60(3.5,-0.3) 61(4.1,0) 62(3.5,0.3) 63(4.1,0.6) 64(3.5,0.9) 65(4.1,1.2) 66(3.5,1.5) 67(4.1,1.8) 68(3.5,2.1) 69(4.1,2.4) 70(3.5,2.7) 71(4.1,3) 72(3.5,3.3) 73(4.1,3.6)
  rect 0.305x0.406 smd: 25(-3.6,-4.1) 26(-3.3,-3.5) 27(-3,-4.1) 28(-2.7,-3.5) 29(-2.4,-4.1) 30(-2.1,-3.5) 31(-1.8,-4.1) 32(-1.5,-3.5) 33(-1.2,-4.1) 34(-0.9,-3.5) 35(-0.6,-4.1) 36(-0.3,-3.5) 37(0,-4.1) 38(0.3,-3.5) 39(0.6,-4.1) 40(0.9,-3.5) 41(1.2,-4.1) 42(1.5,-3.5) 43(1.8,-4.1) 44(2.1,-3.5) 45(2.4,-4.1) 46(2.7,-3.5) 47(3,-4.1) 48(3.3,-3.5) 49(3.6,-4.1) 74(3.6,4.1) 75(3,4.1) 76(2.7,3.5) 77(2.4,4.1) 78(2.1,3.5) 79(1.8,4.1) 80(1.5,3.5) 81(1.2,4.1) 82(0.9,3.5) 83(0.6,4.1) 84(0.3,3.5) 85(0,4.1) 86(-0.3,3.5) 87(-0.6,4.1) 88(-0.9,3.5) 89(-1.2,4.1) 90(-1.5,3.5) 91(-1.8,4.1) 92(-2.1,3.5) 93(-2.4,4.1) 94(-2.7,3.5) 95(-3,4.1) 96(-3.6,4.1)
  rect 4.801x5.004 smd: 97(0,0)
BGA68_15X9_ADI
  rect 0.63x0.63 smd: A1(-3.81,6.35) A2(-3.81,5.08) A3(-3.81,3.81) A4(-3.81,2.54) A5(-3.81,1.27) A6(-3.81,0) A7(-3.81,-1.27) A8(-3.81,-2.54) A9(-3.81,-3.81) A10(-3.81,-5.08) A11(-3.81,-6.35) B1(-2.54,6.35) B3(-2.54,3.81) B4(-2.54,2.54) B5(-2.54,1.27) B7(-2.54,-1.27) B8(-2.54,-2.54) B9(-2.54,-3.81) B10(-2.54,-5.08) B11(-2.54,-6.35) C1(-1.27,6.35) C3(-1.27,3.81) C4(-1.27,2.54) C5(-1.27,1.27) C7(-1.27,-1.27) C8(-1.27,-2.54) C9(-1.27,-3.81) C10(-1.27,-5.08) C11(-1.27,-6.35) D1(0,6.35) D3(0,3.81) D4(0,2.54) D5(0,1.27) D7(0,-1.27) D8(0,-2.54) D9(0,-3.81) D10(0,-5.08) D11(0,-6.35) E1(1.27,6.35) E3(1.27,3.81) E5(1.27,1.27) E7(1.27,-1.27) E8(1.27,-2.54) E9(1.27,-3.81) E10(1.27,-5.08) E11(1.27,-6.35) F1(2.54,6.35) F2(2.54,5.08) F3(2.54,3.81) F4(2.54,2.54) F5(2.54,1.27) F6(2.54,0) F7(2.54,-1.27) F8(2.54,-2.54) F9(2.54,-3.81) F10(2.54,-5.08) F11(2.54,-6.35) G1(3.81,6.35) G2(3.81,5.08) G3(3.81,3.81) G4(3.81,2.54) G5(3.81,1.27) G6(3.81,0) G7(3.81,-1.27) G8(3.81,-2.54) G9(3.81,-3.81) G10(3.81,-5.08) G11(3.81,-6.35)
BGA144_REVC_ADI
  round 0.6 smd: A1(-6.985,6.985) A2(-5.715,6.985) A3(-4.445,6.985) A4(-3.175,6.985) A5(-1.905,6.985) A6(-0.635,6.985) A7(0.635,6.985) A8(1.905,6.985) A9(3.175,6.985) A10(4.445,6.985) A11(5.715,6.985) A12(6.985,6.985) B1(-6.985,5.715) B2(-5.715,5.715) B3(-4.445,5.715) B4(-3.175,5.715) B5(-1.905,5.715) B6(-0.635,5.715) B7(0.635,5.715) B8(1.905,5.715) B9(3.175,5.715) B10(4.445,5.715) B11(5.715,5.715) B12(6.985,5.715) C1(-6.985,4.445) C2(-5.715,4.445) C3(-4.445,4.445) C4(-3.175,4.445) C5(-1.905,4.445) C6(-0.635,4.445) C7(0.635,4.445) C8(1.905,4.445) C9(3.175,4.445) C10(4.445,4.445) C11(5.715,4.445) C12(6.985,4.445) D1(-6.985,3.175) D2(-5.715,3.175) D3(-4.445,3.175) D4(-3.175,3.175) D5(-1.905,3.175) D6(-0.635,3.175) D7(0.635,3.175) D8(1.905,3.175) D9(3.175,3.175) D10(4.445,3.175) D11(5.715,3.175) D12(6.985,3.175) E1(-6.985,1.905) E2(-5.715,1.905) E3(-4.445,1.905) E4(-3.175,1.905) E5(-1.905,1.905) E6(-0.635,1.905) E7(0.635,1.905) E8(1.905,1.905) E9(3.175,1.905) E10(4.445,1.905) E11(5.715,1.905) E12(6.985,1.905) F1(-6.985,0.635) F2(-5.715,0.635) F3(-4.445,0.635) F4(-3.175,0.635) F5(-1.905,0.635) F6(-0.635,0.635) F7(0.635,0.635) F8(1.905,0.635) F9(3.175,0.635) F10(4.445,0.635) F11(5.715,0.635) F12(6.985,0.635) G1(-6.985,-0.635) G2(-5.715,-0.635) G3(-4.445,-0.635) G4(-3.175,-0.635) G5(-1.905,-0.635) G6(-0.635,-0.635) G7(0.635,-0.635) G8(1.905,-0.635) G9(3.175,-0.635) G10(4.445,-0.635) G11(5.715,-0.635) G12(6.985,-0.635) H1(-6.985,-1.905) H2(-5.715,-1.905) H3(-4.445,-1.905) H4(-3.175,-1.905) H5(-1.905,-1.905) H6(-0.635,-1.905) H7(0.635,-1.905) H8(1.905,-1.905) H9(3.175,-1.905) H10(4.445,-1.905) H11(5.715,-1.905) H12(6.985,-1.905) J1(-6.985,-3.175) J2(-5.715,-3.175) J3(-4.445,-3.175) J4(-3.175,-3.175) J5(-1.905,-3.175) J6(-0.635,-3.175) J7(0.635,-3.175) J8(1.905,-3.175) J9(3.175,-3.175) J10(4.445,-3.175) J11(5.715,-3.175) J12(6.985,-3.175) K1(-6.985,-4.445) K2(-5.715,-4.445) K3(-4.445,-4.445) K4(-3.175,-4.445) K5(-1.905,-4.445) K6(-0.635,-4.445) K7(0.635,-4.445) K8(1.905,-4.445) K9(3.175,-4.445) K10(4.445,-4.445) K11(5.715,-4.445) K12(6.985,-4.445) L1(-6.985,-5.715) L2(-5.715,-5.715) L3(-4.445,-5.715) L4(-3.175,-5.715) L5(-1.905,-5.715) L6(-0.635,-5.715) L7(0.635,-5.715) L8(1.905,-5.715) L9(3.175,-5.715) L10(4.445,-5.715) L11(5.715,-5.715) L12(6.985,-5.715) M1(-6.985,-6.985) M2(-5.715,-6.985) M3(-4.445,-6.985) M4(-3.175,-6.985) M5(-1.905,-6.985) M6(-0.635,-6.985) M7(0.635,-6.985) M8(1.905,-6.985) M9(3.175,-6.985) M10(4.445,-6.985) M11(5.715,-6.985) M12(6.985,-6.985)
BT1
  rect 3.18x3.18 smd: (7.3,0) 1(-7.3,0)
  rect 3.96x3.96 smd: 2(0,0)
C0805
  rect 1.6x1.321 smd: 1(0,0.95) 2(0,-0.95)
CONN_39_26_7108
  rect 1.778x1.778 hole 1.092: 1(0,0)
  round 1.778 hole 1.092: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54)
DFN6_EPAD
  rect 0.25x0.7 smd: 1(-0.5,-1.425) 2(0,-1.425) 3(0.5,-1.425) 4(0.5,1.425) 5(0,1.425) 6(-0.5,1.425)
  rect 1.321x1.6 smd: 7(0,0)
DFN8-EPAD_3X2
  rect 0.305x0.787 smd: 1(-0.75,-0.925) 2(-0.25,-0.925) 3(0.25,-0.925) 4(0.75,-0.925) 5(0.75,0.925) 6(0.25,0.925) 7(-0.25,0.925) 8(-0.75,0.925)
  rect 2.21x0.61 smd: 9(0,0)
DFN10_3X3_ONS
  rect 0.762x0.254 smd: 1(-1.422,1) 2(-1.422,0.5) 3(-1.422,0) 4(-1.422,-0.5) 5(-1.422,-1) 6(1.422,-1) 7(1.422,-0.5) 8(1.422,0) 9(1.422,0.5) 10(1.422,1)
  rect 1.803x2.489 smd: 11(0,0)
DIPSWITCH_SMT_2POS
  rect 1.27x0.76 smd: 1(-3.81,0.635) 2(-3.81,-0.635) 3(3.81,-0.635) 4(3.81,0.635)
DIPSWITCH_SMT_OCTAL
  rect 0.762x1.27 smd: 1(-4.445,-3.81) 2(-3.175,-3.81) 3(-1.905,-3.81) 4(-0.635,-3.81) 5(0.635,-3.81) 6(1.905,-3.81) 7(3.175,-3.81) 8(4.445,-3.81) 9(4.445,3.81) 10(3.175,3.81) 11(1.905,3.81) 12(0.635,3.81) 13(-0.635,3.81) 14(-1.905,3.81) 15(-3.175,3.81) 16(-4.445,3.81)
DIPSWITCH_SMT_QUAD
  rect 0.762x1.27 smd: 1(-1.905,-3.81) 2(-0.635,-3.81) 3(0.635,-3.81) 4(1.905,-3.81) 5(1.905,3.81) 6(0.635,3.81) 7(-0.635,3.81) 8(-1.905,3.81)
DO-214AB
  rect 2.032x3.556 smd: 1(3.3,0) 2(-3.3,0)
F2486A
  round 2.032 hole 2.03 unplated: (-36.5,34) (-36.5,-34) (36.5,34) (36.5,-34)
  round 6.35 hole 3.2: (-36.5,0) (-33,30.5) (-33,-30.5) (0,34) (0,-34) (33,30.5) (33,-30.5) (36.5,0)
  round 0.559 smd: A2(-25.547,20.5) A60(24.681,20.5) B1(-26.413,20) B61(25.547,20) C62(26.413,19.5) DA62(26.413,-19.5) DB1(-26.413,-20) DB61(25.547,-20) DC2(-25.547,-20.5) DC60(24.681,-20.5)
  round 0.533 smd: A4(-23.815,20.5) A58(22.949,20.5) B3(-24.681,20) B59(23.815,20) C2(-25.547,19.5) C60(24.681,19.5) CW62(26.413,-18.5) CY1(-26.413,-19) CY61(25.547,-19) D1(-26.413,19) D61(25.547,19) DA2(-25.547,-19.5) DA60(24.681,-19.5) DB3(-24.681,-20) DB59(23.815,-20) DC4(-23.815,-20.5) DC58(22.949,-20.5) E62(26.413,18.5)
  round 0.508 smd: A6(-22.083,20.5) A8(-20.351,20.5) A10(-18.619,20.5) A12(-16.887,20.5) A14(-15.155,20.5) A16(-13.423,20.5) A18(-11.691,20.5) A20(-9.959,20.5) A22(-8.227,20.5) A24(-6.495,20.5) A26(-4.763,20.5) A28(-3.031,20.5) A30(-1.299,20.5) A32(0.433,20.5) A34(2.165,20.5) A36(3.897,20.5) A38(5.629,20.5) A40(7.361,20.5) A42(9.093,20.5) A44(10.825,20.5) A46(12.557,20.5) A48(14.289,20.5) A50(16.021,20.5) A52(17.753,20.5) A54(19.485,20.5) A56(21.217,20.5) AA2(-25.547,10.5) AA4(-23.815,10.5) AA6(-22.083,10.5) AA8(-20.351,10.5) AA10(-18.619,10.5) AA12(-16.887,10.5) AA14(-15.155,10.5) AA16(-13.423,10.5) AA18(-11.691,10.5) AA20(-9.959,10.5) AA22(-8.227,10.5) AA24(-6.495,10.5) AA26(-4.763,10.5) AA28(-3.031,10.5) AA30(-1.299,10.5) AA32(0.433,10.5) AA34(2.165,10.5) AA36(3.897,10.5) AA38(5.629,10.5) AA40(7.361,10.5) AA42(9.093,10.5) AA44(10.825,10.5) AA46(12.557,10.5) AA48(14.289,10.5) AA50(16.021,10.5) AA52(17.753,10.5) AA54(19.485,10.5) AA56(21.217,10.5) AA58(22.949,10.5) AA60(24.681,10.5) AA62(26.413,10.5) AB1(-26.413,10) AB3(-24.681,10) AB5(-22.949,10) AB7(-21.217,10) AB9(-19.485,10) AB11(-17.753,10) AB13(-16.021,10) AB15(-14.289,10) AB17(-12.557,10) AB19(-10.825,10) AB21(-9.093,10) AB23(-7.361,10) AB25(-5.629,10) AB27(-3.897,10) AB29(-2.165,10) AB31(-0.433,10) AB33(1.299,10) AB35(3.031,10) AB37(4.763,10) AB39(6.495,10) AB41(8.227,10) AB43(9.959,10) AB45(11.691,10) AB47(13.423,10) AB49(15.155,10) AB51(16.887,10) AB53(18.619,10) AB55(20.351,10) AB57(22.083,10) AB59(23.815,10) AB61(25.547,10) AC2(-25.547,9.5) AC4(-23.815,9.5) AC6(-22.083,9.5) AC8(-20.351,9.5) AC10(-18.619,9.5) AC12(-16.887,9.5) AC14(-15.155,9.5) AC16(-13.423,9.5) AC18(-11.691,9.5) AC20(-9.959,9.5) AC22(-8.227,9.5) AC24(-6.495,9.5) AC26(-4.763,9.5) AC28(-3.031,9.5) AC30(-1.299,9.5) AC32(0.433,9.5) AC34(2.165,9.5) AC36(3.897,9.5) AC38(5.629,9.5) AC40(7.361,9.5) AC42(9.093,9.5) AC44(10.825,9.5) AC46(12.557,9.5) AC48(14.289,9.5) AC50(16.021,9.5) AC52(17.753,9.5) AC54(19.485,9.5) AC56(21.217,9.5) AC58(22.949,9.5) AC60(24.681,9.5) AC62(26.413,9.5) AD1(-26.413,9) AD3(-24.681,9) AD5(-22.949,9) AD7(-21.217,9) AD9(-19.485,9) AD11(-17.753,9) AD13(-16.021,9) AD15(-14.289,9) AD17(-12.557,9) AD19(-10.825,9) AD21(-9.093,9) AD23(-7.361,9) AD25(-5.629,9) AD27(-3.897,9) AD29(-2.165,9) AD31(-0.433,9) AD33(1.299,9) AD35(3.031,9) AD37(4.763,9) AD39(6.495,9) AD41(8.227,9) AD43(9.959,9) AD45(11.691,9) AD47(13.423,9) AD49(15.155,9) AD51(16.887,9) AD53(18.619,9) AD55(20.351,9) AD57(22.083,9) AD59(23.815,9) AD61(25.547,9) AE2(-25.547,8.5) AE4(-23.815,8.5) AE6(-22.083,8.5) AE8(-20.351,8.5) AE10(-18.619,8.5) AE12(-16.887,8.5) AE14(-15.155,8.5) AE16(-13.423,8.5) AE18(-11.691,8.5) AE20(-9.959,8.5) AE22(-8.227,8.5) AE24(-6.495,8.5) AE26(-4.763,8.5) AE28(-3.031,8.5) AE30(-1.299,8.5) AE32(0.433,8.5) AE34(2.165,8.5) AE36(3.897,8.5) AE38(5.629,8.5) AE40(7.361,8.5) AE42(9.093,8.5) AE44(10.825,8.5) AE46(12.557,8.5) AE48(14.289,8.5) AE50(16.021,8.5) AE52(17.753,8.5) AE54(19.485,8.5) AE56(21.217,8.5) AE58(22.949,8.5) AE60(24.681,8.5) AE62(26.413,8.5) AF1(-26.413,8) AF3(-24.681,8) AF5(-22.949,8) AF7(-21.217,8) AF9(-19.485,8) AF11(-17.753,8) AF13(-16.021,8) AF15(-14.289,8) AF17(-12.557,8) AF19(-10.825,8) AF21(-9.093,8) AF23(-7.361,8) AF25(-5.629,8) AF27(-3.897,8) AF29(-2.165,8) AF31(-0.433,8) AF33(1.299,8) AF35(3.031,8) AF37(4.763,8) AF39(6.495,8) AF41(8.227,8) AF43(9.959,8) AF45(11.691,8) AF47(13.423,8) AF49(15.155,8) AF51(16.887,8) AF53(18.619,8) AF55(20.351,8) AF57(22.083,8) AF59(23.815,8) AF61(25.547,8) AG2(-25.547,7.5) AG4(-23.815,7.5) AG6(-22.083,7.5) AG8(-20.351,7.5) AG10(-18.619,7.5) AG12(-16.887,7.5) AG14(-15.155,7.5) AG16(-13.423,7.5) AG18(-11.691,7.5) AG20(-9.959,7.5) AG22(-8.227,7.5) AG24(-6.495,7.5) AG26(-4.763,7.5) AG28(-3.031,7.5) AG30(-1.299,7.5) AG32(0.433,7.5) AG34(2.165,7.5) AG36(3.897,7.5) AG38(5.629,7.5) AG40(7.361,7.5) AG42(9.093,7.5) AG44(10.825,7.5) AG46(12.557,7.5) AG48(14.289,7.5) AG50(16.021,7.5) AG52(17.753,7.5) AG54(19.485,7.5) AG56(21.217,7.5) AG58(22.949,7.5) AG60(24.681,7.5) AG62(26.413,7.5) AH1(-26.413,7) AH3(-24.681,7) AH5(-22.949,7) AH7(-21.217,7) AH9(-19.485,7) AH11(-17.753,7) AH13(-16.021,7) AH15(-14.289,7) AH17(-12.557,7) AH19(-10.825,7) AH21(-9.093,7) AH23(-7.361,7) AH25(-5.629,7) AH27(-3.897,7) AH29(-2.165,7) AH31(-0.433,7) AH33(1.299,7) AH35(3.031,7) AH37(4.763,7) AH39(6.495,7) AH41(8.227,7) AH43(9.959,7) AH45(11.691,7) AH47(13.423,7) AH49(15.155,7) AH51(16.887,7) AH53(18.619,7) AH55(20.351,7) AH57(22.083,7) AH59(23.815,7) AH61(25.547,7) AJ2(-25.547,6.5) AJ4(-23.815,6.5) AJ6(-22.083,6.5) AJ8(-20.351,6.5) AJ10(-18.619,6.5) AJ12(-16.887,6.5) AJ14(-15.155,6.5) AJ16(-13.423,6.5) AJ18(-11.691,6.5) AJ20(-9.959,6.5) AJ22(-8.227,6.5) AJ24(-6.495,6.5) AJ26(-4.763,6.5) AJ28(-3.031,6.5) AJ30(-1.299,6.5) AJ32(0.433,6.5) AJ34(2.165,6.5) AJ36(3.897,6.5) AJ38(5.629,6.5) AJ40(7.361,6.5) AJ42(9.093,6.5) AJ44(10.825,6.5) AJ46(12.557,6.5) AJ48(14.289,6.5) AJ50(16.021,6.5) AJ52(17.753,6.5) AJ54(19.485,6.5) AJ56(21.217,6.5) AJ58(22.949,6.5) AJ60(24.681,6.5) AJ62(26.413,6.5) AK1(-26.413,6) AK3(-24.681,6) AK5(-22.949,6) AK7(-21.217,6) AK9(-19.485,6) AK11(-17.753,6) AK13(-16.021,6) AK15(-14.289,6) AK17(-12.557,6) AK19(-10.825,6) AK21(-9.093,6) AK23(-7.361,6) AK25(-5.629,6) AK27(-3.897,6) AK29(-2.165,6) AK31(-0.433,6) AK33(1.299,6) AK35(3.031,6) AK37(4.763,6) AK39(6.495,6) AK41(8.227,6) AK43(9.959,6) AK45(11.691,6) AK47(13.423,6) AK49(15.155,6) AK51(16.887,6) AK53(18.619,6) AK55(20.351,6) AK57(22.083,6) AK59(23.815,6) AK61(25.547,6) AL2(-25.547,5.5) AL4(-23.815,5.5) AL6(-22.083,5.5) AL8(-20.351,5.5) AL10(-18.619,5.5) AL12(-16.887,5.5) AL14(-15.155,5.5) AL16(-13.423,5.5) AL18(-11.691,5.5) AL20(-9.959,5.5) AL22(-8.227,5.5) AL24(-6.495,5.5) AL26(-4.763,5.5) AL28(-3.031,5.5) AL30(-1.299,5.5) AL32(0.433,5.5) AL34(2.165,5.5) AL36(3.897,5.5) AL38(5.629,5.5) AL40(7.361,5.5) AL42(9.093,5.5) AL44(10.825,5.5) AL46(12.557,5.5) AL48(14.289,5.5) AL50(16.021,5.5) AL52(17.753,5.5) AL54(19.485,5.5) AL56(21.217,5.5) AL58(22.949,5.5) AL60(24.681,5.5) AL62(26.413,5.5) AM1(-26.413,5) AM3(-24.681,5) AM5(-22.949,5) AM7(-21.217,5) AM9(-19.485,5) AM11(-17.753,5) AM13(-16.021,5) AM15(-14.289,5) AM17(-12.557,5) AM19(-10.825,5) AM21(-9.093,5) AM23(-7.361,5) AM25(-5.629,5) AM27(-3.897,5) AM29(-2.165,5) AM31(-0.433,5) AM33(1.299,5) AM35(3.031,5) AM37(4.763,5) AM39(6.495,5) AM41(8.227,5) AM43(9.959,5) AM45(11.691,5) AM47(13.423,5) AM49(15.155,5) AM51(16.887,5) AM53(18.619,5) AM55(20.351,5) AM57(22.083,5) AM59(23.815,5) AM61(25.547,5) AN2(-25.547,4.5) AN4(-23.815,4.5) AN6(-22.083,4.5) AN8(-20.351,4.5) AN10(-18.619,4.5) AN12(-16.887,4.5) AN14(-15.155,4.5) AN16(-13.423,4.5) AN18(-11.691,4.5) AN20(-9.959,4.5) AN22(-8.227,4.5) AN24(-6.495,4.5) AN26(-4.763,4.5) AN28(-3.031,4.5) AN30(-1.299,4.5) AN32(0.433,4.5) AN34(2.165,4.5) AN36(3.897,4.5) AN38(5.629,4.5) AN40(7.361,4.5) AN42(9.093,4.5) AN44(10.825,4.5) AN46(12.557,4.5) AN48(14.289,4.5) AN50(16.021,4.5) AN52(17.753,4.5) AN54(19.485,4.5) AN56(21.217,4.5) AN58(22.949,4.5) AN60(24.681,4.5) AN62(26.413,4.5) AP1(-26.413,4) AP3(-24.681,4) AP5(-22.949,4) AP7(-21.217,4) AP9(-19.485,4) AP11(-17.753,4) AP13(-16.021,4) AP15(-14.289,4) AP17(-12.557,4) AP19(-10.825,4) AP21(-9.093,4) AP23(-7.361,4) AP25(-5.629,4) AP37(4.763,4) AP39(6.495,4) AP41(8.227,4) AP43(9.959,4) AP45(11.691,4) AP47(13.423,4) AP49(15.155,4) AP51(16.887,4) AP53(18.619,4) AP55(20.351,4) AP57(22.083,4) AP59(23.815,4) AP61(25.547,4) AR2(-25.547,3.5) AR4(-23.815,3.5) AR6(-22.083,3.5) AR8(-20.351,3.5) AR10(-18.619,3.5) AR12(-16.887,3.5) AR14(-15.155,3.5) AR16(-13.423,3.5) AR18(-11.691,3.5) AR20(-9.959,3.5) AR22(-8.227,3.5) AR24(-6.495,3.5) AR26(-4.763,3.5) AR38(5.629,3.5) AR40(7.361,3.5) AR42(9.093,3.5) AR44(10.825,3.5) AR46(12.557,3.5) AR48(14.289,3.5) AR50(16.021,3.5) AR52(17.753,3.5) AR54(19.485,3.5) AR56(21.217,3.5) AR58(22.949,3.5) AR60(24.681,3.5) AR62(26.413,3.5) AT1(-26.413,3) AT3(-24.681,3) AT5(-22.949,3) AT7(-21.217,3) AT9(-19.485,3) AT11(-17.753,3) AT13(-16.021,3) AT15(-14.289,3) AT17(-12.557,3) AT19(-10.825,3) AT21(-9.093,3) AT23(-7.361,3) AT25(-5.629,3) AT37(4.763,3) AT39(6.495,3) AT41(8.227,3) AT43(9.959,3) AT45(11.691,3) AT47(13.423,3) AT49(15.155,3) AT51(16.887,3) AT53(18.619,3) AT55(20.351,3) AT57(22.083,3) AT59(23.815,3) AT61(25.547,3) AU2(-25.547,2.5) AU4(-23.815,2.5) AU6(-22.083,2.5) AU8(-20.351,2.5) AU10(-18.619,2.5) AU12(-16.887,2.5) AU14(-15.155,2.5) AU16(-13.423,2.5) AU18(-11.691,2.5) AU20(-9.959,2.5) AU22(-8.227,2.5) AU24(-6.495,2.5) AU26(-4.763,2.5) AU38(5.629,2.5) AU40(7.361,2.5) AU42(9.093,2.5) AU44(10.825,2.5) AU46(12.557,2.5) AU48(14.289,2.5) AU50(16.021,2.5) AU52(17.753,2.5) AU54(19.485,2.5) AU56(21.217,2.5) AU58(22.949,2.5) AU60(24.681,2.5) AU62(26.413,2.5) AV1(-26.413,2) AV3(-24.681,2) AV5(-22.949,2) AV7(-21.217,2) AV9(-19.485,2) AV11(-17.753,2) AV13(-16.021,2) AV15(-14.289,2) AV17(-12.557,2) AV19(-10.825,2) AV21(-9.093,2) AV23(-7.361,2) AV25(-5.629,2) AV37(4.763,2) AV39(6.495,2) AV41(8.227,2) AV43(9.959,2) AV45(11.691,2) AV47(13.423,2) AV49(15.155,2) AV51(16.887,2) AV53(18.619,2) AV55(20.351,2) AV57(22.083,2) AV59(23.815,2) AV61(25.547,2) AW2(-25.547,1.5) AW4(-23.815,1.5) AW6(-22.083,1.5) AW8(-20.351,1.5) AW10(-18.619,1.5) AW12(-16.887,1.5) AW14(-15.155,1.5) AW16(-13.423,1.5) AW18(-11.691,1.5) AW20(-9.959,1.5) AW22(-8.227,1.5) AW24(-6.495,1.5) AW26(-4.763,1.5) AW38(5.629,1.5) AW40(7.361,1.5) AW42(9.093,1.5) AW44(10.825,1.5) AW46(12.557,1.5) AW48(14.289,1.5) AW50(16.021,1.5) AW52(17.753,1.5) AW54(19.485,1.5) AW56(21.217,1.5) AW58(22.949,1.5) AW60(24.681,1.5) AW62(26.413,1.5) AY1(-26.413,1) AY3(-24.681,1) AY5(-22.949,1) AY7(-21.217,1) AY9(-19.485,1) AY11(-17.753,1) AY13(-16.021,1) AY15(-14.289,1) AY17(-12.557,1) AY19(-10.825,1) AY21(-9.093,1) AY23(-7.361,1) AY25(-5.629,1) AY37(4.763,1) AY39(6.495,1) AY41(8.227,1) AY43(9.959,1) AY45(11.691,1) AY47(13.423,1) AY49(15.155,1) AY51(16.887,1) AY53(18.619,1) AY55(20.351,1) AY57(22.083,1) AY59(23.815,1) AY61(25.547,1) B5(-22.949,20) B7(-21.217,20) B9(-19.485,20) B11(-17.753,20) B13(-16.021,20) B15(-14.289,20) B17(-12.557,20) B19(-10.825,20) B21(-9.093,20) B23(-7.361,20) B25(-5.629,20) B27(-3.897,20) B29(-2.165,20) B31(-0.433,20) B33(1.299,20) B35(3.031,20) B37(4.763,20) B39(6.495,20) B41(8.227,20) B43(9.959,20) B45(11.691,20) B47(13.423,20) B49(15.155,20) B51(16.887,20) B53(18.619,20) B55(20.351,20) B57(22.083,20) BA2(-25.547,0.5) BA4(-23.815,0.5) BA6(-22.083,0.5) BA8(-20.351,0.5) BA10(-18.619,0.5) BA12(-16.887,0.5) BA14(-15.155,0.5) BA16(-13.423,0.5) BA18(-11.691,0.5) BA20(-9.959,0.5) BA22(-8.227,0.5) BA24(-6.495,0.5) BA26(-4.763,0.5) BA38(5.629,0.5) BA40(7.361,0.5) BA42(9.093,0.5) BA44(10.825,0.5) BA46(12.557,0.5) BA48(14.289,0.5) BA50(16.021,0.5) BA52(17.753,0.5) BA54(19.485,0.5) BA56(21.217,0.5) BA58(22.949,0.5) BA60(24.681,0.5) BA62(26.413,0.5) BB1(-26.413,0) BB3(-24.681,0) BB5(-22.949,0) BB7(-21.217,0) BB9(-19.485,0) BB11(-17.753,0) BB13(-16.021,0) BB15(-14.289,0) BB17(-12.557,0) BB19(-10.825,0) BB21(-9.093,0) BB23(-7.361,0) BB25(-5.629,0) BB37(4.763,0) BB39(6.495,0) BB41(8.227,0) BB43(9.959,0) BB45(11.691,0) BB47(13.423,0) BB49(15.155,0) BB51(16.887,0) BB53(18.619,0) BB55(20.351,0) BB57(22.083,0) BB59(23.815,0) BB61(25.547,0) BC2(-25.547,-0.5) BC4(-23.815,-0.5) BC6(-22.083,-0.5) BC8(-20.351,-0.5) BC10(-18.619,-0.5) BC12(-16.887,-0.5) BC14(-15.155,-0.5) BC16(-13.423,-0.5) BC18(-11.691,-0.5) BC20(-9.959,-0.5) BC22(-8.227,-0.5) BC24(-6.495,-0.5) BC26(-4.763,-0.5) BC38(5.629,-0.5) BC40(7.361,-0.5) BC42(9.093,-0.5) BC44(10.825,-0.5) BC46(12.557,-0.5) BC48(14.289,-0.5) BC50(16.021,-0.5) BC52(17.753,-0.5) BC54(19.485,-0.5) BC56(21.217,-0.5) BC58(22.949,-0.5) BC60(24.681,-0.5) BC62(26.413,-0.5) BD1(-26.413,-1) BD3(-24.681,-1) BD5(-22.949,-1) BD7(-21.217,-1) BD9(-19.485,-1) BD11(-17.753,-1) BD13(-16.021,-1) BD15(-14.289,-1) BD17(-12.557,-1) BD19(-10.825,-1) BD21(-9.093,-1) BD23(-7.361,-1) BD25(-5.629,-1) BD37(4.763,-1) BD39(6.495,-1) BD41(8.227,-1) BD43(9.959,-1) BD45(11.691,-1) BD47(13.423,-1) BD49(15.155,-1) BD51(16.887,-1) BD53(18.619,-1) BD55(20.351,-1) BD57(22.083,-1) BD59(23.815,-1) BD61(25.547,-1) BE2(-25.547,-1.5) BE4(-23.815,-1.5) BE6(-22.083,-1.5) BE8(-20.351,-1.5) BE10(-18.619,-1.5) BE12(-16.887,-1.5) BE14(-15.155,-1.5) BE16(-13.423,-1.5) BE18(-11.691,-1.5) BE20(-9.959,-1.5) BE22(-8.227,-1.5) BE24(-6.495,-1.5) BE26(-4.763,-1.5) BE38(5.629,-1.5) BE40(7.361,-1.5) BE42(9.093,-1.5) BE44(10.825,-1.5) BE46(12.557,-1.5) BE48(14.289,-1.5) BE50(16.021,-1.5) BE52(17.753,-1.5) BE54(19.485,-1.5) BE56(21.217,-1.5) BE58(22.949,-1.5) BE60(24.681,-1.5) BE62(26.413,-1.5) BF1(-26.413,-2) BF3(-24.681,-2) BF5(-22.949,-2) BF7(-21.217,-2) BF9(-19.485,-2) BF11(-17.753,-2) BF13(-16.021,-2) BF15(-14.289,-2) BF17(-12.557,-2) BF19(-10.825,-2) BF21(-9.093,-2) BF23(-7.361,-2) BF25(-5.629,-2) BF37(4.763,-2) BF39(6.495,-2) BF41(8.227,-2) BF43(9.959,-2) BF45(11.691,-2) BF47(13.423,-2) BF49(15.155,-2) BF51(16.887,-2) BF53(18.619,-2) BF55(20.351,-2) BF57(22.083,-2) BF59(23.815,-2) BF61(25.547,-2) BG2(-25.547,-2.5) BG4(-23.815,-2.5) BG6(-22.083,-2.5) BG8(-20.351,-2.5) BG10(-18.619,-2.5) BG12(-16.887,-2.5) BG14(-15.155,-2.5) BG16(-13.423,-2.5) BG18(-11.691,-2.5) BG20(-9.959,-2.5) BG22(-8.227,-2.5) BG24(-6.495,-2.5) BG26(-4.763,-2.5) BG38(5.629,-2.5) BG40(7.361,-2.5) BG42(9.093,-2.5) BG44(10.825,-2.5) BG46(12.557,-2.5) BG48(14.289,-2.5) BG50(16.021,-2.5) BG52(17.753,-2.5) BG54(19.485,-2.5) BG56(21.217,-2.5) BG58(22.949,-2.5) BG60(24.681,-2.5) BG62(26.413,-2.5) BH1(-26.413,-3) BH3(-24.681,-3) BH5(-22.949,-3) BH7(-21.217,-3) BH9(-19.485,-3) BH11(-17.753,-3) BH13(-16.021,-3) BH15(-14.289,-3) BH17(-12.557,-3) BH19(-10.825,-3) BH21(-9.093,-3) BH23(-7.361,-3) BH25(-5.629,-3) BH37(4.763,-3) BH39(6.495,-3) BH41(8.227,-3) BH43(9.959,-3) BH45(11.691,-3) BH47(13.423,-3) BH49(15.155,-3) BH51(16.887,-3) BH53(18.619,-3) BH55(20.351,-3) BH57(22.083,-3) BH59(23.815,-3) BH61(25.547,-3) BJ2(-25.547,-3.5) BJ4(-23.815,-3.5) BJ6(-22.083,-3.5) BJ8(-20.351,-3.5) BJ10(-18.619,-3.5) BJ12(-16.887,-3.5) BJ14(-15.155,-3.5) BJ16(-13.423,-3.5) BJ18(-11.691,-3.5) BJ20(-9.959,-3.5) BJ22(-8.227,-3.5) BJ24(-6.495,-3.5) BJ26(-4.763,-3.5) BJ38(5.629,-3.5) BJ40(7.361,-3.5) BJ42(9.093,-3.5) BJ44(10.825,-3.5) BJ46(12.557,-3.5) BJ48(14.289,-3.5) BJ50(16.021,-3.5) BJ52(17.753,-3.5) BJ54(19.485,-3.5) BJ56(21.217,-3.5) BJ58(22.949,-3.5) BJ60(24.681,-3.5) BJ62(26.413,-3.5) BK1(-26.413,-4) BK3(-24.681,-4) BK5(-22.949,-4) BK7(-21.217,-4) BK9(-19.485,-4) BK11(-17.753,-4) BK13(-16.021,-4) BK15(-14.289,-4) BK17(-12.557,-4) BK19(-10.825,-4) BK21(-9.093,-4) BK23(-7.361,-4) BK25(-5.629,-4) BK37(4.763,-4) BK39(6.495,-4) BK41(8.227,-4) BK43(9.959,-4) BK45(11.691,-4) BK47(13.423,-4) BK49(15.155,-4) BK51(16.887,-4) BK53(18.619,-4) BK55(20.351,-4) BK57(22.083,-4) BK59(23.815,-4) BK61(25.547,-4) BL2(-25.547,-4.5) BL4(-23.815,-4.5) BL6(-22.083,-4.5) BL8(-20.351,-4.5) BL10(-18.619,-4.5) BL12(-16.887,-4.5) BL14(-15.155,-4.5) BL16(-13.423,-4.5) BL18(-11.691,-4.5) BL20(-9.959,-4.5) BL22(-8.227,-4.5) BL24(-6.495,-4.5) BL26(-4.763,-4.5) BL28(-3.031,-4.5) BL30(-1.299,-4.5) BL32(0.433,-4.5) BL34(2.165,-4.5) BL36(3.897,-4.5) BL38(5.629,-4.5) BL40(7.361,-4.5) BL42(9.093,-4.5) BL44(10.825,-4.5) BL46(12.557,-4.5) BL48(14.289,-4.5) BL50(16.021,-4.5) BL52(17.753,-4.5) BL54(19.485,-4.5) BL56(21.217,-4.5) BL58(22.949,-4.5) BL60(24.681,-4.5) BL62(26.413,-4.5) BM1(-26.413,-5) BM3(-24.681,-5) BM5(-22.949,-5) BM7(-21.217,-5) BM9(-19.485,-5) BM11(-17.753,-5) BM13(-16.021,-5) BM15(-14.289,-5) BM17(-12.557,-5) BM19(-10.825,-5) BM21(-9.093,-5) BM23(-7.361,-5) BM25(-5.629,-5) BM27(-3.897,-5) BM29(-2.165,-5) BM31(-0.433,-5) BM33(1.299,-5) BM35(3.031,-5) BM37(4.763,-5) BM39(6.495,-5) BM41(8.227,-5) BM43(9.959,-5) BM45(11.691,-5) BM47(13.423,-5) BM49(15.155,-5) BM51(16.887,-5) BM53(18.619,-5) BM55(20.351,-5) BM57(22.083,-5) BM59(23.815,-5) BM61(25.547,-5) BN2(-25.547,-5.5) BN4(-23.815,-5.5) BN6(-22.083,-5.5) BN8(-20.351,-5.5) BN10(-18.619,-5.5) BN12(-16.887,-5.5) BN14(-15.155,-5.5) BN16(-13.423,-5.5) BN18(-11.691,-5.5) BN20(-9.959,-5.5) BN22(-8.227,-5.5) BN24(-6.495,-5.5) BN26(-4.763,-5.5) BN28(-3.031,-5.5) BN30(-1.299,-5.5) BN32(0.433,-5.5) BN34(2.165,-5.5) BN36(3.897,-5.5) BN38(5.629,-5.5) BN40(7.361,-5.5) BN42(9.093,-5.5) BN44(10.825,-5.5) BN46(12.557,-5.5) BN48(14.289,-5.5) BN50(16.021,-5.5) BN52(17.753,-5.5) BN54(19.485,-5.5) BN56(21.217,-5.5) BN58(22.949,-5.5) BN60(24.681,-5.5) BN62(26.413,-5.5) BP1(-26.413,-6) BP3(-24.681,-6) BP5(-22.949,-6) BP7(-21.217,-6) BP9(-19.485,-6) BP11(-17.753,-6) BP13(-16.021,-6) BP15(-14.289,-6) BP17(-12.557,-6) BP19(-10.825,-6) BP21(-9.093,-6) BP23(-7.361,-6) BP25(-5.629,-6) BP27(-3.897,-6) BP29(-2.165,-6) BP31(-0.433,-6) BP33(1.299,-6) BP35(3.031,-6) BP37(4.763,-6) BP39(6.495,-6) BP41(8.227,-6) BP43(9.959,-6) BP45(11.691,-6) BP47(13.423,-6) BP49(15.155,-6) BP51(16.887,-6) BP53(18.619,-6) BP55(20.351,-6) BP57(22.083,-6) BP59(23.815,-6) BP61(25.547,-6) BR2(-25.547,-6.5) BR4(-23.815,-6.5) BR6(-22.083,-6.5) BR8(-20.351,-6.5) BR10(-18.619,-6.5) BR12(-16.887,-6.5) BR14(-15.155,-6.5) BR16(-13.423,-6.5) BR18(-11.691,-6.5) BR20(-9.959,-6.5) BR22(-8.227,-6.5) BR24(-6.495,-6.5) BR26(-4.763,-6.5) BR28(-3.031,-6.5) BR30(-1.299,-6.5) BR32(0.433,-6.5) BR34(2.165,-6.5) BR36(3.897,-6.5) BR38(5.629,-6.5) BR40(7.361,-6.5) BR42(9.093,-6.5) BR44(10.825,-6.5) BR46(12.557,-6.5) BR48(14.289,-6.5) BR50(16.021,-6.5) BR52(17.753,-6.5) BR54(19.485,-6.5) BR56(21.217,-6.5) BR58(22.949,-6.5) BR60(24.681,-6.5) BR62(26.413,-6.5) BT1(-26.413,-7) BT3(-24.681,-7) BT5(-22.949,-7) BT7(-21.217,-7) BT9(-19.485,-7) BT11(-17.753,-7) BT13(-16.021,-7) BT15(-14.289,-7) BT17(-12.557,-7) BT19(-10.825,-7) BT21(-9.093,-7) BT23(-7.361,-7) BT25(-5.629,-7) BT27(-3.897,-7) BT29(-2.165,-7) BT31(-0.433,-7) BT33(1.299,-7) BT35(3.031,-7) BT37(4.763,-7) BT39(6.495,-7) BT41(8.227,-7) BT43(9.959,-7) BT45(11.691,-7) BT47(13.423,-7) BT49(15.155,-7) BT51(16.887,-7) BT53(18.619,-7) BT55(20.351,-7) BT57(22.083,-7) BT59(23.815,-7) BT61(25.547,-7) BU2(-25.547,-7.5) BU4(-23.815,-7.5) BU6(-22.083,-7.5) BU8(-20.351,-7.5) BU10(-18.619,-7.5) BU12(-16.887,-7.5) BU14(-15.155,-7.5) BU16(-13.423,-7.5) BU18(-11.691,-7.5) BU20(-9.959,-7.5) BU22(-8.227,-7.5) BU24(-6.495,-7.5) BU26(-4.763,-7.5) BU28(-3.031,-7.5) BU30(-1.299,-7.5) BU32(0.433,-7.5) BU34(2.165,-7.5) BU36(3.897,-7.5) BU38(5.629,-7.5) BU40(7.361,-7.5) BU42(9.093,-7.5) BU44(10.825,-7.5) BU46(12.557,-7.5) BU48(14.289,-7.5) BU50(16.021,-7.5) BU52(17.753,-7.5) BU54(19.485,-7.5) BU56(21.217,-7.5) BU58(22.949,-7.5) BU60(24.681,-7.5) BU62(26.413,-7.5) BV1(-26.413,-8) BV3(-24.681,-8) BV5(-22.949,-8) BV7(-21.217,-8) BV9(-19.485,-8) BV11(-17.753,-8) BV13(-16.021,-8) BV15(-14.289,-8) BV17(-12.557,-8) BV19(-10.825,-8) BV21(-9.093,-8) BV23(-7.361,-8) BV25(-5.629,-8) BV27(-3.897,-8) BV29(-2.165,-8) BV31(-0.433,-8) BV33(1.299,-8) BV35(3.031,-8) BV37(4.763,-8) BV39(6.495,-8) BV41(8.227,-8) BV43(9.959,-8) BV45(11.691,-8) BV47(13.423,-8) BV49(15.155,-8) BV51(16.887,-8) BV53(18.619,-8) BV55(20.351,-8) BV57(22.083,-8) BV59(23.815,-8) BV61(25.547,-8) BW2(-25.547,-8.5) BW4(-23.815,-8.5) BW6(-22.083,-8.5) BW8(-20.351,-8.5) BW10(-18.619,-8.5) BW12(-16.887,-8.5) BW14(-15.155,-8.5) BW16(-13.423,-8.5) BW18(-11.691,-8.5) BW20(-9.959,-8.5) BW22(-8.227,-8.5) BW24(-6.495,-8.5) BW26(-4.763,-8.5) BW28(-3.031,-8.5) BW30(-1.299,-8.5) BW32(0.433,-8.5) BW34(2.165,-8.5) BW36(3.897,-8.5) BW38(5.629,-8.5) BW40(7.361,-8.5) BW42(9.093,-8.5) BW44(10.825,-8.5) BW46(12.557,-8.5) BW48(14.289,-8.5) BW50(16.021,-8.5) BW52(17.753,-8.5) BW54(19.485,-8.5) BW56(21.217,-8.5) BW58(22.949,-8.5) BW60(24.681,-8.5) BW62(26.413,-8.5) BY1(-26.413,-9) BY3(-24.681,-9) BY5(-22.949,-9) BY7(-21.217,-9) BY9(-19.485,-9) BY11(-17.753,-9) BY13(-16.021,-9) BY15(-14.289,-9) BY17(-12.557,-9) BY19(-10.825,-9) BY21(-9.093,-9) BY23(-7.361,-9) BY25(-5.629,-9) BY27(-3.897,-9) BY29(-2.165,-9) BY31(-0.433,-9) BY33(1.299,-9) BY35(3.031,-9) BY37(4.763,-9) BY39(6.495,-9) BY41(8.227,-9) BY43(9.959,-9) BY45(11.691,-9) BY47(13.423,-9) BY49(15.155,-9) BY51(16.887,-9) BY53(18.619,-9) BY55(20.351,-9) BY57(22.083,-9) BY59(23.815,-9) BY61(25.547,-9) C4(-23.815,19.5) C6(-22.083,19.5) C8(-20.351,19.5) C10(-18.619,19.5) C12(-16.887,19.5) C14(-15.155,19.5) C16(-13.423,19.5) C18(-11.691,19.5) C20(-9.959,19.5) C22(-8.227,19.5) C24(-6.495,19.5) C26(-4.763,19.5) C28(-3.031,19.5) C30(-1.299,19.5) C32(0.433,19.5) C34(2.165,19.5) C36(3.897,19.5) C38(5.629,19.5) C40(7.361,19.5) C42(9.093,19.5) C44(10.825,19.5) C46(12.557,19.5) C48(14.289,19.5) C50(16.021,19.5) C52(17.753,19.5) C54(19.485,19.5) C56(21.217,19.5) C58(22.949,19.5) CA2(-25.547,-9.5) CA4(-23.815,-9.5) CA6(-22.083,-9.5) CA8(-20.351,-9.5) CA10(-18.619,-9.5) CA12(-16.887,-9.5) CA14(-15.155,-9.5) CA16(-13.423,-9.5) CA18(-11.691,-9.5) CA20(-9.959,-9.5) CA22(-8.227,-9.5) CA24(-6.495,-9.5) CA26(-4.763,-9.5) CA28(-3.031,-9.5) CA30(-1.299,-9.5) CA32(0.433,-9.5) CA34(2.165,-9.5) CA36(3.897,-9.5) CA38(5.629,-9.5) CA40(7.361,-9.5) CA42(9.093,-9.5) CA44(10.825,-9.5) CA46(12.557,-9.5) CA48(14.289,-9.5) CA50(16.021,-9.5) CA52(17.753,-9.5) CA54(19.485,-9.5) CA56(21.217,-9.5) CA58(22.949,-9.5) CA60(24.681,-9.5) CA62(26.413,-9.5) CB1(-26.413,-10) CB3(-24.681,-10) CB5(-22.949,-10) CB7(-21.217,-10) CB9(-19.485,-10) CB11(-17.753,-10) CB13(-16.021,-10) CB15(-14.289,-10) CB17(-12.557,-10) CB19(-10.825,-10) CB21(-9.093,-10) CB23(-7.361,-10) CB25(-5.629,-10) CB27(-3.897,-10) CB29(-2.165,-10) CB31(-0.433,-10) CB33(1.299,-10) CB35(3.031,-10) CB37(4.763,-10) CB39(6.495,-10) CB41(8.227,-10) CB43(9.959,-10) CB45(11.691,-10) CB47(13.423,-10) CB49(15.155,-10) CB51(16.887,-10) CB53(18.619,-10) CB55(20.351,-10) CB57(22.083,-10) CB59(23.815,-10) CB61(25.547,-10) CC2(-25.547,-10.5) CC4(-23.815,-10.5) CC6(-22.083,-10.5) CC8(-20.351,-10.5) CC10(-18.619,-10.5) CC12(-16.887,-10.5) CC14(-15.155,-10.5) CC16(-13.423,-10.5) CC18(-11.691,-10.5) CC20(-9.959,-10.5) CC22(-8.227,-10.5) CC24(-6.495,-10.5) CC26(-4.763,-10.5) CC28(-3.031,-10.5) CC30(-1.299,-10.5) CC32(0.433,-10.5) CC34(2.165,-10.5) CC36(3.897,-10.5) CC38(5.629,-10.5) CC40(7.361,-10.5) CC42(9.093,-10.5) CC44(10.825,-10.5) CC46(12.557,-10.5) CC48(14.289,-10.5) CC50(16.021,-10.5) CC52(17.753,-10.5) CC54(19.485,-10.5) CC56(21.217,-10.5) CC58(22.949,-10.5) CC60(24.681,-10.5) CC62(26.413,-10.5) CD1(-26.413,-11) CD3(-24.681,-11) CD5(-22.949,-11) CD7(-21.217,-11) CD9(-19.485,-11) CD11(-17.753,-11) CD13(-16.021,-11) CD15(-14.289,-11) CD17(-12.557,-11) CD19(-10.825,-11) CD21(-9.093,-11) CD23(-7.361,-11) CD25(-5.629,-11) CD27(-3.897,-11) CD29(-2.165,-11) CD31(-0.433,-11) CD33(1.299,-11) CD35(3.031,-11) CD37(4.763,-11) CD39(6.495,-11) CD41(8.227,-11) CD43(9.959,-11) CD45(11.691,-11) CD47(13.423,-11) CD49(15.155,-11) CD51(16.887,-11) CD53(18.619,-11) CD55(20.351,-11) CD57(22.083,-11) CD59(23.815,-11) CD61(25.547,-11) CE2(-25.547,-11.5) CE4(-23.815,-11.5) CE6(-22.083,-11.5) CE8(-20.351,-11.5) CE10(-18.619,-11.5) CE12(-16.887,-11.5) CE14(-15.155,-11.5) CE16(-13.423,-11.5) CE18(-11.691,-11.5) CE20(-9.959,-11.5) CE22(-8.227,-11.5) CE24(-6.495,-11.5) CE26(-4.763,-11.5) CE28(-3.031,-11.5) CE30(-1.299,-11.5) CE32(0.433,-11.5) CE34(2.165,-11.5) CE36(3.897,-11.5) CE38(5.629,-11.5) CE40(7.361,-11.5) CE42(9.093,-11.5) CE44(10.825,-11.5) CE46(12.557,-11.5) CE48(14.289,-11.5) CE50(16.021,-11.5) CE52(17.753,-11.5) CE54(19.485,-11.5) CE56(21.217,-11.5) CE58(22.949,-11.5) CE60(24.681,-11.5) CE62(26.413,-11.5) CF1(-26.413,-12) CF3(-24.681,-12) CF5(-22.949,-12) CF7(-21.217,-12) CF9(-19.485,-12) CF11(-17.753,-12) CF13(-16.021,-12) CF15(-14.289,-12) CF17(-12.557,-12) CF19(-10.825,-12) CF21(-9.093,-12) CF23(-7.361,-12) CF25(-5.629,-12) CF27(-3.897,-12) CF29(-2.165,-12) CF31(-0.433,-12) CF33(1.299,-12) CF35(3.031,-12) CF37(4.763,-12) CF39(6.495,-12) CF41(8.227,-12) CF43(9.959,-12) CF45(11.691,-12) CF47(13.423,-12) CF49(15.155,-12) CF51(16.887,-12) CF53(18.619,-12) CF55(20.351,-12) CF57(22.083,-12) CF59(23.815,-12) CF61(25.547,-12) CG2(-25.547,-12.5) CG4(-23.815,-12.5) CG6(-22.083,-12.5) CG8(-20.351,-12.5) CG10(-18.619,-12.5) CG12(-16.887,-12.5) CG14(-15.155,-12.5) CG16(-13.423,-12.5) CG18(-11.691,-12.5) CG20(-9.959,-12.5) CG22(-8.227,-12.5) CG24(-6.495,-12.5) CG26(-4.763,-12.5) CG28(-3.031,-12.5) CG30(-1.299,-12.5) CG32(0.433,-12.5) CG34(2.165,-12.5) CG36(3.897,-12.5) CG38(5.629,-12.5) CG40(7.361,-12.5) CG42(9.093,-12.5) CG44(10.825,-12.5) CG46(12.557,-12.5) CG48(14.289,-12.5) CG50(16.021,-12.5) CG52(17.753,-12.5) CG54(19.485,-12.5) CG56(21.217,-12.5) CG58(22.949,-12.5) CG60(24.681,-12.5) CG62(26.413,-12.5) CH1(-26.413,-13) CH3(-24.681,-13) CH5(-22.949,-13) CH7(-21.217,-13) CH9(-19.485,-13) CH11(-17.753,-13) CH13(-16.021,-13) CH15(-14.289,-13) CH17(-12.557,-13) CH19(-10.825,-13) CH21(-9.093,-13) CH23(-7.361,-13) CH25(-5.629,-13) CH27(-3.897,-13) CH29(-2.165,-13) CH31(-0.433,-13) CH33(1.299,-13) CH35(3.031,-13) CH37(4.763,-13) CH39(6.495,-13) CH41(8.227,-13) CH43(9.959,-13) CH45(11.691,-13) CH47(13.423,-13) CH49(15.155,-13) CH51(16.887,-13) CH53(18.619,-13) CH55(20.351,-13) CH57(22.083,-13) CH59(23.815,-13) CH61(25.547,-13) CJ2(-25.547,-13.5) CJ4(-23.815,-13.5) CJ6(-22.083,-13.5) CJ8(-20.351,-13.5) CJ10(-18.619,-13.5) CJ12(-16.887,-13.5) CJ14(-15.155,-13.5) CJ16(-13.423,-13.5) CJ18(-11.691,-13.5) CJ20(-9.959,-13.5) CJ22(-8.227,-13.5) CJ24(-6.495,-13.5) CJ26(-4.763,-13.5) CJ28(-3.031,-13.5) CJ30(-1.299,-13.5) CJ32(0.433,-13.5) CJ34(2.165,-13.5) CJ36(3.897,-13.5) CJ38(5.629,-13.5) CJ40(7.361,-13.5) CJ42(9.093,-13.5) CJ44(10.825,-13.5) CJ46(12.557,-13.5) CJ48(14.289,-13.5) CJ50(16.021,-13.5) CJ52(17.753,-13.5) CJ54(19.485,-13.5) CJ56(21.217,-13.5) CJ58(22.949,-13.5) CJ60(24.681,-13.5) CJ62(26.413,-13.5) CK1(-26.413,-14) CK3(-24.681,-14) CK5(-22.949,-14) CK7(-21.217,-14) CK9(-19.485,-14) CK11(-17.753,-14) CK13(-16.021,-14) CK15(-14.289,-14) CK17(-12.557,-14) CK19(-10.825,-14) CK21(-9.093,-14) CK23(-7.361,-14) CK25(-5.629,-14) CK27(-3.897,-14) CK29(-2.165,-14) CK31(-0.433,-14) CK33(1.299,-14) CK35(3.031,-14) CK37(4.763,-14) CK39(6.495,-14) CK41(8.227,-14) CK43(9.959,-14) CK45(11.691,-14) CK47(13.423,-14) CK49(15.155,-14) CK51(16.887,-14) CK53(18.619,-14) CK55(20.351,-14) CK57(22.083,-14) CK59(23.815,-14) CK61(25.547,-14) CL2(-25.547,-14.5) CL4(-23.815,-14.5) CL6(-22.083,-14.5) CL8(-20.351,-14.5) CL10(-18.619,-14.5) CL12(-16.887,-14.5) CL14(-15.155,-14.5) CL16(-13.423,-14.5) CL18(-11.691,-14.5) CL20(-9.959,-14.5) CL22(-8.227,-14.5) CL24(-6.495,-14.5) CL26(-4.763,-14.5) CL28(-3.031,-14.5) CL30(-1.299,-14.5) CL32(0.433,-14.5) CL34(2.165,-14.5) CL36(3.897,-14.5) CL38(5.629,-14.5) CL40(7.361,-14.5) CL42(9.093,-14.5) CL44(10.825,-14.5) CL46(12.557,-14.5) CL48(14.289,-14.5) CL50(16.021,-14.5) CL52(17.753,-14.5) CL54(19.485,-14.5) CL56(21.217,-14.5) CL58(22.949,-14.5) CL60(24.681,-14.5) CL62(26.413,-14.5) CM1(-26.413,-15) CM3(-24.681,-15) CM5(-22.949,-15) CM7(-21.217,-15) CM9(-19.485,-15) CM11(-17.753,-15) CM13(-16.021,-15) CM15(-14.289,-15) CM17(-12.557,-15) CM19(-10.825,-15) CM21(-9.093,-15) CM23(-7.361,-15) CM25(-5.629,-15) CM27(-3.897,-15) CM29(-2.165,-15) CM31(-0.433,-15) CM33(1.299,-15) CM35(3.031,-15) CM37(4.763,-15) CM39(6.495,-15) CM41(8.227,-15) CM43(9.959,-15) CM45(11.691,-15) CM47(13.423,-15) CM49(15.155,-15) CM51(16.887,-15) CM53(18.619,-15) CM55(20.351,-15) CM57(22.083,-15) CM59(23.815,-15) CM61(25.547,-15) CN2(-25.547,-15.5) CN4(-23.815,-15.5) CN6(-22.083,-15.5) CN8(-20.351,-15.5) CN10(-18.619,-15.5) CN12(-16.887,-15.5) CN14(-15.155,-15.5) CN16(-13.423,-15.5) CN18(-11.691,-15.5) CN20(-9.959,-15.5) CN22(-8.227,-15.5) CN24(-6.495,-15.5) CN26(-4.763,-15.5) CN28(-3.031,-15.5) CN30(-1.299,-15.5) CN32(0.433,-15.5) CN34(2.165,-15.5) CN36(3.897,-15.5) CN38(5.629,-15.5) CN40(7.361,-15.5) CN42(9.093,-15.5) CN44(10.825,-15.5) CN46(12.557,-15.5) CN48(14.289,-15.5) CN50(16.021,-15.5) CN52(17.753,-15.5) CN54(19.485,-15.5) CN56(21.217,-15.5) CN58(22.949,-15.5) CN60(24.681,-15.5) CN62(26.413,-15.5) CP1(-26.413,-16) CP3(-24.681,-16) CP5(-22.949,-16) CP7(-21.217,-16) CP9(-19.485,-16) CP11(-17.753,-16) CP13(-16.021,-16) CP15(-14.289,-16) CP17(-12.557,-16) CP19(-10.825,-16) CP21(-9.093,-16) CP23(-7.361,-16) CP25(-5.629,-16) CP27(-3.897,-16) CP29(-2.165,-16) CP31(-0.433,-16) CP33(1.299,-16) CP35(3.031,-16) CP37(4.763,-16) CP39(6.495,-16) CP41(8.227,-16) CP43(9.959,-16) CP45(11.691,-16) CP47(13.423,-16) CP49(15.155,-16) CP51(16.887,-16) CP53(18.619,-16) CP55(20.351,-16) CP57(22.083,-16) CP59(23.815,-16) CP61(25.547,-16) CR2(-25.547,-16.5) CR4(-23.815,-16.5) CR6(-22.083,-16.5) CR8(-20.351,-16.5) CR10(-18.619,-16.5) CR12(-16.887,-16.5) CR14(-15.155,-16.5) CR16(-13.423,-16.5) CR18(-11.691,-16.5) CR20(-9.959,-16.5) CR22(-8.227,-16.5) CR24(-6.495,-16.5) CR26(-4.763,-16.5) CR28(-3.031,-16.5) CR30(-1.299,-16.5) CR32(0.433,-16.5) CR34(2.165,-16.5) CR36(3.897,-16.5) CR38(5.629,-16.5) CR40(7.361,-16.5) CR42(9.093,-16.5) CR44(10.825,-16.5) CR46(12.557,-16.5) CR48(14.289,-16.5) CR50(16.021,-16.5) CR52(17.753,-16.5) CR54(19.485,-16.5) CR56(21.217,-16.5) CR58(22.949,-16.5) CR60(24.681,-16.5) CR62(26.413,-16.5) CT1(-26.413,-17) CT3(-24.681,-17) CT5(-22.949,-17) CT7(-21.217,-17) CT9(-19.485,-17) CT11(-17.753,-17) CT13(-16.021,-17) CT15(-14.289,-17) CT17(-12.557,-17) CT19(-10.825,-17) CT21(-9.093,-17) CT23(-7.361,-17) CT25(-5.629,-17) CT27(-3.897,-17) CT29(-2.165,-17) CT31(-0.433,-17) CT33(1.299,-17) CT35(3.031,-17) CT37(4.763,-17) CT39(6.495,-17) CT41(8.227,-17) CT43(9.959,-17) CT45(11.691,-17) CT47(13.423,-17) CT49(15.155,-17) CT51(16.887,-17) CT53(18.619,-17) CT55(20.351,-17) CT57(22.083,-17) CT59(23.815,-17) CT61(25.547,-17) CU2(-25.547,-17.5) CU4(-23.815,-17.5) CU6(-22.083,-17.5) CU8(-20.351,-17.5) CU10(-18.619,-17.5) CU12(-16.887,-17.5) CU14(-15.155,-17.5) CU16(-13.423,-17.5) CU18(-11.691,-17.5) CU20(-9.959,-17.5) CU22(-8.227,-17.5) CU24(-6.495,-17.5) CU26(-4.763,-17.5) CU28(-3.031,-17.5) CU30(-1.299,-17.5) CU32(0.433,-17.5) CU34(2.165,-17.5) CU36(3.897,-17.5) CU38(5.629,-17.5) CU40(7.361,-17.5) CU42(9.093,-17.5) CU44(10.825,-17.5) CU46(12.557,-17.5) CU48(14.289,-17.5) CU50(16.021,-17.5) CU52(17.753,-17.5) CU54(19.485,-17.5) CU56(21.217,-17.5) CU58(22.949,-17.5) CU60(24.681,-17.5) CU62(26.413,-17.5) CV1(-26.413,-18) CV3(-24.681,-18) CV5(-22.949,-18) CV7(-21.217,-18) CV9(-19.485,-18) CV11(-17.753,-18) CV13(-16.021,-18) CV15(-14.289,-18) CV17(-12.557,-18) CV19(-10.825,-18) CV21(-9.093,-18) CV23(-7.361,-18) CV25(-5.629,-18) CV27(-3.897,-18) CV29(-2.165,-18) CV31(-0.433,-18) CV33(1.299,-18) CV35(3.031,-18) CV37(4.763,-18) CV39(6.495,-18) CV41(8.227,-18) CV43(9.959,-18) CV45(11.691,-18) CV47(13.423,-18) CV49(15.155,-18) CV51(16.887,-18) CV53(18.619,-18) CV55(20.351,-18) CV57(22.083,-18) CV59(23.815,-18) CV61(25.547,-18) CW2(-25.547,-18.5) CW4(-23.815,-18.5) CW6(-22.083,-18.5) CW8(-20.351,-18.5) CW10(-18.619,-18.5) CW12(-16.887,-18.5) CW14(-15.155,-18.5) CW16(-13.423,-18.5) CW18(-11.691,-18.5) CW20(-9.959,-18.5) CW22(-8.227,-18.5) CW24(-6.495,-18.5) CW26(-4.763,-18.5) CW28(-3.031,-18.5) CW30(-1.299,-18.5) CW32(0.433,-18.5) CW34(2.165,-18.5) CW36(3.897,-18.5) CW38(5.629,-18.5) CW40(7.361,-18.5) CW42(9.093,-18.5) CW44(10.825,-18.5) CW46(12.557,-18.5) CW48(14.289,-18.5) CW50(16.021,-18.5) CW52(17.753,-18.5) CW54(19.485,-18.5) CW56(21.217,-18.5) CW58(22.949,-18.5) CW60(24.681,-18.5) CY3(-24.681,-19) CY5(-22.949,-19) CY7(-21.217,-19) CY9(-19.485,-19) CY11(-17.753,-19) CY13(-16.021,-19) CY15(-14.289,-19) CY17(-12.557,-19) CY19(-10.825,-19) CY21(-9.093,-19) CY23(-7.361,-19) CY25(-5.629,-19) CY27(-3.897,-19) CY29(-2.165,-19) CY31(-0.433,-19) CY33(1.299,-19) CY35(3.031,-19) CY37(4.763,-19) CY39(6.495,-19) CY41(8.227,-19) CY43(9.959,-19) CY45(11.691,-19) CY47(13.423,-19) CY49(15.155,-19) CY51(16.887,-19) CY53(18.619,-19) CY55(20.351,-19) CY57(22.083,-19) CY59(23.815,-19) D3(-24.681,19) D5(-22.949,19) D7(-21.217,19) D9(-19.485,19) D11(-17.753,19) D13(-16.021,19) D15(-14.289,19) D17(-12.557,19) D19(-10.825,19) D21(-9.093,19) D23(-7.361,19) D25(-5.629,19) D27(-3.897,19) D29(-2.165,19) D31(-0.433,19) D33(1.299,19) D35(3.031,19) D37(4.763,19) D39(6.495,19) D41(8.227,19) D43(9.959,19) D45(11.691,19) D47(13.423,19) D49(15.155,19) D51(16.887,19) D53(18.619,19) D55(20.351,19) D57(22.083,19) D59(23.815,19) DA4(-23.815,-19.5) DA6(-22.083,-19.5) DA8(-20.351,-19.5) DA10(-18.619,-19.5) DA12(-16.887,-19.5) DA14(-15.155,-19.5) DA16(-13.423,-19.5) DA18(-11.691,-19.5) DA20(-9.959,-19.5) DA22(-8.227,-19.5) DA24(-6.495,-19.5) DA26(-4.763,-19.5) DA28(-3.031,-19.5) DA30(-1.299,-19.5) DA32(0.433,-19.5) DA34(2.165,-19.5) DA36(3.897,-19.5) DA38(5.629,-19.5) DA40(7.361,-19.5) DA42(9.093,-19.5) DA44(10.825,-19.5) DA46(12.557,-19.5) DA48(14.289,-19.5) DA50(16.021,-19.5) DA52(17.753,-19.5) DA54(19.485,-19.5) DA56(21.217,-19.5) DA58(22.949,-19.5) DB5(-22.949,-20) DB7(-21.217,-20) DB9(-19.485,-20) DB11(-17.753,-20) DB13(-16.021,-20) DB15(-14.289,-20) DB17(-12.557,-20) DB19(-10.825,-20) DB21(-9.093,-20) DB23(-7.361,-20) DB25(-5.629,-20) DB27(-3.897,-20) DB29(-2.165,-20) DB31(-0.433,-20) DB33(1.299,-20) DB35(3.031,-20) DB37(4.763,-20) DB39(6.495,-20) DB41(8.227,-20) DB43(9.959,-20) DB45(11.691,-20) DB47(13.423,-20) DB49(15.155,-20) DB51(16.887,-20) DB53(18.619,-20) DB55(20.351,-20) DB57(22.083,-20) DC6(-22.083,-20.5) DC8(-20.351,-20.5) DC10(-18.619,-20.5) DC12(-16.887,-20.5) DC14(-15.155,-20.5) DC16(-13.423,-20.5) DC18(-11.691,-20.5) DC20(-9.959,-20.5) DC22(-8.227,-20.5) DC24(-6.495,-20.5) DC26(-4.763,-20.5) DC28(-3.031,-20.5) DC30(-1.299,-20.5) DC32(0.433,-20.5) DC34(2.165,-20.5) DC36(3.897,-20.5) DC38(5.629,-20.5) DC40(7.361,-20.5) DC42(9.093,-20.5) DC44(10.825,-20.5) DC46(12.557,-20.5) DC48(14.289,-20.5) DC50(16.021,-20.5) DC52(17.753,-20.5) DC54(19.485,-20.5) DC56(21.217,-20.5) E2(-25.547,18.5) E4(-23.815,18.5) E6(-22.083,18.5) E8(-20.351,18.5) E10(-18.619,18.5) E12(-16.887,18.5) E14(-15.155,18.5) E16(-13.423,18.5) E18(-11.691,18.5) E20(-9.959,18.5) E22(-8.227,18.5) E24(-6.495,18.5) E26(-4.763,18.5) E28(-3.031,18.5) E30(-1.299,18.5) E32(0.433,18.5) E34(2.165,18.5) E36(3.897,18.5) E38(5.629,18.5) E40(7.361,18.5) E42(9.093,18.5) E44(10.825,18.5) E46(12.557,18.5) E48(14.289,18.5) E50(16.021,18.5) E52(17.753,18.5) E54(19.485,18.5) E56(21.217,18.5) E58(22.949,18.5) E60(24.681,18.5) F1(-26.413,18) F3(-24.681,18) F5(-22.949,18) F7(-21.217,18) F9(-19.485,18) F11(-17.753,18) F13(-16.021,18) F15(-14.289,18) F17(-12.557,18) F19(-10.825,18) F21(-9.093,18) F23(-7.361,18) F25(-5.629,18) F27(-3.897,18) F29(-2.165,18) F31(-0.433,18) F33(1.299,18) F35(3.031,18) F37(4.763,18) F39(6.495,18) F41(8.227,18) F43(9.959,18) F45(11.691,18) F47(13.423,18) F49(15.155,18) F51(16.887,18) F53(18.619,18) F55(20.351,18) F57(22.083,18) F59(23.815,18) F61(25.547,18) G2(-25.547,17.5) G4(-23.815,17.5) G6(-22.083,17.5) G8(-20.351,17.5) G10(-18.619,17.5) G12(-16.887,17.5) G14(-15.155,17.5) G16(-13.423,17.5) G18(-11.691,17.5) G20(-9.959,17.5) G22(-8.227,17.5) G24(-6.495,17.5) G26(-4.763,17.5) G28(-3.031,17.5) G30(-1.299,17.5) G32(0.433,17.5) G34(2.165,17.5) G36(3.897,17.5) G38(5.629,17.5) G40(7.361,17.5) G42(9.093,17.5) G44(10.825,17.5) G46(12.557,17.5) G48(14.289,17.5) G50(16.021,17.5) G52(17.753,17.5) G54(19.485,17.5) G56(21.217,17.5) G58(22.949,17.5) G60(24.681,17.5) G62(26.413,17.5) H1(-26.413,17) H3(-24.681,17) H5(-22.949,17) H7(-21.217,17) H9(-19.485,17) H11(-17.753,17) H13(-16.021,17) H15(-14.289,17) H17(-12.557,17) H19(-10.825,17) H21(-9.093,17) H23(-7.361,17) H25(-5.629,17) H27(-3.897,17) H29(-2.165,17) H31(-0.433,17) H33(1.299,17) H35(3.031,17) H37(4.763,17) H39(6.495,17) H41(8.227,17) H43(9.959,17) H45(11.691,17) H47(13.423,17) H49(15.155,17) H51(16.887,17) H53(18.619,17) H55(20.351,17) H57(22.083,17) H59(23.815,17) H61(25.547,17) J2(-25.547,16.5) J4(-23.815,16.5) J6(-22.083,16.5) J8(-20.351,16.5) J10(-18.619,16.5) J12(-16.887,16.5) J14(-15.155,16.5) J16(-13.423,16.5) J18(-11.691,16.5) J20(-9.959,16.5) J22(-8.227,16.5) J24(-6.495,16.5) J26(-4.763,16.5) J28(-3.031,16.5) J30(-1.299,16.5) J32(0.433,16.5) J34(2.165,16.5) J36(3.897,16.5) J38(5.629,16.5) J40(7.361,16.5) J42(9.093,16.5) J44(10.825,16.5) J46(12.557,16.5) J48(14.289,16.5) J50(16.021,16.5) J52(17.753,16.5) J54(19.485,16.5) J56(21.217,16.5) J58(22.949,16.5) J60(24.681,16.5) J62(26.413,16.5) K1(-26.413,16) K3(-24.681,16) K5(-22.949,16) K7(-21.217,16) K9(-19.485,16) K11(-17.753,16) K13(-16.021,16) K15(-14.289,16) K17(-12.557,16) K19(-10.825,16) K21(-9.093,16) K23(-7.361,16) K25(-5.629,16) K27(-3.897,16) K29(-2.165,16) K31(-0.433,16) K33(1.299,16) K35(3.031,16) K37(4.763,16) K39(6.495,16) K41(8.227,16) K43(9.959,16) K45(11.691,16) K47(13.423,16) K49(15.155,16) K51(16.887,16) K53(18.619,16) K55(20.351,16) K57(22.083,16) K59(23.815,16) K61(25.547,16) L2(-25.547,15.5) L4(-23.815,15.5) L6(-22.083,15.5) L8(-20.351,15.5) L10(-18.619,15.5) L12(-16.887,15.5) L14(-15.155,15.5) L16(-13.423,15.5) L18(-11.691,15.5) L20(-9.959,15.5) L22(-8.227,15.5) L24(-6.495,15.5) L26(-4.763,15.5) L28(-3.031,15.5) L30(-1.299,15.5) L32(0.433,15.5) L34(2.165,15.5) L36(3.897,15.5) L38(5.629,15.5) L40(7.361,15.5) L42(9.093,15.5) L44(10.825,15.5) L46(12.557,15.5) L48(14.289,15.5) L50(16.021,15.5) L52(17.753,15.5) L54(19.485,15.5) L56(21.217,15.5) L58(22.949,15.5) L60(24.681,15.5) L62(26.413,15.5) M1(-26.413,15) M3(-24.681,15) M5(-22.949,15) M7(-21.217,15) M9(-19.485,15) M11(-17.753,15) M13(-16.021,15) M15(-14.289,15) M17(-12.557,15) M19(-10.825,15) M21(-9.093,15) M23(-7.361,15) M25(-5.629,15) M27(-3.897,15) M29(-2.165,15) M31(-0.433,15) M33(1.299,15) M35(3.031,15) M37(4.763,15) M39(6.495,15) M41(8.227,15) M43(9.959,15) M45(11.691,15) M47(13.423,15) M49(15.155,15) M51(16.887,15) M53(18.619,15) M55(20.351,15) M57(22.083,15) M59(23.815,15) M61(25.547,15) N2(-25.547,14.5) N4(-23.815,14.5) N6(-22.083,14.5) N8(-20.351,14.5) N10(-18.619,14.5) N12(-16.887,14.5) N14(-15.155,14.5) N16(-13.423,14.5) N18(-11.691,14.5) N20(-9.959,14.5) N22(-8.227,14.5) N24(-6.495,14.5) N26(-4.763,14.5) N28(-3.031,14.5) N30(-1.299,14.5) N32(0.433,14.5) N34(2.165,14.5) N36(3.897,14.5) N38(5.629,14.5) N40(7.361,14.5) N42(9.093,14.5) N44(10.825,14.5) N46(12.557,14.5) N48(14.289,14.5) N50(16.021,14.5) N52(17.753,14.5) N54(19.485,14.5) N56(21.217,14.5) N58(22.949,14.5) N60(24.681,14.5) N62(26.413,14.5) P1(-26.413,14) P3(-24.681,14) P5(-22.949,14) P7(-21.217,14) P9(-19.485,14) P11(-17.753,14) P13(-16.021,14) P15(-14.289,14) P17(-12.557,14) P19(-10.825,14) P21(-9.093,14) P23(-7.361,14) P25(-5.629,14) P27(-3.897,14) P29(-2.165,14) P31(-0.433,14) P33(1.299,14) P35(3.031,14) P37(4.763,14) P39(6.495,14) P41(8.227,14) P43(9.959,14) P45(11.691,14) P47(13.423,14) P49(15.155,14) P51(16.887,14) P53(18.619,14) P55(20.351,14) P57(22.083,14) P59(23.815,14) P61(25.547,14) R2(-25.547,13.5) R4(-23.815,13.5) R6(-22.083,13.5) R8(-20.351,13.5) R10(-18.619,13.5) R12(-16.887,13.5) R14(-15.155,13.5) R16(-13.423,13.5) R18(-11.691,13.5) R20(-9.959,13.5) R22(-8.227,13.5) R24(-6.495,13.5) R26(-4.763,13.5) R28(-3.031,13.5) R30(-1.299,13.5) R32(0.433,13.5) R34(2.165,13.5) R36(3.897,13.5) R38(5.629,13.5) R40(7.361,13.5) R42(9.093,13.5) R44(10.825,13.5) R46(12.557,13.5) R48(14.289,13.5) R50(16.021,13.5) R52(17.753,13.5) R54(19.485,13.5) R56(21.217,13.5) R58(22.949,13.5) R60(24.681,13.5) R62(26.413,13.5) T1(-26.413,13) T3(-24.681,13) T5(-22.949,13) T7(-21.217,13) T9(-19.485,13) T11(-17.753,13) T13(-16.021,13) T15(-14.289,13) T17(-12.557,13) T19(-10.825,13) T21(-9.093,13) T23(-7.361,13) T25(-5.629,13) T27(-3.897,13) T29(-2.165,13) T31(-0.433,13) T33(1.299,13) T35(3.031,13) T37(4.763,13) T39(6.495,13) T41(8.227,13) T43(9.959,13) T45(11.691,13) T47(13.423,13) T49(15.155,13) T51(16.887,13) T53(18.619,13) T55(20.351,13) T57(22.083,13) T59(23.815,13) T61(25.547,13) U2(-25.547,12.5) U4(-23.815,12.5) U6(-22.083,12.5) U8(-20.351,12.5) U10(-18.619,12.5) U12(-16.887,12.5) U14(-15.155,12.5) U16(-13.423,12.5) U18(-11.691,12.5) U20(-9.959,12.5) U22(-8.227,12.5) U24(-6.495,12.5) U26(-4.763,12.5) U28(-3.031,12.5) U30(-1.299,12.5) U32(0.433,12.5) U34(2.165,12.5) U36(3.897,12.5) U38(5.629,12.5) U40(7.361,12.5) U42(9.093,12.5) U44(10.825,12.5) U46(12.557,12.5) U48(14.289,12.5) U50(16.021,12.5) U52(17.753,12.5) U54(19.485,12.5) U56(21.217,12.5) U58(22.949,12.5) U60(24.681,12.5) U62(26.413,12.5) V1(-26.413,12) V3(-24.681,12) V5(-22.949,12) V7(-21.217,12) V9(-19.485,12) V11(-17.753,12) V13(-16.021,12) V15(-14.289,12) V17(-12.557,12) V19(-10.825,12) V21(-9.093,12) V23(-7.361,12) V25(-5.629,12) V27(-3.897,12) V29(-2.165,12) V31(-0.433,12) V33(1.299,12) V35(3.031,12) V37(4.763,12) V39(6.495,12) V41(8.227,12) V43(9.959,12) V45(11.691,12) V47(13.423,12) V49(15.155,12) V51(16.887,12) V53(18.619,12) V55(20.351,12) V57(22.083,12) V59(23.815,12) V61(25.547,12) W2(-25.547,11.5) W4(-23.815,11.5) W6(-22.083,11.5) W8(-20.351,11.5) W10(-18.619,11.5) W12(-16.887,11.5) W14(-15.155,11.5) W16(-13.423,11.5) W18(-11.691,11.5) W20(-9.959,11.5) W22(-8.227,11.5) W24(-6.495,11.5) W26(-4.763,11.5) W28(-3.031,11.5) W30(-1.299,11.5) W32(0.433,11.5) W34(2.165,11.5) W36(3.897,11.5) W38(5.629,11.5) W40(7.361,11.5) W42(9.093,11.5) W44(10.825,11.5) W46(12.557,11.5) W48(14.289,11.5) W50(16.021,11.5) W52(17.753,11.5) W54(19.485,11.5) W56(21.217,11.5) W58(22.949,11.5) W60(24.681,11.5) W62(26.413,11.5) Y1(-26.413,11) Y3(-24.681,11) Y5(-22.949,11) Y7(-21.217,11) Y9(-19.485,11) Y11(-17.753,11) Y13(-16.021,11) Y15(-14.289,11) Y17(-12.557,11) Y19(-10.825,11) Y21(-9.093,11) Y23(-7.361,11) Y25(-5.629,11) Y27(-3.897,11) Y29(-2.165,11) Y31(-0.433,11) Y33(1.299,11) Y35(3.031,11) Y37(4.763,11) Y39(6.495,11) Y41(8.227,11) Y43(9.959,11) Y45(11.691,11) Y47(13.423,11) Y49(15.155,11) Y51(16.887,11) Y53(18.619,11) Y55(20.351,11) Y57(22.083,11) Y59(23.815,11) Y61(25.547,11)
