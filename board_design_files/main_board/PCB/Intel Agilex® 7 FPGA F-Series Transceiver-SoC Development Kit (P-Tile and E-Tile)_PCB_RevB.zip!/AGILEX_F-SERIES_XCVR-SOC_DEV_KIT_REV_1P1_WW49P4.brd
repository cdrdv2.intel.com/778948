# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LTM4680_SHARE_CLK: length 9.6
  ART18 w0.114: v2(165.4,180.14) 165.84,179.71 165.84,178.64 164.01,176.81 160.17,176.81 v4(159.54,176.17)
  BOTTOM w0.109: R5460.1 v2(165.4,180.14)
LTM4680_SYNC: length 18.1
  ART18 w0.114: v2(165.35,178.74) 164.85,179.25 152.88,179.25 152.6,178.97 152.6,175.59 v4(151.92,174.9)
  BOTTOM w0.109: R5459.1 v2(165.35,178.74)
M2F_I2C_SCL: length 77.1
  ART16 w0.114: v2(150.21,96.32) 149.76,96.77 149.76,98.04 151.23,99.52 151.23,102.22 153.32,104.3 161.33,104.3 162.74,102.89 162.74,102.57 162.61,102.44 162.61,102.01 162.87,101.75 163.09,101.75 163.28,101.55 163.28,101.3 163.39,101.19 163.39,100.71 163.68,100.43 163.68,99.94 164.05,99.57 164.68,99.57 v2(165.07,99.18)
  ART18 w0.114: v2(150.21,96.32) 147.77,96.32 143.81,100.28 140.18,100.28 139.06,101.4 139.06,105.84 138.42,106.49 138.03,106.49 137.95,106.56 137.95,106.56 137.45,107.06 137.08,107.06 136.55,107.6 136.27,107.6 136.05,107.81 136.05,108.32 136.11,108.38 136.11,108.82 135.8,109.14 135.33,109.14 134.86,108.67 134.54,108.67 134.09,109.13 133.77,109.13 133.36,109.53 133.36,110.26 133.11,110.52 132.75,110.52 132.27,111 131.95,111 131.45,111.5 131.02,111.5 130.54,111.99 129.86,111.99 128.81,113.04 126.81,113.04 126.29,112.52 125.81,112.52 125.34,112.99 124.98,112.99 124.48,113.49 124.11,113.49 123.61,113.99 123.25,113.99 122.75,114.49 122.38,114.49 121.88,114.99 121.51,114.99 121.01,115.49 119.63,115.49 119.12,116 118.05,116 117.55,116.5 117.17,116.5 116.65,117.02 116.28,117.02 115.79,117.51 115.47,117.51 114.88,118.1 v2(113.92,118.1)
  BOTTOM w0.109: 163.45,98.82 163.15,98.82 R382.1
  BOTTOM w0.127: 163.45,98.82 164.1,98.82 164.12,98.81 164.42,98.81 164.43,98.82 164.71,98.82 v2(165.07,99.18)
M2F_I2C_SDA: length 72.1
  ART16 w0.114: v2(149.27,97.8) 149.3,97.83 149.3,98.27 150.81,99.78 150.81,102.39 153.14,104.72 161.5,104.72 163.7,102.53 163.7,101 163.87,100.83 163.87,100.67 163.98,100.56 163.98,100.55 164.12,100.42 164.42,100.42 164.85,99.98 v2(165.07,99.98)
  ART18 w0.114: v2(149.27,97.8) 148.57,97.8 143.13,103.25 140.76,103.25 140.26,103.75 140.26,108.5 140.25,108.52 140.25,108.96 137.72,111.49 136.51,111.49 135.88,112.12 135.24,112.12 134.87,112.49 134.28,112.49 134,112.21 133.68,112.21 133.46,112.43 132.83,112.43 132.27,112.99 131.95,112.99 131.68,112.71 131.08,112.71 130.58,113.21 129.88,113.21 129.38,113.71 125.89,113.71 125.42,114.18 125.06,114.18 124.53,114.71 124.22,114.71 124.21,114.71 124.16,114.71 123.66,115.21 123.29,115.21 122.79,115.71 122.43,115.71 121.92,116.21 121.56,116.21 121.06,116.71 120.69,116.71 120.19,117.21 119.67,117.21 119.32,117.56 118.84,117.56 118.42,117.99 118.4,117.99 118.17,118.21 118.09,118.21 117.87,118.44 117.87,120.62 v2(117.39,121.1)
  BOTTOM w0.109: 163.45,99.92 163.42,99.95 R383.1
  BOTTOM w0.127: 163.45,99.92 163.78,99.59 164.68,99.59 v2(165.07,99.98)
MAX10_OVERTEMP: length 249
  TOP w0.109: U23.V5 v2(45.94,168.72)
  ART03 w0.114: v2(45.94,168.72) 46.47,168.18 46.47,167.84 46.74,167.57 47.13,167.57 47.15,167.59 47.5,167.59 48.34,166.74 48.84,166.74 49.11,167.01 53.46,167.01 63.88,156.59 98.93,156.59 99.95,155.57 105.28,155.57 107.95,158.24 116.71,158.24 117.35,157.61 132.1,157.61 133.3,156.41 134.34,156.41 136.11,154.64 176.38,154.64 v2(176.91,155.17)
  ART20 w0.114: v2(176.91,155.17) 178.17,153.9 178.17,151.74 179.8,150.11 179.8,145.8 181.11,144.49 181.11,137.9 182.65,136.36 187.15,136.36 190.38,133.13 190.38,128.39 191.4,127.37 191.4,123.48 191.61,123.27 191.61,122.56 191.61,122.56 191.61,120.88 192.23,120.26 192.23,119.95 193.43,118.75 193.97,118.75 194.37,118.35 194.37,103.82 193.42,102.87 193.42,102.84 193.27,102.69 193.27,86.93 192.71,86.36 191.49,86.36 190.47,85.34 189.36,85.34 188.85,85.85 187.32,85.85 186.56,85.09 185.67,85.09 183.65,83.07 182.66,83.07 182.65,83.06 179.2,83.06 178.18,82.04 177.44,82.04 174.78,84.71 169.67,84.71 169.23,85.15 169.23,87.02 v2(169.07,87.18)
MAX_SCL: length 247.4
  TOP w0.109: U23.N7 v2(41.93,170.32)
  ART03 w0.114: v2(41.93,170.32) 42.32,170.71 44.2,170.71 44.93,169.98 47.11,169.98 47.69,169.4 50.39,169.4 50.55,169.4 50.99,169.84 51.78,169.84 64.01,157.61 99.19,157.61 100.2,156.59 105.03,156.59 107.7,159.26 117.24,159.26 118.11,158.38 132.49,158.38 133.07,157.81 135.15,157.81 136.98,155.98 168.27,155.98 168.58,156.29 175.59,156.29 v2(175.82,156.51)
  ART20 w0.114: v2(169.87,87.98) 169.87,87.94 170.28,87.53 170.28,86.73 170.48,86.53 170.48,86.32 171.07,85.72 175.26,85.72 175.9,85.09 184,85.09 185.62,86.71 189.71,86.71 190.94,87.95 190.94,97.79 190.97,97.82 190.97,101.69 193.29,104.01 193.29,115.44 191.75,116.98 191.75,118.32 190.37,119.71 190.37,123.09 190.43,123.16 190.43,126.91 189.95,127.4 189.25,127.4 188.82,127.82 188.82,130.91 188.61,131.12 188.61,132.07 188.61,132.07 188.61,133.58 187.33,134.86 182.97,134.86 180.15,137.68 180.15,141.77 178.79,143.13 178.79,149.94 177.33,151.4 177.33,153.26 175.83,154.77 175.83,154.85 175.82,154.86 v2(175.82,156.51)
MAX_SDA: length 253.6
  TOP w0.109: U23.N8 v2(41.93,171.12)
  ART03 w0.114: v2(175.74,157.5) 174.98,156.74 168.37,156.74 168.03,156.4 137.17,156.4 134.69,158.88 118.36,158.88 117.47,159.77 108.97,159.77 104.27,164.47 100.97,164.47 94.61,158.12 64.14,158.12 51.94,170.31 50.72,170.31 50.23,169.82 47.96,169.82 47.29,170.49 45.05,170.49 44.04,171.5 42.31,171.5 v2(41.93,171.12)
  ART20 w0.114: v2(169.87,87.18) 169.87,86.57 170.06,86.38 170.06,86.1 170.94,85.22 175.13,85.22 176.35,84 183.54,84 185.84,86.3 190.09,86.3 191.52,87.72 191.52,94.13 191.39,94.26 191.39,101.43 193.71,103.76 193.71,117.41 193.49,117.63 192.61,117.63 192.17,118.07 192.17,118.49 190.85,119.81 190.85,121.7 191.2,122.04 191.2,122.38 191.19,122.39 191.19,123.09 190.85,123.43 190.85,127.25 189.96,128.14 189.96,128.15 189.94,128.17 189.94,132.98 186.98,135.94 182.48,135.94 180.57,137.85 180.57,141.95 179.3,143.22 179.3,150.03 177.75,151.57 177.75,153.43 176.25,154.94 176.25,157 v2(175.74,157.5)
MDC_T: length 18
  TOP w0.109: v2(20.19,19.94) 20.79,19.34 U15.25
  TOP w0.163: v2(32.45,21.34) 33.21,20.57 U16.C2
  ART03 w0.114: v2(20.19,19.94) 20.7,19.43 21.61,19.43 21.84,19.66 21.84,20.95 22.53,21.64 30.3,21.64 31.09,20.85 31.97,20.85 v2(32.45,21.34)
MDIN0: length 13.5
  TOP w0.089: U15.31 20.64,17.19 19.64,17.19 18.81,18.02 18.46,18.02 R256.2 17.49,18 16.17,18 15.91,18.26 15.91,19.54 15.82,19.63 15.4,19.63 15.31,19.54 15.31,18.26 15.06,18 12.99,18 12.71,18.28 12.46,18.52 12.43,18.6 12.31,18.64 J15.2
MDIN1: length 14.7
  TOP w0.089: 11.35,13.08 12.45,14.73 13,14.78 13.68,15.46 17.49,15.46 v2(17.97,14.99) ; v2(22,15.57) 22,15.67 21.52,16.14 U15.34
  ART05 w0.094: v2(22,15.57) 21.25,15.92 21.14,15.88 21.08,15.77 21.08,15.18 20.61,14.71 19.33,14.71 18.52,15.52 18.06,15.52 17.97,15.43 v2(17.97,14.99)
MDIN2: length 12.4
  TOP w0.089: U15.41 20.64,14.19 19.78,14.19 19.38,13.79 19.38,13.26 19.05,12.94 18.46,12.94 v2(17.97,12.45)
  ART05 w0.094: v2(17.97,12.45) 17.97,12.89 17.88,12.98 16.87,12.98 14.3,15.54 13.09,15.54 12.68,15.13 12.68,15.04 12.72,14.94 J15.5
MDIN3: length 16.3
  TOP w0.089: v2(17.97,9.91) 17.52,10.36 13.13,10.36 12.61,10.88 12.53,11.03 12.41,11.07 J15.8 ; U15.43 20.37,13.44 v2(20.17,13.64)
  ART03 w0.094: v2(20.17,13.64) 20.88,13.59 20.98,13.68 20.99,13.81 20.99,14.38 20.89,14.48 19.84,14.48 19.5,14.14 19.5,10.96 18.92,10.38 18.46,10.38 17.99,9.91 v2(17.97,9.91)
MDIO_T: length 15.8
  TOP w0.109: v2(21.29,19.94) 21.29,19.94 U15.24
  TOP w0.163: U16.C1 33.98,21.07 v2(32.45,22.61)
  ART03 w0.114: v2(21.29,19.94) 21.29,20.91 22.4,22.02 31.86,22.02 v2(32.45,22.61)
MDIP0: length 13.4
  TOP w0.089: J15.1 12.77,18.87 12.71,18.81 12.71,18.68 13.1,18.29 14.94,18.29 15.03,18.38 15.03,19.66 15.28,19.92 15.94,19.92 16.19,19.66 16.19,18.38 16.28,18.29 17.46,18.29 R255.2 18.46,18.3 18.93,18.3 19.75,17.48 20.63,17.48 U15.29
MDIP1: length 14.6
  TOP w0.089: v2(17.97,16.26) 17.46,15.75 13.57,15.75 12.87,15.05 12.72,15.04 12.68,15.04 12.61,15.12 12.57,15.27 13.62,16.84 J15.3 ; U15.33 v2(20.17,16.44)
  ART05 w0.094: v2(17.97,16.26) 17.97,15.81 18.06,15.72 18.6,15.72 18.88,15.45 19.04,15.45 19.18,15.3 19.18,15.14 19.41,14.91 19.89,14.91 20,15.02 20.21,15.02 20.32,14.91 20.52,14.91 20.88,15.27 20.88,15.84 20.9,15.86 20.95,15.97 20.91,16.09 v2(20.17,16.44)
MDIP2: length 12.4
  TOP w0.089: v2(17.97,13.72) 18.46,13.22 18.94,13.22 19.09,13.38 19.09,13.91 19.66,14.48 20.63,14.48 U15.39
  ART05 w0.094: J15.4 12.27,15.16 12.45,15.19 13.01,15.75 14.38,15.75 16.95,13.18 17.88,13.18 17.97,13.27 v2(17.97,13.72)
MDIP3: length 16.4
  TOP w0.089: v2(21.98,13.53) 21.77,13.74 U15.42 ; J15.7 12.83,11.28 12.79,11.16 12.84,11.05 13.25,10.64 17.44,10.64 v2(17.97,11.18)
  ART03 w0.094: v2(21.98,13.53) 21.27,13.57 21.18,13.67 21.19,13.8 21.19,14.47 20.98,14.68 19.76,14.68 19.3,14.22 19.3,11.05 18.83,10.58 18.57,10.58 v2(17.97,11.18)
MEM_ADDR_CMD0: length 63.5
  TOP w0.137: CON1.113 128.82,59.69 v2(128.9,59.61)
  ART03 w0.114: v2(111.33,86.6) 111.33,86.15 110.94,85.76 110.94,85.65 110.92,85.63 110.92,85.42
  ART03 w0.135: 110.92,85.42 110.88,85.38 110.88,81.95 110.56,81.63 110.37,81.63 108.32,79.58 108.32,66.2 110.18,64.34 111.3,64.34 111.96,63.68 112.29,62.86 112.29,62.51 112.15,60.85 111.96,60.17 111.96,55.96 112.93,54.99 113.24,54.99 113.51,54.72 114.23,52.41 114.37,52.27 114.65,52.27 115.49,52.36 115.77,52.36 117.86,52.03 118.37,51.93 118.64,51.66 119.02,51.66 119.81,52.15 121.86,54.2 121.86,54.21 121.9,54.25 121.91,54.25 121.92,54.25 122.78,54.25 123.19,53.85 128.62,53.85 129.21,54.44 129.21,54.82 129.22,54.82 129.22,54.85 129.46,55.1 129.77,55.1 130.06,55.39 130.06,55.6 129.93,58.68 129.02,59.59 128.92,59.59 v2(128.9,59.61)
MEM_ADDR_CMD1: length 64.3
  TOP w0.137: v2(130.07,51.99) CON1.108
  ART03 w0.114: 110.11,87.3 110.11,87.31 110.21,87.4 arc(110.32,87.48) 110.46,87.5 111.1,87.5 arc(111.22,87.53) v2(111.33,87.6)
  ART03 w0.135: v2(130.07,51.99) 129.64,51.56 128.78,51.56 127.76,50.55 125.96,50.55 125.39,51.11 124.94,51.11 124.8,50.98 123.7,50.98 123.26,50.55 121.38,50.55 121.08,50.85 120.6,50.85 119.44,49.69 113.62,49.69 112.82,50.49 111.84,50.49 111,51.33 111,54.08 110.5,54.57 110.5,54.78 110.26,55.03 109.84,55.03 109.27,55.6 109.27,60.37 108.79,60.86 108.79,63.5 107.21,65.08 107.21,81.71 107.62,82.12 108.09,82.12 108.32,82.35 108.32,83.68 108.71,84.07 108.71,85.9 110.11,87.3
  BOTTOM w0.137: v2(130.07,51.99) 129.96,52.11 R109.1
MEM_ADDR_CMD2: length 60.8
  TOP w0.137: v2(116.28,59.03) 117.82,60.57 CON1.149
  ART03 w0.135: v2(116.28,59.03) 116.27,59.02 115.5,59.02 115.19,58.7 114.35,58.7 114.09,58.44 112.43,58.44 112.3,58.58 112.3,59.51 112.41,59.62 112.72,59.62 112.88,59.47 112.88,58.95 112.98,58.85 113.23,58.85 113.42,59.04 113.42,59.62 113.59,59.79 113.59,60.43 113.26,60.76 113.26,62.93 111.4,64.79 110.2,64.79 109.6,65.4 109.6,65.65 109.79,65.84 109.79,66.03 109.6,66.22 109.41,66.22 109.22,66.03 109.03,66.03 108.82,66.23 108.82,67.83 108.95,67.96 109.18,67.96 109.32,68.1 109.32,68.37 109.18,68.5 108.95,68.5 108.82,68.64 108.82,68.91 108.95,69.04 109.18,69.04 109.32,69.18 109.32,69.45 109.18,69.58 108.95,69.58 108.72,69.81 108.72,70.18 108.72,70.18 108.72,71.28 108.72,71.29 108.72,72.12 108.72,72.12 108.72,73.04 108.72,73.04 108.72,73.87 108.72,73.88 108.72,74.79 108.72,74.79 108.72,75.63 108.72,75.63 108.72,76.55 108.72,76.55 108.72,77.11 108.95,77.34 111.78,77.34 111.91,77.48 111.91,77.75 111.78,77.88 108.95,77.88 108.82,78.02 108.82,78.29 108.95,78.42 111.78,78.42 111.91,78.56 111.91,78.83 111.78,78.96 108.95,78.96 108.82,79.09 108.82,79.36 108.95,79.5 111.78,79.5 111.91,79.63 111.91,79.9 111.78,80.04 109.96,80.04 109.83,80.17 109.83,80.43 109.96,80.57 111.63,80.57 111.76,80.7 111.76,85.67 v2(112.19,86.1)
MEM_ADDR_CMD3: length 61.5
  TOP w0.137: v2(127.48,51.05) 127.48,51.28 128.57,52.37 CON1.114
  ART03 w0.114: 110.49,85.62 110.53,85.62 110.62,85.71 110.62,85.71 110.85,85.94 110.85,86.39 110.92,86.46 110.92,86.59 arc(110.93,86.7) 110.98,86.8 110.98,86.81 arc(111.12,86.95) 111.3,87 112.1,87 v2(112.19,87.1)
  ART03 w0.135: 110.49,85.62 110.26,85.62 109.93,85.29 109.93,82.96 110.08,82.8 110.08,82.32 109.85,82.09 109.22,82.09 109.04,81.91 109.04,81.38 107.99,80.33 107.99,65.75 109.8,63.93 111.22,63.93 111.58,63.58 111.58,63.32 111.43,63.17 111.43,60.78 111.55,60.66 111.55,56.84 111.42,56.71 110.98,56.71 110.84,56.57 110.84,56.3 110.98,56.17 111.42,56.17 111.55,56.04 111.55,55.73 112.6,54.69 112.6,54.44 112.99,54.04 112.99,51.94 112.99,51.94 112.99,51.5 113.45,51.04 118.58,51.04 118.89,50.72 119.28,50.72 120.9,52.35 125.35,52.35 126.27,51.43 126.27,51.35 126.63,50.98 127.41,50.98 v2(127.48,51.05)
MEM_ADDR_CMD4: length 59.5
  TOP w0.137: 114.58,59.41 115.09,59.79 115.37,59.9 115.82,60.2 116.32,60.69 CON1.155
  ART03 w0.114: U1.CM33 112.89,86.6 arc(112.8,86.47) 112.77,86.32 112.77,86.06 arc(112.76,85.95) 112.73,85.83 112.67,85.7 arc(112.65,85.59) 112.67,85.48 112.73,85.35 arc(112.79,85.07) 112.71,84.8 arc(112.65,84.6) 112.71,84.4 arc(112.79,84.1) 112.71,83.8 arc(112.65,83.6) 112.71,83.4 arc(112.79,83.1) 112.71,82.8 arc(112.65,82.6) 112.71,82.4 arc(112.79,82.1) 112.71,81.81 112.71,81.8 arc(112.65,81.6) 112.71,81.4 arc(112.79,81.1) 112.71,80.81 112.71,80.8 arc(112.67,80.72) 112.65,80.62 arc(112.65,80.61) 112.65,80.6 112.65,79.86 112.73,79.78 112.73,79.76
  ART03 w0.135: 114.58,59.41 114.58,59.23 114.67,59.14 114.86,59.14 114.86,59.14 114.94,59.14 115.02,59.21 115.02,59.71 114.79,59.93 114.79,60.41 114.5,60.7 114.5,64.09 114.17,64.42 112.86,64.42 112.7,64.59 112.7,64.78 112.84,64.91 114.02,64.91 114.5,65.4 114.5,69.89 113.94,70.46 109.66,70.46 109.5,70.62 109.5,70.96 109.63,71.1 112.3,71.1 112.63,71.43 112.63,71.98 112.3,72.31 109.63,72.31 109.5,72.45 109.5,72.71 109.63,72.85 112.32,72.85 112.65,73.18 112.65,73.73 112.32,74.06 109.63,74.06 109.5,74.2 109.5,74.47 109.63,74.6 112.32,74.6 112.65,74.93 112.65,75.48 112.32,75.82 109.63,75.82 109.5,75.95 109.5,76.22 109.64,76.37 112.4,76.37 112.73,76.7 112.73,79.76
MEM_ADDR_CMD5: length 60
  TOP w0.137: 113.89,58.93 113.89,59.36 114.82,60.29 CON1.161
  ART03 w0.114: U1.CK33 112.71,86.94 112.58,86.62 112.58,86.06 arc(112.57,85.98) 112.55,85.91 112.5,85.78 arc(112.46,85.59) 112.5,85.4 112.56,85.27 arc(112.6,85.08) 112.54,84.9 arc(112.46,84.6) 112.54,84.3 arc(112.6,84.1) 112.54,83.9 arc(112.46,83.6) 112.54,83.3 arc(112.6,83.1) 112.54,82.9 112.54,82.89 arc(112.46,82.6) 112.54,82.3 arc(112.6,82.1) 112.54,81.9 arc(112.46,81.6) 112.54,81.3 arc(112.6,81.1) 112.54,80.9 arc(112.49,80.77) 112.46,80.63 arc(112.46,80.62) 112.46,80.6 112.46,79.86 112.39,79.78 112.39,79.76
  ART03 w0.135: 113.89,58.93 114.18,59.65 114.45,59.92 114.45,60.27 114.16,60.56 114.16,63.95 114.03,64.09 112.72,64.09 112.36,64.45 112.36,64.92 112.7,65.25 113.88,65.25 114.16,65.54 114.16,69.76 113.8,70.12 109.52,70.12 109.16,70.48 109.16,71.1 109.49,71.43 112.16,71.43 112.29,71.57 112.29,71.84 112.16,71.97 109.49,71.97 109.16,72.31 109.16,72.85 109.49,73.19 112.18,73.19 112.32,73.32 112.32,73.59 112.18,73.73 109.49,73.73 109.16,74.06 109.16,74.61 109.49,74.94 112.18,74.94 112.32,75.07 112.32,75.34 112.18,75.48 109.49,75.48 109.16,75.81 109.16,76.36 109.5,76.71 112.26,76.71 112.39,76.84 112.39,79.76
MEM_ADDR_CMD6: length 58.6
  TOP w0.137: v2(129.07,58.42) 129.82,59.17 CON1.109
  ART03 w0.114: v2(113.92,86.1) 114.25,85.78 114.25,84.7 114.39,84.55 arc(114.41,84.47) 114.44,84.4 arc(114.52,84.1) 114.44,83.8 arc(114.39,83.6) 114.44,83.4 arc(114.52,83.1) 114.44,82.8 arc(114.39,82.6) 114.44,82.4 arc(114.52,82.1) 114.44,81.81 114.44,81.8 arc(114.39,81.6) 114.44,81.4 arc(114.55,81.12) 114.59,80.83 114.59,80.67 113.88,79.95 113.88,79.76
  ART03 w0.135: 113.88,79.76 113.88,71.78 114.06,71.59 115,71.59 115.63,70.96 115.63,63.29 116.33,62.59 116.35,62.59 116.63,62.31 116.63,61.09 117.39,60.33 117.39,58.56 115.78,56.96 115.78,53.81 116.2,53.39 120.09,53.39 120.95,54.25 120.95,54.69 121.76,55.5 121.99,55.5 122.15,55.65 122.15,55.85 122.43,56.14 122.62,56.14 122.76,56 122.76,55.51 123.12,55.14 123.5,55.14 123.63,55.01 123.63,54.7 123.77,54.57 124.01,54.57 124.17,54.73 124.17,55 124.31,55.14 126.25,55.14 126.48,55.37 126.72,55.37 126.95,55.14 127.4,55.14 127.41,55.14 127.58,55.14 127.9,55.46 127.9,55.75 128.14,56 128.93,56 129.07,56.13 v2(129.07,58.42)
MEM_ADDR_CMD7: length 58.9
  TOP w0.137: v2(129.64,55.56) 129.13,55.05 129.13,54.53 129.57,54.1 CON1.110
  ART03 w0.114: v2(113.92,87.1) 113.92,86.67 113.65,86.4 arc(113.57,86.28) 113.52,86.14 arc(113.52,86.08) 113.53,86.03 113.58,85.92 arc(113.6,85.87) 113.64,85.82 114.01,85.45 arc(114.05,85.41) 114.06,85.35 114.06,84.62 114.07,84.61 114.07,84.58 114.22,84.42 arc(114.25,84.36) 114.28,84.3 arc(114.33,84.1) 114.28,83.9 arc(114.2,83.6) 114.28,83.3 arc(114.33,83.1) 114.28,82.9 114.27,82.89 arc(114.2,82.6) 114.28,82.3 arc(114.33,82.1) 114.28,81.9 114.2,81.76 114.2,81.38 114.26,81.31 114.27,81.31 114.27,81.3 114.28,81.3 114.31,81.16 114.31,80.94 114.26,80.89 114.24,80.86 113.54,80.16 113.54,79.76
  ART03 w0.135: v2(129.64,55.56) 129.45,55.56 128.88,54.99 128.88,54.96 128.88,54.96 128.88,54.61 128.5,54.23 123.56,54.23 122.63,55.16 121.93,55.16 121.29,54.52 121.29,54.1 120.23,53.04 115.71,53.04 115.44,53.31 115.44,56.13 115.31,56.27 114.94,56.27 114.81,56.4 114.81,56.67 114.94,56.81 115.31,56.81 115.44,56.94 115.44,57.1 114.99,57.55 114.99,57.74 115.13,57.88 115.37,57.88 115.71,57.54 115.88,57.54 117.05,58.71 117.05,59.45 116.1,60.4 116.1,61.87 115.29,62.68 115.29,70.82 114.86,71.25 113.78,71.25 113.54,71.5 113.54,79.76
MEM_ADDR_CMD8: length 56.2
  TOP w0.137: CON1.157 115.82,62.79 116.84,63.8 v2(116.85,63.8)
  ART03 w0.135: v2(115.66,86.1) 116.01,86.1 116.13,85.99 116.13,81 115.88,80.75 115.88,80.49 115.97,80.39 116.84,80.39 117.02,80.21 117.02,80.01 116.89,79.88 115.45,79.88 115.31,79.75 115.31,79.46 115.45,79.32 117.61,79.32 117.74,79.19 117.74,78.93 117.62,78.82 115.22,78.82 115.09,78.69 115.09,78.4 115.23,78.27 117.64,78.27 117.78,78.13 117.78,77.86 117.64,77.73 115.25,77.73 115.12,77.59 115.12,77.35 115.28,77.19 117.64,77.19 117.78,77.05 117.78,76.79 117.64,76.65 115.28,76.65 115.14,76.52 115.14,76.27 115.3,76.11 117.64,76.11 117.78,75.98 117.78,75.72 117.64,75.58 115.3,75.58 115.17,75.45 115.17,75.2 115.32,75.04 117.64,75.04 117.78,74.91 117.78,74.64 117.64,74.5 115.3,74.5 115.14,74.34 115.14,74.1 115.27,73.97 116.12,73.97 116.25,73.83 116.25,73.56 116.12,73.43 115.24,73.43 115.12,73.3 115.12,73.02 115.25,72.89 116.67,72.89 116.91,72.65 116.91,63.85 116.86,63.8 v2(116.85,63.8)
MEM_ADDR_CMD9: length 56.5
  TOP w0.137: CON1.143 121.32,60.77 120.75,60.2 v2(119.35,60.2)
  ART03 w0.135: v2(119.35,60.2) 119.23,60.2 118.69,60.74 118.69,61.31 118.54,61.47 118.01,61.47 117.85,61.62 117.85,61.8 117.85,62.43 118.16,62.74 118.16,63.19 117.96,63.4 117.4,63.4 117.27,63.53 117.27,65.45 117.4,65.58 118.46,65.58 118.58,65.71 118.58,65.99 118.46,66.12 117.38,66.12 117.24,66.25 117.24,66.52 117.38,66.66 119.48,66.66 119.63,66.8 119.63,67.08 119.51,67.2 117.38,67.2 117.24,67.33 117.24,67.6 117.38,67.74 119.48,67.74 119.63,67.88 119.63,68.16 119.51,68.27 117.38,68.27 117.24,68.41 117.24,68.68 117.38,68.81 119.48,68.81 119.62,68.95 119.62,69.22 119.48,69.35 117.38,69.35 117.24,69.49 117.24,69.75 117.38,69.89 119.48,69.89 119.62,70.02 119.62,70.29 119.48,70.43 117.4,70.43 117.27,70.56 117.27,72.96 117.4,73.1 117.69,73.1 117.83,73.23 117.83,73.5 117.69,73.64 116.79,73.64 116.66,73.77 116.66,74.03 116.79,74.17 117.88,74.17 118.11,74.4 118.11,79.72 117.96,79.88 117.62,79.88 117.5,80.01 117.5,80.59 117.42,80.67 117.12,80.67 116.94,80.85 116.94,86.97 116.8,87.1 v2(115.66,87.1)
MEM_ADDR_CMD10: length 64
  TOP w0.137: v2(120.89,50.43) 121.07,50.61 CON1.144
  ART03 w0.114: 110.81,87.89 arc(110.66,87.75) 110.46,87.7 110.46,87.7 arc(110.1,87.62) 109.8,87.42
  ART03 w0.135: v2(111.33,88.6) 111.33,88.28 111.24,88.19 arc(110.99,88.09) 110.81,87.9 110.81,87.89 ; 109.8,87.42 108.28,85.9 108.28,84.45 107.72,83.9 107.72,83.16 106.77,82.21 106.77,64.86 107.92,63.7 107.92,60.73 108.25,60.4 108.25,59.65 108.12,59.51 107.22,59.51 107.08,59.38 107.08,59.13 107.22,58.99 107.84,58.99 107.97,58.86 107.97,58.59 107.84,58.45 107.22,58.45 107.08,58.32 107.08,58.02 107.22,57.89 107.79,57.89 107.92,57.75 107.92,57.48 107.79,57.35 107.22,57.35 107.08,57.21 107.08,56.29 107.39,55.98 108.25,55.98 109.52,54.71 109.52,54.56 109.99,54.09 109.99,51.19 110.51,50.67 112.74,49.25 122.02,49.25 122.25,49.48 122.25,49.8 122.06,49.99 120.9,49.99 120.77,50.12 120.77,50.31 v2(120.89,50.43)
MEM_ADDR_CMD11: length 65.8
  TOP w0.137: v2(125.34,59.95) 124.46,59.95 123.82,60.59 CON1.133
  ART03 w0.114: 115.1,90.32 114.53,89.91 arc(114.48,89.86) 114.44,89.81 114.44,89.8 arc(114.22,89.59) 113.93,89.5 113.92,89.5 arc(113.66,89.57) 113.45,89.74 113.37,89.84 arc(113.1,89.99) 112.81,89.9 112.74,89.84 arc(112.73,89.83) 112.72,89.81 112.7,89.78 arc(112.62,89.69) 112.53,89.61 arc(112.48,89.59) 112.42,89.58
  ART03 w0.135: v2(111.33,89.6) 111.42,89.67 arc(111.47,89.7) 111.53,89.7 112.42,89.58 ; v2(125.34,59.95) 125.34,60.24 126.15,61.05 127.37,61.05 127.38,61.06 128.18,61.06 128.69,61.57 128.88,61.57 129.2,61.25 129.4,61.25 129.59,61.44 129.59,61.63 129.27,61.95 129.27,62.14 129.69,62.56 129.69,63.3 129.79,63.4 129.79,64.31 129.99,64.52 131.34,64.52 131.47,64.65 131.47,64.86 131.32,65.02 130.32,65.02 130.21,65.13 130.21,65.36 130.35,65.5 131.47,65.5 131.6,65.63 131.6,65.9 131.47,66.03 130.35,66.03 130.21,66.17 130.21,66.44 130.35,66.57 131.47,66.57 131.6,66.71 131.6,66.98 131.47,67.11 130.35,67.11 130.21,67.25 130.21,67.51 130.32,67.61 130.78,67.61 130.94,67.77 130.94,77.37 127.34,80.96 127.34,87.92 127.12,88.14 126.69,88.14 126.49,88.34 126.49,89.33 126.21,89.61 125.88,89.61 125.63,89.87 125.63,90.8 125.3,91.13 124.94,91.13 124.41,91.67 124.1,91.67 123.62,92.15 123.21,92.15 122.78,92.58 122.4,92.58 121.94,92.12 121.54,92.12 121.03,92.63 120.65,92.63 120.24,93.04 119.78,93.04 119.25,92.51 118.95,92.51 118.44,92 117.96,92 117.5,91.54 117.09,91.54 116.66,91.11 116.33,91.11 115.9,90.68 115.45,90.68 115.1,90.32
MEM_ADDR_CMD12: length 64.3
  TOP w0.137: v2(124.03,49.99) 124.03,53.26 CON1.132
  ART03 w0.114: 112.1,89.2 111.07,89.2
  ART03 w0.135: v2(112.19,89.1) 112.1,89.2 ; 111.07,89.2 110.72,89.55 110.35,89.55 109.98,89.18 109.98,89.15 109.24,87.98 107.25,85.99 106.09,83.7 106.09,64.18 106.37,63.91 106.37,63.37 105.89,62.89 105.89,60.76 106.35,60.3 106.35,55.93 107.57,54.71 107.57,54.42 108,53.99 108,51.76 108.24,51.07 108.67,50.63 112.37,48.32 116.86,47.75 122.3,47.75 122.82,48.27 123.55,49.51 v2(124.03,49.99)
MEM_ADDR_CMD13: length 64
  TOP w0.137: CON1.131 124.32,60.69 124.66,60.35 125.89,60.35 v2(125.97,60.26)
  ART03 w0.114: 114.34,90.72 114.34,89.98 arc(114.3,89.94) 114.28,89.9 114.27,89.89 arc(113.92,89.7) 113.58,89.89 113.54,89.96 arc(113.45,90.07) 113.34,90.16
  ART03 w0.135: 114.34,90.72 114.78,91.16 115.03,91.16 115.41,91.54 115.85,91.54 116.33,92.02 116.69,92.02 117.29,92.63 117.62,92.63 118.08,93.09 118.46,93.09 118.89,93.52 119.2,93.52 119.73,94.06 120.14,94.06 120.65,93.55 121.05,93.55 121.49,93.12 121.99,93.12 122.43,93.55 123.24,93.55 124.15,92.63 124.51,92.63 125.07,92.07 125.42,92.07 125.96,91.54 126.24,91.54 126.49,91.29 126.49,90.42 126.74,90.17 126.95,90.17 127.33,89.79 127.33,88.92 127.63,88.62 127.86,88.62 128.23,88.25 128.23,80.91 131.27,77.87 131.27,71.96 131.41,71.82 131.81,71.82 131.94,71.69 131.94,71.42 131.81,71.28 131.41,71.28 131.27,71.15 131.27,70.88 131.41,70.75 131.81,70.75 131.94,70.61 131.94,70.34 131.81,70.21 131.41,70.21 131.27,70.07 131.27,69.8 131.41,69.67 131.81,69.67 131.94,69.53 131.94,69.27 131.81,69.13 131.41,69.13 131.27,69 131.27,68.73 131.41,68.59 131.81,68.59 131.94,68.46 131.94,68.19 131.81,68.05 131.41,68.05 131.27,67.92 131.27,67.58 131.41,67.45 131.81,67.45 131.94,67.31 131.94,64.5 131.63,64.19 131.63,64.05 131.46,63.88 130.38,63.88 130.13,63.63 130.13,62.92 130.12,62.91 130.12,62.56 130.13,62.56 130.13,60.86 129.99,60.72 127.52,60.72 127.51,60.71 126.51,60.71 126.09,60.3 126.01,60.3 v2(125.97,60.26) ; v2(112.19,90.1) 112.24,90.15 arc(112.29,90.18) 112.36,90.2 113.21,90.2 arc(113.28,90.19) 113.34,90.16
MEM_ADDR_CMD14: length 62.9
  TOP w0.137: CON1.128 125.07,51.9 v2(125.17,51.8)
  ART03 w0.114: 111.94,87.58 111.55,87.2 111.33,87.2 111.04,87.18 110.91,87.03 110.86,86.97 110.85,86.96 110.85,86.96 110.84,86.95 110.82,86.91 110.62,86.71 110.6,86.71 110.55,86.66
  ART03 w0.135: 110.55,86.66 110.06,86.66 109.12,85.72 109.12,85.11 109.22,85.01 109.22,82.98 108.9,82.66 108.9,82.35 108.61,82.05 108.61,81.61 107.65,80.65 107.65,65.32 109.29,63.68 109.29,63.32 109.66,62.96 109.66,60.61 109.77,60.49 110.09,60.49 110.24,60.34 110.24,59.65 110.13,59.54 109.88,59.54 109.71,59.36 109.71,59 109.84,58.87 110.61,58.87 110.74,58.73 110.74,58.46 110.61,58.33 109.84,58.33 109.71,58.19 109.71,57.93 109.84,57.79 110.61,57.79 110.74,57.66 110.74,57.39 110.61,57.25 109.84,57.25 109.71,57.12 109.71,55.78 110.02,55.47 110.95,55.47 111.52,54.9 111.52,54.46 112.01,53.97 112.01,51.33 112.42,50.93 113,50.93 113.8,50.13 119.17,50.13 120.5,51.46 124.66,51.46 125,51.8 v2(125.17,51.8) ; v2(113.06,88.6) 112.76,88.3 112.76,88.08 112.25,87.58 111.94,87.58
MEM_ADDR_CMD15: length 64.4
  TOP w0.137: CON1.126 125.57,53.3 125.57,51.61 125.12,51.16 v2(125.12,50.67)
  ART03 w0.114: 112.02,88.66 111.68,89 111.41,89 arc(111.16,88.97) 110.98,88.81
  ART03 w0.135: v2(113.06,89.6) 112.7,89.24 112.7,88.99 112.37,88.66 112.02,88.66 ; v2(125.12,50.67) 124.97,50.52 123.87,50.52 122.25,48.89 112.44,48.89 109.58,50.69 109.01,51.26 109.01,52.48 108.78,52.71 108.78,54.21 108.65,54.34 108.65,54.6 108.23,55.02 107.82,55.02 106.73,56.11 106.73,59.51 107.21,59.99 107.21,60.37 106.91,60.68 106.91,63.93 106.43,64.41 106.43,83.62 107.52,85.83 110.01,88.32 arc(110.21,88.46) 110.46,88.5 110.47,88.5 arc(110.76,88.59) 110.98,88.8 110.98,88.81
MEM_ADDR_CMD16: length 62.3
  TOP w0.137: CON1.127 125.32,62.81 v2(125.35,62.84)
  ART03 w0.114: v2(113.92,89.1) 114.13,89.31 114.33,89.31 114.43,89.2 115.06,89.2 115.34,89.48 115.49,89.48 115.5,89.49 115.82,89.49 115.82,89.48 115.93,89.48 116.29,89.11
  ART03 w0.135: 116.29,89.11 116.7,89.11 117.17,88.65 117.6,88.65 118.12,89.16 118.51,89.16 118.96,89.61 119.23,89.61 119.71,90.09 120.19,90.09 120.67,89.61 120.98,89.61 121.51,89.08 121.94,89.08 122.43,89.56 122.81,89.56 123.21,89.15 123.21,88.85 123.9,88.17 123.9,86.92 124.31,86.51 124.54,86.51 124.75,86.3 124.75,81.33 125.89,80.19 126.37,80.19 126.98,79.58 126.98,79.39 126.86,79.27 126.86,79.08 127.05,78.89 127.24,78.89 127.36,79.01 127.55,79.01 128.42,78.14 128.42,75.01 128.59,74.84 129.05,74.84 129.19,74.69 129.19,68.97 129.19,68.97 129.19,67.8 129.04,67.65 125.65,67.65 125.52,67.51 125.52,67.29 125.65,67.16 129.05,67.16 129.19,67.02 129.19,66.83 129.05,66.7 125.63,66.7 125.49,66.56 125.49,66.37 125.63,66.24 128.37,66.24 128.5,66.1 128.5,65.91 128.35,65.76 125.62,65.76 125.49,65.63 125.49,65.39 125.63,65.26 127.17,65.26 127.55,64.88 127.55,64.28 127.29,64.02 126.84,64.02 126.71,63.89 126.71,63.35 126.52,63.16 126.14,63.16 125.85,62.86 125.37,62.86 v2(125.35,62.84)
MEM_ADDR_CMD17: length 64
  TOP w0.137: v2(126.74,52.15) 126.57,52.32 CON1.122
  ART03 w0.135: v2(113.92,90.1) 113.51,90.98 113.51,91.29 113.73,91.5 114.15,91.69 115.29,92.4 117.25,93.5 118.05,94 119.83,95.05 120.08,95.05 120.95,94.51 121.82,94.06 123.57,94.06 124.79,93.46 125.24,93.06 126.55,92.31 127.03,92.09 127.38,91.74 127.38,90.88 127.58,90.68 127.81,90.68 128.22,90.27 128.22,89.31 128.42,89.1 128.8,89.1 129.05,88.85 129.05,80.87 132.28,77.65 132.28,74.58 132.3,74.57 132.3,73.28 132.28,73.27 132.28,64.36 131.96,64.05 131.96,62.8 131.54,62.38 131.19,60.68 130.87,60.37 130.87,56.26 130.99,54.84 130.99,54.48 130.92,54.29 130.77,54.14 130.03,53.51 127.68,51.66 127.29,51.66 v2(126.74,52.15)
MEM_ADDR_CMD18: length 63
  TOP w0.137: v2(125.35,63.6) 125.35,63.59 125.82,63.13 CON1.125
  ART03 w0.135: v2(125.35,63.6) 125.35,63.59 125.35,63.42 125.48,63.29 125.69,63.29 125.79,63.39 125.79,64.23 125.93,64.36 126.92,64.36 127.1,64.54 127.1,64.79 126.97,64.92 125.29,64.92 125.16,65.06 125.16,67.77 125.37,67.98 128.72,67.98 128.85,68.12 128.85,68.31 128.72,68.45 125.29,68.45 125.16,68.58 125.16,68.84 125.29,68.98 128.72,68.98 128.86,69.11 128.86,74.4 128.76,74.5 128.29,74.5 128.08,74.71 128.08,77.94 127.59,78.43 127.3,78.43 127.12,78.26 127.12,74.6 127,74.47 126.77,74.47 126.65,74.59 126.65,78.81 126.41,79.04 126.41,79.6 126.24,79.78 125.82,79.78 124.97,80.63 124.13,80.63 123.89,80.86 123.89,85.89 123.55,86.23 123.55,87.81 122.76,88.6 122.43,88.6 121.97,88.14 121.59,88.14 121.18,88.55 120.77,88.55 120.29,89.03 119.76,89.03 119.28,88.55 119,88.55 118.55,88.1 118.04,88.1 117.55,87.61 117.14,87.61 116.66,88.09 116.43,88.09 115.92,88.6 v2(114.79,88.6)
MEM_ADDR_CMD19: length 64
  TOP w0.137: CON1.121 126.82,62.54 127.01,62.73 v2(127.03,62.73)
  ART03 w0.114: v2(114.79,89.6) 115.08,89.89 115.2,89.89 115.42,89.68 116.05,89.68 116.36,89.99 116.68,89.99 116.73,89.94 116.91,89.94
  ART03 w0.135: 116.91,89.94 117.24,89.61 117.47,89.61 117.98,90.12 118.51,90.12 118.92,90.52 119.17,90.52 119.71,91.06 120.16,91.06 120.62,90.6 121.03,90.6 121.46,90.17 121.92,90.17 122.27,90.52 122.78,90.52 123.29,90.02 123.67,90.02 123.85,89.84 123.85,88.95 124.2,88.59 124.43,88.59 124.76,88.26 124.76,87.45 125.02,87.2 125.4,87.2 125.62,86.98 125.62,80.96 126.11,80.47 126.57,80.47 128.8,78.24 128.8,75.34 128.91,75.22 129.73,75.22 129.87,75.36 129.87,75.64 129.74,75.77 129.34,75.77 129.21,75.9 129.21,77.39 129.36,77.55 129.72,77.55 130.26,77.01 130.26,74.96 130.13,74.83 129.67,74.83 129.54,74.69 129.54,74.44 129.67,74.31 130.13,74.31 130.26,74.17 130.26,73.9 130.13,73.77 129.67,73.77 129.54,73.63 129.54,73.37 129.67,73.23 130.13,73.23 130.26,73.1 130.26,72.83 130.13,72.69 129.67,72.69 129.54,72.56 129.54,72.29 129.67,72.15 130.13,72.15 130.26,72.02 130.26,71.75 130.13,71.62 129.67,71.62 129.54,71.48 129.54,71.21 129.67,71.08 130.13,71.08 130.26,70.94 130.26,70.67 130.13,70.54 129.67,70.54 129.54,70.4 129.54,70.13 129.67,70 130.13,70 130.26,69.87 130.26,69.6 130.13,69.46 129.67,69.46 129.54,69.33 129.54,69.06 129.67,68.92 130.13,68.92 130.26,68.79 130.26,68.52 130.12,68.38 129.67,68.38 129.54,68.24 129.54,66.5 129.39,66.34 129.08,66.34 128.93,66.19 128.93,65.96 129.08,65.81 129.4,65.81 129.54,65.68 129.54,65.05 129.37,64.88 128.02,64.88 127.89,64.74 127.89,64.5 128.02,64.36 128.55,64.36 128.65,64.26 128.65,63.98 128.33,63.66 128.33,62.16 127.9,61.73 127.39,61.73 127.25,61.87 127.25,62.35 127.45,62.56 127.45,62.86 127.51,62.91 127.51,63.4 127.41,63.49 127.41,63.49 127.37,63.54 127.18,63.54 127.05,63.4 127.05,62.75 v2(127.03,62.73)
MEM_ADDR_CMD20: length 59.3
  TOP w0.137: CON1.146 118.57,52.35 v2(118.8,52.12)
  ART03 w0.114: v2(115.66,89.1) 115.56,89 114.43,89 114.12,88.7 113.79,88.7 113.54,88.44 113.54,86.74 113.46,86.52 113.43,86.44 113.33,86.26 113.31,86.11 113.31,85.97 113.34,85.87 113.43,85.78 113.44,85.76 113.49,85.71 113.49,85.24
  ART03 w0.135: v2(118.8,52.12) 118.8,52.57 118.67,52.7 115,52.7 114.78,52.93 114.78,54.21 114.55,54.43 114.55,54.56 114.42,54.69 114.06,54.69 113.93,54.83 113.93,55.09 114.06,55.23 114.37,55.23 114.5,55.36 114.5,55.77 114.37,55.9 112.75,55.9 112.3,56.35 112.3,57.97 112.44,58.11 112.7,58.11 112.83,57.97 112.83,56.47 112.97,56.34 113.21,56.34 113.37,56.5 113.37,57.97 113.5,58.11 113.77,58.11 113.91,57.97 113.91,56.64 114.04,56.51 114.32,56.51 114.45,56.64 114.45,58.21 114.58,58.34 115.36,58.34 115.62,58.6 116.46,58.6 116.71,58.85 116.71,59.31 115.75,60.28 115.75,61.75 114.94,62.55 114.94,70.67 114.7,70.92 113.34,70.92 113.15,71.1 113.15,76.51 113.17,76.52 113.17,80.81 113.49,81.13 113.49,85.24
MEM_ADDR_CMD21: length 62.3
  TOP w0.137: v2(127.51,52.09) 127.43,52.09 127.07,52.45 CON1.120
  ART03 w0.135: v2(127.51,52.09) 130.15,54.56 130.15,54.74 130.46,55.06 130.46,55.96 130.28,58.83 129.07,60.03 128.83,60.03 127.68,59.84 127.1,59.84 125.45,59.53 125.16,59.53 124.9,59.78 124.9,60.28 126.01,61.39 127.23,61.39 127.24,61.4 128.04,61.4 128.68,62.03 128.68,62.92 128.96,63.2 129.12,63.2 129.44,63.52 129.44,63.54 129.45,63.55 129.45,64.45 129.88,64.87 129.88,67.65 130.6,68.37 130.6,77.15 126.85,80.89 126.73,81.07 126.48,81.52 126.48,87.08 126.38,87.39 125.93,87.7 125.88,87.7 125.65,87.94 125.65,88.51 125.51,88.89 125.36,88.99 125.35,89 125.34,89 124.99,89.23 124.85,89.37 124.74,89.61 124.74,90.12 124.67,90.32 124.49,90.49 123.64,90.98 123.51,91.03 122.86,91.52 122.43,91.52 121.84,91.19 121.51,91.19 120.16,92 119.85,92 118.42,91.18 116.9,90.35 116.69,90.2 116.36,90.2 116.07,90.18 v2(115.66,90.1)
MEM_ADDR_CMD22: length 57
  TOP w0.137: CON1.119 127.32,60.72 127.25,60.65 v2(127.25,59.07)
  ART03 w0.135: v2(118.26,87.6) 119.35,87.6 119.81,88.06 120.27,88.06 120.71,87.62 120.97,87.62 121.5,87.08 121.98,87.08 122.17,86.89 122.17,80.95 123.29,79.83 124.79,79.83 125.2,79.42 125.2,78.25 125.44,78.01 125.44,77.82 125.2,77.58 125.2,77.37 125.4,77.17 125.4,76.96 125.2,76.76 125.2,76.35 125.3,76.25 125.49,76.25 125.63,76.1 125.63,75.91 125.51,75.79 125.32,75.79 125.2,75.67 125.2,75.3 125.37,75.13 125.37,74.8 125.2,74.62 125.2,73.86 125.38,73.68 128.04,73.68 128.18,73.54 128.18,73.29 128.09,73.2 124.66,73.2 124.53,73.07 124.53,72.8 124.63,72.7 126.91,72.7 127.06,72.55 127.06,70.02 126.69,69.65 124.61,69.65 124.48,69.52 124.48,64.33 124.05,63.91 124.05,62.05 124.2,61.91 124.2,61.71 124.05,61.57 123.55,61.57 123.45,61.47 123.45,61.21 123.59,61.07 123.89,61.07 124.23,60.74 124.23,59.63 123.92,59.33 123.92,58.75 124.37,58.3 124.58,58.3 124.69,58.41 124.69,58.72 124.82,58.85 126.82,58.85 127.02,58.65 127.02,58.37 127.34,58.05 127.57,58.05 127.71,58.19 127.71,58.85 127.49,59.07 v2(127.25,59.07)
MEM_ADDR_CMD23: length 56.4
  TOP w0.137: CON1.158 115.57,54.38 v2(117.04,55.85)
  ART03 w0.135: v2(119.12,86.1) 118.74,85.72 118.74,85.48 arc(118.72,85.42) 118.69,85.35 arc(118.62,85.1) 118.69,84.85 arc(118.75,84.6) 118.69,84.35 arc(118.62,84.1) 118.69,83.85 arc(118.75,83.6) 118.69,83.35 arc(118.62,83.1) 118.69,82.85 arc(118.75,82.6) 118.69,82.35 arc(118.62,82.1) 118.69,81.85 arc(118.75,81.6) 118.69,81.35 arc(118.62,81.1) 118.69,80.85 118.69,80.85 118.69,80.54 120.3,78.93 120.3,77.78 120.44,77.65 121.51,77.65 121.65,77.51 121.65,77.23 121.51,77.1 120.44,77.1 120.3,76.96 120.3,76.69 120.44,76.56 121.51,76.56 121.65,76.42 121.65,76.15 121.51,76.02 120.44,76.02 120.3,75.89 120.3,75.62 120.44,75.48 121.51,75.48 121.65,75.35 121.65,74.86 121.46,74.68 120.58,74.68 120.44,74.54 120.44,74.28 120.58,74.14 122.32,74.14 122.44,74.02 122.44,73.74 122.3,73.6 120.44,73.6 120.3,73.47 120.3,65.47 120.11,65.28 119.38,65.28 119.01,64.91 118.09,64.91 117.96,64.77 117.96,64.5 118.09,64.36 118.97,64.36 119.08,64.26 119.08,64.01 118.95,63.88 118.51,63.88 118.39,63.75 118.39,63.46 118.52,63.32 118.97,63.32 119.07,63.22 119.07,62.58 118.89,62.41 118.43,62.41 118.31,62.28 118.31,61.96 118.45,61.82 119.73,61.82 119.86,61.69 119.86,61.43 119.73,61.29 119.23,61.29 119.1,61.16 119.1,60.91 119.25,60.75 119.84,60.75 119.99,60.6 119.99,59.03 119.83,58.88 118.75,58.88 118.62,58.74 118.62,58.46 118.75,58.33 119.31,58.33 119.45,58.19 119.45,57.95 119.29,57.79 118.35,57.79 117.75,57.19 117.75,56.23 117.61,56.09 117.61,55.89 117.45,55.73 117.17,55.73 v2(117.04,55.85)
MEM_ADDR_CMD24: length 56.6
  TOP w0.137: CON1.151 117.32,62.33 117.09,62.56 117.09,63.25 v2(117.7,63.85)
  ART03 w0.135: v2(119.12,87.1) 119.1,87.12 118.11,87.12 117.83,86.84 117.83,81.4 118.08,81.15 118.08,80.43 118.45,80.06 118.45,79.63 118.59,79.5 119.22,79.5 119.35,79.37 119.35,79.12 119.19,78.96 118.59,78.96 118.45,78.83 118.45,78.56 118.59,78.43 119.83,78.43 119.97,78.3 119.97,78.03 119.83,77.89 118.59,77.89 118.45,77.76 118.45,77.5 118.59,77.36 119.83,77.36 119.97,77.23 119.97,76.96 119.83,76.83 118.59,76.83 118.45,76.7 118.45,76.43 118.59,76.29 119.83,76.29 119.97,76.16 119.97,75.89 119.83,75.75 118.59,75.75 118.45,75.62 118.45,75.35 118.59,75.21 120.03,75.21 120.17,75.08 120.17,74.84 120.01,74.68 118.59,74.68 118.45,74.54 118.45,74.27 118.59,74.14 119.83,74.14 119.97,74 119.97,73.73 119.83,73.6 118.33,73.6 118.21,73.48 118.21,73.18 118.33,73.06 119.83,73.06 119.97,72.93 119.97,72.66 119.83,72.53 117.76,72.53 117.62,72.4 117.62,72.15 117.78,71.99 119.83,71.99 119.97,71.86 119.97,71.59 119.83,71.45 117.76,71.45 117.62,71.32 117.62,71.07 117.78,70.91 119.83,70.91 119.97,70.78 119.97,65.74 119.86,65.63 119.58,65.63 119.43,65.79 119.43,66.17 119.3,66.29 119.05,66.29 118.92,66.16 118.92,65.45 118.71,65.24 117.74,65.24 117.61,65.11 117.61,63.95 v2(117.7,63.85)
MEM_ADDR_CMD25: length 54.8
  TOP w0.137: CON1.156 116.07,54.12 116.91,54.96 v2(117.04,54.96)
  ART03 w0.114: 119.79,80.49 119.79,81.17 119.69,81.27 arc(119.67,81.33) 119.64,81.4 arc(119.58,81.6) 119.64,81.8 119.64,81.81 arc(119.72,82.1) 119.64,82.4 arc(119.58,82.6) 119.64,82.8 arc(119.72,83.1) 119.64,83.4 arc(119.58,83.6) 119.64,83.8 arc(119.72,84.1) 119.64,84.4 arc(119.58,84.6) 119.64,84.8 arc(119.72,85.1) 119.64,85.4 arc(119.58,85.6) 119.64,85.8 arc(119.7,85.95) 119.72,86.11 119.72,86.33 v2(119.99,86.6)
  ART03 w0.135: v2(117.04,54.96) 117.04,55.22 117.18,55.35 117.37,55.35 117.42,55.29 117.68,55.29 117.8,55.42 118.31,55.42 118.41,55.52 118.41,55.66 118.46,55.72 118.46,56.2 118.6,56.34 119.05,56.34 119.17,56.21 119.17,55.83 119.27,55.74 119.42,55.74 119.99,56.32 119.99,56.51 119.86,56.64 118.69,56.64 118.56,56.78 118.56,56.97 118.71,57.12 120.84,57.12 120.98,57.25 120.98,57.65 120.67,57.96 120.67,61.86 119.75,62.77 119.75,63.92 119.89,64.06 120.57,64.06 120.72,64.21 120.72,64.79 120.86,64.92 122.97,64.92 123.13,65.08 123.13,65.3 122.97,65.45 121.11,65.45 120.98,65.58 120.98,65.83 121.11,65.96 122.9,65.96 123.04,66.1 123.04,66.29 122.9,66.42 121.15,66.42 120.98,66.6 120.98,69.51 121.11,69.65 122.85,69.65 123.13,69.93 123.13,78.21 122.98,78.36 121.19,78.36 121.09,78.46 121.09,79.19 119.79,80.49
MEM_ADDR_CMD26: length 55.5
  TOP w0.137: CON1.152 117.07,54.38 117.47,54.78 117.47,55.34 v2(118.03,55.91)
  ART03 w0.114: 119.42,80.33 119.42,80.79 arc(119.44,80.84) 119.47,80.89 119.47,80.9 arc(119.53,81.1) 119.47,81.3 arc(119.39,81.6) 119.47,81.9 arc(119.53,82.1) 119.47,82.3 arc(119.39,82.6) 119.47,82.89 119.47,82.9 arc(119.53,83.1) 119.47,83.3 arc(119.39,83.6) 119.47,83.9 arc(119.53,84.1) 119.47,84.3 arc(119.39,84.6) 119.47,84.9 arc(119.53,85.1) 119.47,85.3 arc(119.39,85.6) 119.47,85.9 arc(119.53,86.1) 119.47,86.3 arc(119.39,86.6) 119.47,86.9 arc(119.54,86.99) 119.62,87.07 119.62,87.24 v2(119.99,87.6)
  ART03 w0.135: 119.42,80.33 120.75,79 120.75,78.14 120.88,78 122.57,78 122.78,77.8 122.78,76.35 122.59,76.17 122.59,75.81 122.78,75.63 122.78,73.4 122.6,73.23 120.75,73.23 120.64,73.12 120.64,72.86 120.78,72.72 122.66,72.72 122.79,72.59 122.79,72.32 122.66,72.18 120.78,72.18 120.64,72.05 120.64,71.78 120.78,71.65 122.66,71.65 122.79,71.51 122.79,71.24 122.66,71.11 120.78,71.11 120.64,70.97 120.64,70.7 120.78,70.57 122.66,70.57 122.79,70.43 122.79,70.17 122.66,70.03 120.78,70.03 120.64,69.9 120.64,65.32 120.26,64.94 119.55,64.94 119.41,64.8 119.41,62.63 120.33,61.71 120.33,58.66 120.19,58.52 119.99,58.52 119.86,58.39 119.86,58.12 119.99,57.98 120.19,57.98 120.33,57.85 120.33,57.59 120.19,57.45 118.54,57.45 118.09,57 118.09,55.96 v2(118.03,55.91)
MEM_ADDR_CMD27: length 55.8
  TOP w0.137: v2(128.32,54.71) 128.07,54.46 CON1.116
  ART03 w0.135: v2(120.85,86.1) 121.17,86.1 121.28,85.99 121.28,81.3 123.09,79.5 124.64,79.5 124.86,79.28 124.86,74.03 124.55,73.71 124.28,73.71 124.14,73.57 124.14,72.5 124.28,72.36 126.58,72.36 126.72,72.23 126.72,71.96 126.72,71.95 126.72,70.16 126.55,69.99 124.4,69.99 124.14,69.73 124.14,64.47 123.71,64.05 123.71,62.4 123.11,61.8 123.11,60.96 123.34,60.73 123.75,60.73 123.89,60.6 123.89,59.88 123.58,59.58 123.58,58.61 124.23,57.96 124.72,57.96 125.26,58.5 126.38,58.5 127.38,57.5 128.23,57.5 128.37,57.36 128.37,57.09 128.23,56.96 127.26,56.96 127.12,56.82 127.12,56.14 127.26,56.01 127.53,56.01 127.66,56.13 127.66,56.38 127.79,56.51 128.47,56.51 128.73,56.78 128.73,58.16 128.64,58.24 128.64,58.79 128.78,58.93 129.21,58.93 129.56,58.57 129.56,56.15 128.32,54.91 v2(128.32,54.71)
MEM_ADDR_CMD28: length 54.9
  TOP w0.137: CON1.150 117.57,54.32 117.98,54.74 v2(117.98,54.99)
  ART03 w0.114: 120.18,80.57 120.18,81.24 120.34,81.4 arc(120.39,81.6) 120.34,81.8 120.34,81.81 arc(120.26,82.1) 120.34,82.4 arc(120.39,82.6) 120.34,82.8 arc(120.26,83.1) 120.34,83.4 arc(120.39,83.6) 120.34,83.8 arc(120.26,84.1) 120.34,84.4 arc(120.39,84.6) 120.34,84.8 arc(120.26,85.1) 120.34,85.4 arc(120.39,85.6) 120.34,85.8 120.24,85.9 120.24,86.31 120.37,86.44 120.37,86.62 v2(120.85,87.1)
  ART03 w0.135: 120.18,80.57 120.8,79.96 120.99,79.96 121.17,80.14 121.41,80.14 121.55,80 121.55,79.76 121.37,79.58 121.37,79.38 121.42,79.33 121.42,78.85 121.56,78.71 121.74,78.71 121.89,78.87 121.89,79.09 122.03,79.22 122.27,79.22 122.4,79.09 122.4,78.87 122.55,78.71 123.33,78.71 123.47,78.58 123.47,76.33 123.73,76.07 123.73,75.88 123.47,75.61 123.47,75.31 123.62,75.16 123.62,74.9 123.47,74.75 123.47,69.39 123.33,69.25 121.43,69.25 121.32,69.13 121.32,68.83 121.43,68.71 123.33,68.71 123.47,68.58 123.47,68.31 123.33,68.18 121.43,68.18 121.32,68.06 121.32,66.97 121.52,66.76 123.33,66.76 123.47,66.62 123.47,64.76 123.23,64.53 121.27,64.53 121.16,64.41 121.16,63.9 120.98,63.72 120.22,63.72 120.09,63.58 120.09,62.91 121,62 121,59.24 121.14,59.11 121.33,59.11 121.46,58.98 121.46,58.71 121.33,58.57 121.14,58.57 121,58.44 121,58.18 121.14,58.04 122.24,58.04 122.37,57.91 122.37,57.64 122.24,57.5 121.71,57.5 119.71,55.5 119.71,55.12 119.57,54.99 v2(117.98,54.99)
MEM_ADDR_CMD29: length 54
  TOP w0.137: v2(120.57,63.3) 120.55,63.27 119.83,63.27 118.82,62.25 CON1.145
  ART03 w0.114: v2(121.72,86.6) 120.8,86.6 120.56,86.36 arc(120.45,86.14) 120.5,85.9 arc(120.58,85.6) 120.5,85.3 arc(120.45,85.1) 120.5,84.9 arc(120.58,84.6) 120.5,84.3 arc(120.45,84.1) 120.5,83.9 arc(120.58,83.6) 120.5,83.3 arc(120.45,83.1) 120.5,82.9 120.5,82.89 arc(120.58,82.6) 120.5,82.3 arc(120.45,82.1) 120.5,81.9 arc(120.56,81.75) 120.58,81.59 120.58,81.39 120.52,81.33 120.45,81.15 120.45,80.95 120.77,80.62
  ART03 w0.135: 120.77,80.62 121.43,80.62 122.88,79.16 124.36,79.16 124.52,78.99 124.52,74.17 124.42,74.07 123.9,74.07 123.8,73.97 123.8,72.08 123.94,71.94 126.25,71.94 126.39,71.81 126.39,71.54 126.25,71.4 123.94,71.4 123.8,71.27 123.8,71 123.94,70.87 126.25,70.87 126.39,70.73 126.39,70.46 126.25,70.33 123.94,70.33 123.8,70.19 123.8,67.87 123.63,67.69 121.79,67.69 121.65,67.55 121.65,67.27 121.79,67.13 123.62,67.13 123.8,66.95 123.8,64.62 123.37,64.19 122.86,64.19 122.61,63.94 122.61,63.13 122.48,62.99 122.29,62.99 122.15,63.14 122.15,63.19 121.99,63.34 121.17,63.34 121.01,63.19 121.01,62.93 121.51,62.43 121.84,62.43 121.94,62.33 121.94,60.78 121.84,60.68 121.49,60.68 121.36,60.81 121.36,62.12 120.57,62.91 v2(120.57,63.3)
MEM_ADDR_CMD30: length 54.2
  TOP w0.137: v2(127.91,59.33) 128.32,59.74 CON1.115
  ART03 w0.135: v2(121.72,87.6) 122.73,87.6 122.99,87.35 122.99,80.77 123.56,80.19 124.96,80.19 125.61,79.55 125.61,78.9 125.74,78.76 126.18,78.76 126.31,78.64 126.31,74.26 126.45,74.13 128.38,74.13 128.52,73.99 128.52,69.73 128.38,69.6 128.1,69.6 127.96,69.73 127.96,72.69 127.83,72.82 127.59,72.82 127.43,72.66 127.43,69.45 127.29,69.31 124.95,69.31 124.82,69.18 124.82,64.46 124.93,64.35 124.93,62.45 125.06,62.31 126.63,62.31 126.77,62.18 126.77,61.99 126.6,61.82 124.7,61.82 124.56,61.69 124.56,61.5 124.7,61.37 125.07,61.37 125.17,61.26 125.17,61.06 125.02,60.91 124.67,60.91 124.56,60.81 124.56,59.32 124.7,59.19 126.77,59.19 127.08,59.49 127.75,59.49 v2(127.91,59.33)
MEM_CLKN: length 59.2
  TOP w0.137: 122.1,59.77 122.32,59.99 CON1.139
  ART03 w0.114: U1.CK35 114.79,87.59 arc(114.85,87.36) 115,87.18 arc(115.02,87.17) 115.04,87.15 arc(115.05,87.15) 115.06,87.14 115.08,87.13 arc(115.08,87.13) 115.09,87.12 115.11,87.11 arc(115.14,87.1) 115.16,87.08 115.18,87.06 arc(115.34,86.86) 115.39,86.6 arc(115.37,86.43) 115.3,86.28 arc(115.27,86.22) 115.26,86.17 arc(115.26,86.03) 115.31,85.9 arc(115.39,85.6) 115.31,85.3 arc(115.25,85.1) 115.31,84.9 arc(115.39,84.6) 115.31,84.3 arc(115.25,84.1) 115.31,83.9 arc(115.39,83.6) 115.31,83.3 arc(115.25,83.1) 115.31,82.9 115.31,82.89 arc(115.39,82.6) 115.31,82.3 arc(115.25,82.1) 115.31,81.9 arc(115.39,81.6) 115.31,81.3 arc(115.27,81.23) 115.26,81.15 115.26,80.36 114.78,79.88 114.78,79.78 114.76,79.76
  ART03 w0.135: 114.76,79.76 114.65,79.65 114.65,72.69 114.95,72.39 115.67,72.39 116.41,71.65 116.41,63.61 116.66,63.36 116.67,63.36 117.41,62.63 117.41,62.52 117.41,61.41 118.17,60.65 118.17,58.23 116.56,56.62 116.56,54.32 116.7,54.18 116.95,54.18 117.15,54.39 117.41,54.39 117.61,54.18 117.86,54.18 118.06,54.39 118.32,54.39 118.52,54.18 118.77,54.18 118.97,54.39 119.23,54.39 119.43,54.18 119.77,54.18 120.16,54.57 120.16,55 120.34,55.18 120.34,55.47 120.52,55.65 120.8,55.65 120.98,55.83 120.98,56.11 121.16,56.29 121.44,56.29 122.2,57.05 122.98,57.05 123.55,56.48 123.55,56.19 123.69,56.06 124.06,56.06 124.34,56.34 126.19,56.34 126.33,56.48 126.33,57.44 126.04,57.73 125.66,57.73 125.42,57.48 125.42,57.1 125.09,56.77 124.28,56.77 123.93,57.13 123.64,57.13 123.46,57.31 123.46,57.59 123.28,57.77 123,57.77 122.82,57.95 122.82,58.23 122.35,58.7 122.35,59.51 122.1,59.77
MEM_CLKP: length 59
  TOP w0.137: CON1.137 122.82,59.88 122.94,59.77
  ART03 w0.114: U1.CM35 114.79,86.87 arc(114.81,86.93) 114.85,86.97 arc(114.9,86.99) 114.96,86.98 114.99,86.96 arc(114.99,86.96) 115,86.96 115.02,86.95 arc(115.03,86.94) 115.04,86.93 115.05,86.92 arc(115.16,86.78) 115.2,86.6 arc(115.19,86.48) 115.14,86.38 arc(115.1,86.3) 115.07,86.21 arc(115.07,86) 115.14,85.8 arc(115.2,85.6) 115.14,85.4 arc(115.06,85.1) 115.14,84.8 arc(115.2,84.6) 115.14,84.4 arc(115.06,84.1) 115.14,83.8 arc(115.2,83.6) 115.14,83.4 arc(115.06,83.1) 115.14,82.8 arc(115.2,82.6) 115.14,82.4 arc(115.06,82.1) 115.14,81.81 115.14,81.8 arc(115.2,81.6) 115.14,81.4 arc(115.09,81.29) 115.07,81.17 arc(115.06,81.16) 115.06,81.15 115.06,80.44 114.64,80.02 114.54,80.02 114.32,79.79 114.32,79.76
  ART03 w0.135: 122.94,59.77 122.69,59.52 122.69,58.84 124.42,57.11 124.95,57.11 125.08,57.24 125.08,57.62 125.52,58.06 126.18,58.06 126.67,57.58 126.67,56.34 126.33,56.01 124.48,56.01 124.2,55.72 123.55,55.72 123.21,56.05 123.21,56.34 122.84,56.71 122.34,56.71 120.5,54.86 120.5,54.43 119.91,53.85 116.56,53.85 116.22,54.18 116.22,56.76 117.83,58.37 117.83,60.51 117.07,61.27 117.07,62.49 116.53,63.03 116.52,63.03 116.07,63.47 116.07,71.51 115.53,72.05 114.81,72.05 114.32,72.55 114.32,79.76
MEM_CONFIG0: length 461.4
  TOP w0.109: CON1.134 123.57,49.12 v2(123.8,48.89)
  ART18 w0.114: v2(123.8,48.89) 123.5,49.19 90.09,49.19 89.79,48.9 88.03,48.9 88.03,48.9 87.7,48.9 87.35,49.25 80.72,49.25 80.16,49.81 78.79,49.81 78.51,49.53 70.99,49.53 69.93,48.47 62.64,48.47 62.53,48.36 55.68,48.36 55.32,48.72 47.93,48.72 46.89,49.76 45.09,49.76 44.4,50.44 44.4,54.57 43.87,55.1 43.87,57.48 42.98,58.37 42.98,65.75 43.01,65.77 43.01,66.15 42.98,66.18 42.98,83.59 40.97,85.6 40.97,86.54 27.43,100.08 18.95,100.08 9.13,109.89 9.13,141.06 4.06,146.13 4.06,171.88 10.59,178.41 10.59,182.37 15.54,187.32 27.63,187.32 30.38,190.07 35.76,190.07 37.51,191.82 47.07,191.82 48.51,190.37 48.51,184.15 52.96,179.71 52.96,171.32 56.77,167.51 60.83,167.51 63.25,165.1 82.42,165.1 83.95,166.62 105.54,166.62 109.98,162.18 129.67,162.18 131.06,163.58 131.06,176.76 131.56,177.25 131.56,178.98 133.6,181.03 133.6,190.09 136.48,192.97 136.7,192.97 136.71,192.96 137.1,192.96 138.04,193.9 138.04,196.58 137.41,197.21 137.41,200.43 138.68,201.7 138.68,204.34 139.67,205.33 147.93,205.33 v2(149.35,206.76) 149.86,206.25 154.97,206.25 v3(155.74,205.49)
  BOTTOM w0.109: v2(149.35,206.76) 148.88,207.23 R107.2 ; U82.5 158.69,202.2 158.95,202.46 158.95,203.25 158.7,203.5 U82.7 157.28,203.5 157.07,203.71 157.07,204.15 v3(155.74,205.49) R870.2
MEM_DMAN0: length 60.8
  TOP w0.109: v2(154.07,52.12) CON1.12
  ART07 w0.114: v2(132.11,83.6) 133.13,83.6 133.62,83.11 134.02,83.11 134.28,82.85 arc(134.46,82.67) 134.71,82.6 134.71,82.6 arc(134.96,82.53) 135.14,82.36 135.14,82.35 arc(135.21,82.12) 135.16,81.89 arc(135.13,81.79) 135.12,81.68 135.12,80.72 arc(135.1,80.67) 135.07,80.62 134.96,80.51 134.32,80.51 134.2,80.4 134.2,80.18 134.33,80.05 134.96,80.05 135.08,79.94 135.08,79.37 136.49,77.96 138.66,77.96 139.07,77.56 139.07,74.22 139.18,74.11 145.53,74.11 151.29,68.34 151.29,64.07 151.72,63.64 151.72,63.64 151.74,63.62 151.74,63.33 151.29,62.88 151.29,62.56 150.76,62.03 150.76,59.55 150.65,59.44 149.81,59.44 149.7,59.32 149.7,59.08 149.81,58.97 150.65,58.97 150.76,58.85 150.76,58.62 150.65,58.51 149.81,58.51 149.7,58.4 149.7,58.17 149.81,58.05 150.65,58.05 150.76,57.94 150.76,57.71 150.65,57.6 149.81,57.6 149.7,57.48 149.7,57.25 149.81,57.14 150.65,57.14 150.76,57.02 150.76,56.8 150.65,56.68 149.81,56.68 149.7,56.57 149.7,56.31 150.61,55.4 151.32,55.4 151.98,54.73 151.98,54.31 151.61,53.94 151.61,51.28 151.9,51 153.24,51 153.59,51.35 153.59,51.65 v2(154.07,52.12)
MEM_DMAN1: length 57.5
  TOP w0.109: v2(148.99,62.71) 148.82,62.53 CON1.33
  ART07 w0.114: v2(148.99,62.71) 148.97,62.73 148.97,63.89 147.43,65.43 142.26,65.43 141.98,65.71 141.72,65.71 141.52,65.51 141.36,65.51 141.25,65.62 141.25,65.78 141.5,66.03 141.5,66.19 141.33,66.36 141.16,66.36 140.4,65.6 140.24,65.6 140.08,65.76 140.08,65.92 140.84,66.69 140.84,66.85 140.68,67.01 140.52,67.01 139.75,66.25 139.59,66.25 139.43,66.41 139.43,66.57 140.19,67.33 140.19,67.5 140.03,67.66 139.87,67.66 139.11,66.89 138.95,66.89 138.78,67.06 138.78,67.22 139.55,67.98 139.55,68.14 137.4,70.29 137.4,70.45 138.57,71.62 138.57,71.78 138.41,71.94 138.24,71.94 137.08,70.77 136.92,70.77 136.76,70.94 136.76,71.1 137.92,72.26 137.92,72.42 137.76,72.59 137.6,72.59 136.43,71.42 136.27,71.42 136.11,71.58 136.11,71.74 137.27,72.91 137.27,73.07 137.11,73.23 136.95,73.23 135.79,72.07 135.62,72.07 135.46,72.23 135.46,72.39 136.63,73.56 136.63,73.72 136.47,73.88 136.3,73.88 135.14,72.71 134.98,72.71 134.82,72.87 134.82,73.04 135.98,74.2 135.98,74.36 135.82,74.53 135.66,74.53 134.49,73.36 134.33,73.36 134.16,73.53 134.16,73.74 135.17,74.75 135.17,75.02 135,75.19 134.84,75.19 134.5,74.85 134.3,74.85 134.16,74.99 134.16,75.16 134.52,75.51 134.52,75.68 134.16,76.03 134.16,77.76 132.21,79.7 132.21,81.5 v2(132.11,81.6)
