# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Nets (continued)
FLASH_DC1_IO5: J11.9 U29.L10
FLASH_DC1_IO6: J11.25 U29.R10
FLASH_DC1_IO7: J11.21 U29.R11
FLASH_DC1_IO8: J11.18 U29.V13
FLASH_DC1_IO9: J11.20 U29.V14
FLASH_DC1_IO10: J11.10 U29.R12
FLASH_DC1_IO11: J11.11 U29.R13
FLASH_DC1_IO12: J11.12 U29.T13
FLASH_DC1_IO13: J11.13 U29.T14
FLASH_DC1_IO14: J11.24 U29.R14
FLASH_DC1_IO15: J11.26 U29.T15
FLASH_DC1_IO16: J11.28 U29.V15
FLASH_DC1_IO17: J11.29 U29.U15
FLASH_DC1_IO18: J11.30 U29.U16
FLASH_DC1_IO19: J11.31 U29.U17
FLASH_DC1_IO20: J11.32 U29.V16
FLASH_DC1_IO21: J11.33 U29.V17
FLASH_DC1_IO22: J11.34 U29.P14
FLASH_DC1_IO23: J11.37 U29.N14
FLASH_DC1_IO24: J11.38 U29.R16
FLASH_DC1_IO25: J11.41 U29.T16
FLASH_DC1_IO26: J11.42 U29.M11
FLASH_DC1_IO27: J11.43 U29.M12
FLASH_DC1_IO28: J11.44 U29.T18
FLASH_DC1_IO29: J11.45 U29.U18
FLASH_DC1_IO30: J11.46 U29.M15
FLASH_DC1_IO31: J11.47 U29.N15
FLASH_DC1_IO32: J11.48 U29.M16
FLASH_DC1_IO33: J11.50 U29.N16
FLASH_DC1_IO34: J11.51 U29.P15
FLASH_DC1_IO35: J11.52 U29.R15
FLASH_DC1_IO36: J11.53 U29.L11
FLASH_DC1_IO37: J11.54 U29.L12
FLASH_DC1_IO38: J11.56 U29.R17
FLASH_DC1_IO39: J11.57 U29.T17
FLASH_DC1_PRSNTN: R179.2 R181.1 R355.1 U23.M18 U29.B2
FLASH_DC1_RSTN: J11.55 R183.1 U29.V6
FMC_JTAG_BYPASSN: SW3.3 U23.L12
FPGA_DNU_CORE0: U1.CF61
FPGA_DNU_CORE1: U1.CH61
FPGA_DNU_CORE2: U1.BY55
FPGA_DNU_CORNER0: U1.CB61
FPGA_DNU_CORNER1: U1.AD45
FPGA_DNU_CORNER2: U1.BW18
FPGA_DNU_CORNER3: U1.AD19
FPGA_DNU_CORNER4: U1.BY61
FPGA_DNU_CORNER5: U1.AE44
FPGA_DNU_CORNER6: U1.BY19
FPGA_DNU_CORNER7: U1.AF19
FPGA_DNU_SDM0: U1.CB53
FPGA_DNU_SDM1: U1.BY53
FPGA_GPIO0: U1.V45 U29.D13
FPGA_GPIO1: U1.T45 U29.D12
FPGA_GPIO2: U1.W44 U29.C15
FPGA_GPIO3: U1.U44 U29.C16
FPGA_GPIO4: U1.V43 U29.A14
FPGA_GPIO5: U1.T43 U29.A15
FPGA_GPIO6: U1.W42 U29.C13
FPGA_GPIO7: U1.U42 U29.C14
FPGA_GPIO8: U1.V41 U29.B13
FPGA_GPIO9: U1.T41 U29.B14
FPGA_GPIO10: U1.W40 U29.F12
FPGA_GPIO11: U1.U40 U29.F11
FPGA_GPIO12: U1.P45 U29.B12
FPGA_GPIO13: U1.M45 U29.C12
FPGA_GPIO14: U1.N44 U29.B11
FPGA_GPIO15: U1.L44 U29.C11
FPGA_GPIO_OUTCLKN: R44.2 U1.CL20
FPGA_GPIO_OUTCLKP: R35.2 U1.CN20
FPGA_GPIO_REFCLK: R449.1 R1027.1
FPGA_GPIO_REFCLKN0: C812.2 R24.1 R27.1 R28.1 R899.1 U1.DA22
FPGA_GPIO_REFCLKN1: C838.2 R25.2 R31.1 R32.1 R901.1 U1.CL22
FPGA_GPIO_REFCLKN2: C1326.1 R26.2 R43.2 R49.1 R50.1 U1.CE24
FPGA_GPIO_REFCLKP0: C814.2 R24.2 R29.1 R30.1 R900.1 U1.DC22
FPGA_GPIO_REFCLKP1: C839.2 R25.1 R34.1 R36.1 R902.1 U1.CN22
FPGA_GPIO_REFCLKP2: C1325.1 R26.1 R33.2 R51.1 R52.1 U1.CG24
FPGA_JTAG_BYPASSN: SW3.1 U23.L11
FPGA_JTAG_TCK: R19.2 U1.CU62 U23.E14
FPGA_JTAG_TDI: R20.2 U1.CV61 U23.B16
FPGA_JTAG_TDO: R921.2 U1.CR62 U23.B17
FPGA_JTAG_TMS: R18.2 U1.CT61 U23.D14
FPGA_LED_G0: U1.D43 U18.C7
FPGA_LED_G1: U1.B43 U18.C5
FPGA_LED_G2: U1.C42 U18.C3
FPGA_LED_G3: U1.A42 U18.C1
FPGA_LED_G4: U1.D41 U19.C7
FPGA_LED_G5: U1.B41 U19.C5
FPGA_LED_G6: U1.C40 U19.C3
FPGA_LED_G7: U1.A40 U19.C1
FPGA_MSEL0: R5.2 R9.1 SW1.1 U29.A6
FPGA_MSEL1: R6.2 R10.1 SW1.2 U29.B5
FPGA_MSEL2: R11.1 R13.2 SW1.3 U29.C6
FPGA_MSEL_EN: R857.1 SW1.4 U29.B7
FPGA_NCONFIG: R22.2 U1.CB57 U29.R8
FPGA_NSTATUS: R21.2 U1.CH59 U29.R9
FPGA_OSC_CLK_1: R444.2 U1.CC60
FPGA_PB0: C1398.2 R275.1 S1.2 U1.H41
FPGA_PB1: C1399.2 R276.1 S2.2 U1.F41
FPGA_PB2: C1400.2 R277.1 S3.2 U1.J40
FPGA_PB3: C1401.2 R278.1 S4.2 U1.G40
FPGA_PB4: C1402.2 R280.1 S5.2 U1.D45
FPGA_PB5: C1403.2 R281.1 S6.2 U1.B45
FPGA_PB6: C1404.2 R282.1 S7.2 U1.C44
FPGA_PB7: C1405.2 R283.1 S8.2 U1.A44
FPGA_SW0: C1390.2 SW2.1 U1.H45
FPGA_SW1: C1391.2 SW2.2 U1.F45
FPGA_SW2: C1392.2 SW2.3 U1.J44
FPGA_SW3: C1393.2 SW2.4 U1.G44
FPGA_SW4: C1394.2 SW2.5 U1.H43
FPGA_SW5: C1395.2 SW2.6 U1.F43
FPGA_SW6: C1396.2 SW2.7 U1.J42
FPGA_SW7: C1397.2 SW2.8 U1.G42
FPGA_SYS_RESETN: U1.G52 U29.A17
FPGA_SYSTEM_CLK: R452.1 R1028.1
FPGA_TEMP0N: C793.2 U1.CA52 U31.24
FPGA_TEMP0P: C793.1 U1.CC52 U31.23
FPGA_TEMP1N: C791.2 U1.AR20 U31.2
FPGA_TEMP1P: C791.1 U1.AN18 U31.1
FPGA_TEMP2N: C792.2 U1.AG46 U31.4
FPGA_TEMP2P: C792.1 U1.AH45 U31.3
FPGA_TEMP3N: C795.2 U1.AH43 U31.7
FPGA_TEMP3P: C795.1 U1.AF43 U31.5
FPGA_TEST_ALERTN: R274.1 U1.U36 U17.A3
FPGA_TEST_SCL: R272.1 U1.C36 U17.A1
FPGA_TEST_SDA: R273.1 U1.C34 U17.A2
FPGA_TESTI2C_ALERTN: J17.4 R269.1 U17.C3
FPGA_TESTI2C_SCL: J17.2 R271.1 U17.C1
FPGA_TESTI2C_SDA: J17.1 R270.1 U17.C2
FPGA_TESTI2C_TSN: R279.1 U17.B3
FPGA_TESTIO0: J16.2 U1.W34
FPGA_TESTIO1: J16.4 U1.U34
FPGA_TESTIO2: J16.8 U1.V33
FPGA_TESTIO3: J16.10 U1.T33
FPGA_TESTIO4: J16.1 U1.N38
FPGA_TESTIO5: J16.3 U1.L38
FPGA_TESTIO6: J16.7 U1.P37
FPGA_TESTIO7: J16.9 U1.M37
FPGA_TESTIO8: J17.10 U1.N36
FPGA_TESTIO9: J17.9 U1.L36
FPGA_TESTIO10: TP1.1(TP) U1.L34
FPGA_TESTIO11: TP2.1(TP) U1.P33
FPGA_TESTIO12: TP3.1(TP) U1.M33
FPGA_VREFN_ADC: R855.1 U1.CA62
FPGA_VREFP_ADC: R856.1 U1.CC62
FPGA_VSIGN_0: J49.3 U1.CE62
FPGA_VSIGN_1: J49.9 U1.CL62
FPGA_VSIGP_0: J49.1 U1.CG62
FPGA_VSIGP_1: J49.7 U1.CN62
FX2_DN: CN1.2 U20.2 U21.9
FX2_DP: CN1.3 U20.3 U21.8
FX2_FLAGA: U21.29 U23.E17
FX2_FLAGB: U21.30 U23.D18
FX2_FLAGC: U21.31 U23.G12
FX2_PA0: U21.33 U23.L18
FX2_PA1: U21.34 U23.M17
FX2_PA2: U21.35 U23.K17
FX2_PA3: U21.36 U23.L17
FX2_PA4: U21.37 U23.J18
FX2_PA5: U21.38 U23.K18
FX2_PA6: U21.39 U23.G18
FX2_PA7: U21.40 U23.H18
FX2_PB0: U21.18 U23.G17
FX2_PB1: U21.19 U23.H17
FX2_PB2: U21.20 U23.J12
FX2_PB3: U21.21 U23.J11
FX2_PB4: U21.22 U23.H15
FX2_PB5: U21.23 U23.J15
FX2_PB6: U21.24 U23.H16
FX2_PB7: U21.25 U23.J16
FX2_PD0: R304.2 U21.45
FX2_PD1: R303.2 U21.46
FX2_PD2: R305.2 U21.47
FX2_PD3: R306.2 U21.48
FX2_PD4: U21.49 U23.G15
FX2_PD5: U21.50 U23.F15
FX2_PD6: U21.51 U23.F16
FX2_PD7: U21.52 U23.G16
FX2_RESETN: R295.1 U21.42 U22.2 U23.H11
FX2_SCL: R292.1 R296.1 U21.15
FX2_SDA: R293.1 R297.1 U21.16
FX2_SLRDN: U21.1 U23.E16
FX2_SLWRN: U21.2 U23.D16
FX2_WAKEUP: C669.1 R299.2 R300.2 U21.44
HPS_DC_JTAG_TCK: J5.55 R74.1 R1005.2 U23.C16
HPS_DC_JTAG_TDI: J5.56 U23.A14
HPS_DC_JTAG_TDO: J5.58 U23.A15
HPS_DC_JTAG_TMS: J5.57 U23.C15
HPS_DC_PRSNTN: J5.52 R79.1 R357.1 U23.N18 U29.A2
HPS_DC_RESETN: J5.53 R84.2 U23.C13 U29.V12
HPS_GPIO0: J5.3 U1.AH5
HPS_GPIO1: J5.4 U1.AD1
HPS_GPIO2: J5.5 U1.AG6
HPS_GPIO3: J5.6 U1.AB1
HPS_GPIO4: J5.7 U1.AG4
HPS_GPIO5: J5.8 U1.AD3
HPS_GPIO6: J5.9 U1.AF5
HPS_GPIO7: J5.10 U1.AC2
HPS_GPIO8: J5.11 U1.AF1
HPS_GPIO9: J5.12 U1.AB3
HPS_GPIO10: J5.13 U1.AF3
HPS_GPIO11: J5.14 U1.AA2
HPS_GPIO12: J5.15 U1.AC4
HPS_GPIO13: J5.16 U1.V1
HPS_GPIO14: J5.17 U1.AA4
HPS_GPIO15: J5.18 U1.T1
HPS_GPIO16: J5.19 U1.AD5
HPS_GPIO17: J5.20 U1.P1
HPS_GPIO18: J5.21 U1.AF7
HPS_GPIO19: J5.22 U1.M1
HPS_GPIO20: J5.23 U1.AF9
HPS_GPIO21: J5.24 U1.W2
HPS_GPIO22: J5.25 U1.AB5
HPS_GPIO23: J5.26 U1.U2
HPS_GPIO24: J5.27 U1.AC6
HPS_GPIO25: J5.28 U1.H1
HPS_GPIO26: J5.29 U1.AA6
HPS_GPIO27: J5.30 U1.F1
HPS_GPIO28: J5.31 R76.1 U1.AD7
HPS_GPIO28_R: R76.2 R82.1 U29.U9
HPS_GPIO29: J5.32 R75.1 U1.N2
HPS_GPIO29_R: R75.2 R83.1 U29.U8
HPS_GPIO30: J5.33 R80.1 R493.2 U1.AB7 U29.V8
HPS_GPIO31: J5.34 R81.1 R494.2 U1.L2 U29.M8
HPS_GPIO32: J5.35 U1.AC8
HPS_GPIO33: J5.36 U1.J2
HPS_GPIO34: J5.37 U1.AA8
HPS_GPIO35: J5.38 U1.G2
HPS_GPIO36: J5.39 U1.AD9
HPS_GPIO37: J5.40 U1.V3
HPS_GPIO38: J5.41 U1.AB9
HPS_GPIO39: J5.42 U1.T3
HPS_GPIO40: J5.43 U1.AC10
HPS_GPIO41: J5.44 U1.P3
HPS_GPIO42: J5.45 U1.AD11
HPS_GPIO43: J5.46 U1.M3
HPS_GPIO44: J5.47 U1.AC12
HPS_GPIO45: J5.48 U1.H3
HPS_GPIO46: J5.49 U1.AD13
HPS_GPIO47: J5.50 U1.F3
HPS_PROC_RSTN: U23.V8 U29.K7
HPS_PWREN: J5.51 R77.1 U23.R6 U25.11
HPS_PWRGD: J5.54 R73.1 U23.U5
I2C_3.3V_ALERTN: R496.2 U29.C7
I2C_3.3V_EN: R504.1 R852.1 U29.F1 U45.5 U81.5
I2C_3.3V_SCL: R396.1 R507.1 U31.20 U32.2 U33.2 U44.6 U45.7 U46.1
I2C_3.3V_SDA: R397.1 R506.1 U31.19 U32.3 U33.3 U44.5 U45.6 U46.16
I2C_ADI_ALERTN: R927.1 R996.2 U29.A8
I2C_ADI_SCL: R924.1 R925.1 U81.7
I2C_ADI_SDA: R923.1 R926.1 U81.6
I2C_ALERTN_R: R563.1 R569.2 U53.H11
I2C_ALERTN_R_1: R646.1 R654.2 U58.H11
I2C_PCIE_SCL: R235.1 U29.A3
I2C_PCIE_SDA: R236.1 U29.D5
I2C_VID_ALERTN: R495.2 R5285.1 U29.C8
I2C_VID_SCL: R486.1 R5283.1 U43.7
I2C_VID_SDA: R484.1 R5284.1 U43.6
IREF: C1718.2 C2113.2 R6041.1 U54.33 U54.43 U54.44 U54.47 U54.48
ISENSE0: R5883.2 U54.4 U87.33
ISENSE2: R5881.2 U54.3 U89.33
ISENSE3: R5997.2 U54.52 U90.33
ISENSE4: R5882.2 U54.51 U88.33
ISENSE_12VIN: R514.2 U32.23
ISENSEN_VCCCLK_GXE_FPGA_2.5V: R5298.1 V19.2(SNS)
ISENSEN_VCCFUSEWR_SDM_FPGA_2.4V: R5300.1 V21.2(SNS)
ISENSEN_VCCH_GXE_FPGA_1.1V: R5292.1 V13.2(SNS)
ISENSEN_VCCIO_FPGA_1.5V: R5296.1 V17.2(SNS)
ISENSEN_VCCIO_FPGA_1.8V: R5294.1 V25.2(SNS)
ISENSEN_VCCL_HPS_FPGA_0.9V: R5288.1 V9.2(SNS)
ISENSEN_VCCL_SDM_FPGA_0.8V: R5290.1 V11.2(SNS)
ISENSEN_VDD_SODIMM: R5302.1 V23.2(SNS)
ISENSEP_VCCCLK_GXE_FPGA_2.5V: R5297.1 V18.2(SNS)
ISENSEP_VCCFUSEWR_SDM_FPGA_2.4V: R5299.1 V20.2(SNS)
ISENSEP_VCCH_GXE_FPGA_1.1V: R5291.1 V12.2(SNS)
ISENSEP_VCCIO_FPGA_1.5V: R5295.1 V16.2(SNS)
ISENSEP_VCCIO_FPGA_1.8V: R5293.1 V24.2(SNS)
ISENSEP_VCCL_HPS_FPGA_0.9V: R5287.1 V8.2(SNS)
ISENSEP_VCCL_SDM_FPGA_0.8V: R5289.1 V10.2(SNS)
ISENSEP_VDD_SODIMM: R5301.1 V22.2(SNS)
ITH0: C1720.2 U54.9
ITHR0: C1721.1 U54.10
JTAG_RX: D15.1(CATHODE) U23.B3
JTAG_TX: D16.1(CATHODE) U23.A3
LMK05028_PDN: J26.10 R454.1 R850.2 U23.R2 U38.46
LTM4608_BSEL1: R6075.1 U60.B7
LTM4608_BSEL2: R6076.1 U61.B7
LTM4608_BSEL3: R6077.1 U62.B7
LTM4608_BSEL4: R6078.1 U63.B7
LTM4608_BSEL5: R6079.1 U64.B7
LTM4608_BSEL6: R6080.1 U68.B7
LTM4608_BSEL7: R6081.1 U70.B7
LTM4608_BSEL8: R6082.1 U71.B7
LTM4608_FB1: C1946.1 R684.1 U60.E7
LTM4608_FB2: C1947.1 R5400.1 U61.E7
LTM4608_FB3: C1948.1 R5409.1 U62.E7
LTM4608_FB4: C1949.1 R5418.1 U63.E7
LTM4608_FB5: C1950.1 R5427.1 U64.E7
LTM4608_FB6: C1951.1 R759.1 R760.2 R6066.1 U68.E7
LTM4608_FB7: C1954.1 R5445.1 U70.E7
LTM4608_FB8: C1957.1 R5454.1 U71.E7
LTM4608_MGN1: R5391.2 R5392.1 U60.B8
LTM4608_MGN2: R5394.2 R5398.1 U61.B8
LTM4608_MGN3: R5403.2 R5407.1 U62.B8
LTM4608_MGN4: R5412.2 R5416.1 U63.B8
LTM4608_MGN5: R5421.2 R5425.1 U64.B8
LTM4608_MGN6: R5430.2 R5434.1 U68.B8
LTM4608_MGN7: R5439.2 R5443.1 U70.B8
LTM4608_MGN8: R5448.2 R5452.1 U71.B8
LTM4608_MODE1: R6045.2 U60.B5
LTM4608_MODE2: R6049.2 U61.B5
LTM4608_MODE3: R6053.2 U62.B5
LTM4608_MODE4: R6057.2 U63.B5
LTM4608_MODE5: R6061.2 U64.B5
LTM4608_MODE6: R6065.2 U68.B5
LTM4608_MODE7: R6070.2 U70.B5
LTM4608_MODE8: R6074.2 U71.B5
LTM4608_PHMODE1: R6044.1 U60.B4
LTM4608_PHMODE2: R6046.1 U61.B4
LTM4608_PHMODE3: R6050.1 U62.B4
LTM4608_PHMODE4: R6054.1 U63.B4
LTM4608_PHMODE5: R6058.1 U64.B4
LTM4608_PHMODE6: R6062.1 U68.B4
LTM4608_PHMODE7: R6067.1 U70.B4
LTM4608_PHMODE8: R6071.1 U71.B4
LTM4608_SVIN_1: R5390.2 U60.F4
LTM4608_SVIN_2: R5401.2 U61.F4
LTM4608_SVIN_3: R5410.2 U62.F4
LTM4608_SVIN_4: R5419.2 U63.F4
LTM4608_SVIN_5: R5428.2 U64.F4
LTM4608_SVIN_6: R5437.2 U68.F4
LTM4608_SVIN_7: R5446.2 U70.F4
LTM4608_SVIN_8: R5455.2 U71.F4
LTM4608_TRACK1: R5390.1 U60.E5
LTM4608_TRACK2: R5401.1 U61.E5
LTM4608_TRACK3: R5410.1 U62.E5
LTM4608_TRACK4: R5419.1 U63.E5
LTM4608_TRACK5: R5428.1 U64.E5
LTM4608_TRACK6: R5437.1 U68.E5
LTM4608_TRACK7: R5446.1 U70.E5
LTM4608_TRACK8: R5455.1 U71.E5
LTM4623_INTVCC_1: C2110.2 R1125.1 R6027.1 R6028.1 U49.E4
LTM4623_INTVCC_2: C1895.2 R5995.1 R6020.1 U52.E4
LTM4623_INTVCC_3: C1970.2 R5999.1 R6023.1 U65.E4
LTM4623_INTVCC_4: C2086.2 R6009.1 R6022.1 U66.E4
LTM4623_INTVCC_5: C2062.2 R6016.1 R6021.1 U72.E4
LTM4677_INTVCC: TP193.1(TP) U59.F9 U59.G9
LTM4677_VDD33: R670.2 R671.2 R672.2 R673.2 R5473.2 R5474.2
LTM4678_1_VDD33: R563.2 R564.2 R566.2 R5316.2 R5317.2 R5318.2 R5319.2 U53.E8
LTM4678_2_VDD33: R646.2 R647.2 R648.2 R5338.2 R5339.2 R5340.2 R5341.2 U58.E8
LTM4680_FAULT0N: R5463.2 U57.G11 U57.H12
LTM4680_SHARE_CLK: R5460.1 U57.D11
LTM4680_SYNC: R5459.1 U57.K12
M2F_I2C_SCL: R382.1 U1.J34 U29.B16
M2F_I2C_SDA: R383.1 U1.C38 U29.B17
MAX10_OVERTEMP: U23.V5 U29.G1
MAX_SCL: R307.1 U23.N7 U29.H2
MAX_SDA: R308.1 U23.N8 U29.H1
MDC_T: R242.2 U15.25 U16.C2
MDIN0: J15.2 R256.2 U15.31
MDIN1: J15.6 R258.2 U15.34
MDIN2: J15.5 R260.2 U15.41
MDIN3: J15.8 R262.2 U15.43
MDIO_T: R241.2 U15.24 U16.C1
MDIP0: J15.1 R255.2 U15.29
MDIP1: J15.3 R257.2 U15.33
MDIP2: J15.4 R259.2 U15.39
MDIP3: J15.7 R261.2 U15.42
MEM_ADDR_CMD0: CON1.113 U1.CM31
MEM_ADDR_CMD1: CON1.108 R109.1 R110.2 U1.CK31
MEM_ADDR_CMD2: CON1.149 U1.CN32
MEM_ADDR_CMD3: CON1.114 U1.CL32
MEM_ADDR_CMD4: CON1.155 U1.CM33
MEM_ADDR_CMD5: CON1.161 U1.CK33
MEM_ADDR_CMD6: CON1.109 R111.2 U1.CN34
MEM_ADDR_CMD7: CON1.110 R112.2 U1.CL34
MEM_ADDR_CMD8: CON1.157 U1.CN36
MEM_ADDR_CMD9: CON1.143 U1.CL36
MEM_ADDR_CMD10: CON1.144 U1.CH31
MEM_ADDR_CMD11: CON1.133 U1.CF31
MEM_ADDR_CMD12: CON1.132 U1.CG32
MEM_ADDR_CMD13: CON1.131 U1.CE32
MEM_ADDR_CMD14: CON1.128 U1.CH33
MEM_ADDR_CMD15: CON1.126 U1.CF33
MEM_ADDR_CMD16: CON1.127 U1.CG34
MEM_ADDR_CMD17: CON1.122 U1.CE34
MEM_ADDR_CMD18: CON1.125 U1.CH35
MEM_ADDR_CMD19: CON1.121 U1.CF35
MEM_ADDR_CMD20: CON1.146 U1.CG36
MEM_ADDR_CMD21: CON1.120 U1.CE36
MEM_ADDR_CMD22: CON1.119 U1.CK39
MEM_ADDR_CMD23: CON1.158 U1.CN40
MEM_ADDR_CMD24: CON1.151 U1.CL40
MEM_ADDR_CMD25: CON1.156 U1.CM41
MEM_ADDR_CMD26: CON1.152 U1.CK41
MEM_ADDR_CMD27: CON1.116 R104.2 U1.CN42
MEM_ADDR_CMD28: CON1.150 U1.CL42
MEM_ADDR_CMD29: CON1.145 U1.CM43
MEM_ADDR_CMD30: CON1.115 U1.CK43
MEM_CLKN: CON1.139 U1.CK35
MEM_CLKP: CON1.137 U1.CM35
MEM_CONFIG0: CON1.134 R107.2 R870.2 R871.2 U82.5 U82.7
MEM_DMAN0: CON1.12 U1.CV55
MEM_DMAN1: CON1.33 U1.DB55
MEM_DMAN2: CON1.54 U1.CU48
MEM_DMAN3: CON1.75 U1.DC48
MEM_DMBN0: CON1.178 U1.CV41
MEM_DMBN1: CON1.199 U1.DB41
MEM_DMBN2: CON1.220 U1.CU34
MEM_DMBN3: CON1.241 U1.DC34
MEM_DQ_ADDR_CMD0: CON1.104 U1.CG38
MEM_DQ_ADDR_CMD1: CON1.105 U1.CE38
MEM_DQ_ADDR_CMD2: CON1.101 U1.CH39
MEM_DQ_ADDR_CMD3: CON1.100 U1.CF39
MEM_DQ_ADDR_CMD4: CON1.96 U1.CH41
MEM_DQ_ADDR_CMD5: CON1.88 U1.CG42
MEM_DQ_ADDR_CMD6: CON1.91 U1.CE42
MEM_DQ_ADDR_CMD7: CON1.92 U1.CH43
MEM_DQ_ADDR_CMD8: CON1.87 U1.CF43
MEM_DQA0: CON1.8 U1.CR52
MEM_DQA1: CON1.7 U1.CV53
MEM_DQA2: CON1.20 U1.CU56
MEM_DQA3: CON1.21 U1.CV57
MEM_DQA4: CON1.4 U1.CU52
MEM_DQA5: CON1.3 U1.CT53
MEM_DQA6: CON1.16 U1.CR56
MEM_DQA7: CON1.17 U1.CT57
MEM_DQA8: CON1.28 U1.DA56
MEM_DQA9: CON1.29 U1.DC56
MEM_DQA10: CON1.41 U1.DA52
MEM_DQA11: CON1.42 U1.DC52
MEM_DQA12: CON1.24 U1.CY57
MEM_DQA13: CON1.25 U1.DB57
MEM_DQA14: CON1.38 U1.CY53
MEM_DQA15: CON1.37 U1.DB53
MEM_DQA16: CON1.50 U1.CT45
MEM_DQA17: CON1.49 U1.CR46
MEM_DQA18: CON1.62 U1.CT49
MEM_DQA19: CON1.63 U1.CU50
MEM_DQA20: CON1.46 U1.CV45
MEM_DQA21: CON1.45 U1.CU46
MEM_DQA22: CON1.58 U1.CR50
MEM_DQA23: CON1.59 U1.CV49
MEM_DQA24: CON1.70 U1.DA46
MEM_DQA25: CON1.71 U1.DB49
MEM_DQA26: CON1.83 U1.CY45
MEM_DQA27: CON1.84 U1.DB45
MEM_DQA28: CON1.66 U1.DA50
MEM_DQA29: CON1.67 U1.DC50
MEM_DQA30: CON1.79 U1.CY49
MEM_DQA31: CON1.80 U1.DC46
MEM_DQA32: CON1.140 U1.CY55
MEM_DQA33: CON1.138 U1.DA48
MEM_DQB0: CON1.174 U1.CU42
MEM_DQB1: CON1.173 U1.CV43
MEM_DQB2: CON1.187 U1.CT39
MEM_DQB3: CON1.186 U1.CR38
MEM_DQB4: CON1.170 U1.CR42
MEM_DQB5: CON1.169 U1.CT43
MEM_DQB6: CON1.183 U1.CV39
MEM_DQB7: CON1.182 U1.CU38
MEM_DQB8: CON1.195 U1.DA42
MEM_DQB9: CON1.194 U1.DC42
MEM_DQB10: CON1.207 U1.DB39
MEM_DQB11: CON1.208 U1.DC38
MEM_DQB12: CON1.191 U1.DB43
MEM_DQB13: CON1.190 U1.CY43
MEM_DQB14: CON1.203 U1.CY39
MEM_DQB15: CON1.204 U1.DA38
MEM_DQB16: CON1.216 U1.CV35
MEM_DQB17: CON1.215 U1.CR32
MEM_DQB18: CON1.228 U1.CT31
MEM_DQB19: CON1.229 U1.CU36
MEM_DQB20: CON1.211 U1.CR36
MEM_DQB21: CON1.212 U1.CT35
MEM_DQB22: CON1.224 U1.CV31
MEM_DQB23: CON1.225 U1.CU32
MEM_DQB24: CON1.237 U1.CY35
MEM_DQB25: CON1.236 U1.DA36
MEM_DQB26: CON1.249 U1.DA32
MEM_DQB27: CON1.250 U1.CY31
MEM_DQB28: CON1.232 U1.DC36
MEM_DQB29: CON1.233 U1.DB35
MEM_DQB30: CON1.245 U1.DC32
MEM_DQB31: CON1.246 U1.DB31
MEM_DQB32: CON1.165 U1.CY41
MEM_DQB33: CON1.162 U1.DA34
MEM_DQS_ADDR_CMDN: CON1.95 U1.CE40
MEM_DQS_ADDR_CMDP: CON1.97 U1.CG40
MEM_DQSAN0: CON1.11 U1.CR54
MEM_DQSAN1: CON1.32 U1.DA54
MEM_DQSAN2: CON1.53 U1.CT47
MEM_DQSAN3: CON1.74 U1.CY47
MEM_DQSAP0: CON1.13 U1.CU54
MEM_DQSAP1: CON1.34 U1.DC54
MEM_DQSAP2: CON1.55 U1.CV47
MEM_DQSAP3: CON1.76 U1.DB47
MEM_DQSBN0: CON1.177 U1.CR40
MEM_DQSBN1: CON1.198 U1.DA40
MEM_DQSBN2: CON1.219 U1.CT33
MEM_DQSBN3: CON1.240 U1.CY33
MEM_DQSBP0: CON1.179 U1.CU40
MEM_DQSBP1: CON1.200 U1.DC40
MEM_DQSBP2: CON1.221 U1.CV33
MEM_DQSBP3: CON1.242 U1.DB33
MSTR0: SW3.6 U23.L15
MSTR1: SW3.7 U23.K16
MSTR2: SW3.8 U23.L16
MXP_RXN0: J13.8 U1.AJ8
MXP_RXN1: J13.6 U1.AM11
MXP_RXN2: J13.4 U1.AN8
MXP_RXN3: J13.2 U1.AT11
MXP_RXP0: J13.7 U1.AK7
MXP_RXP1: J13.5 U1.AL10
MXP_RXP2: J13.3 U1.AP7
MXP_RXP3: J13.1 U1.AR10
MXP_TXN0: J13.9 U1.AJ2
MXP_TXN1: J13.11 U1.AM5
MXP_TXN2: J13.13 U1.AN2
MXP_TXN3: J13.15 U1.AT5
MXP_TXP0: J13.10 U1.AK1
MXP_TXP1: J13.12 U1.AL4
MXP_TXP2: J13.14 U1.AP1
MXP_TXP3: J13.16 U1.AR4
OPT_FAN_RPM: R403.1 U29.B4
OV_12V_DCIN: C955.1 R521.1 R524.2 U48.4
OVERTEMPN: R399.1 U29.C5 U31.16
PCIE_EP_PERSTN: J14.A11 R234.1 R238.2 U29.D9
PCIE_JTAG_BYPASSN: SW3.5 U23.R17
PCIE_RC_JTAG_TCK: J14.A5 R230.1 U23.N15
PCIE_RC_JTAG_TDI: J14.A6 R231.1 U23.M16
PCIE_RC_JTAG_TDO: J14.A7 R232.1 U23.N16
PCIE_RC_JTAG_TMS: J14.A8 R233.1 U23.M15
PCIE_RC_JTAG_TRSTN: J14.B9 R237.2 U23.P15
PCIE_RC_PERSTN: R88.1 R89.1 U1.BU58 U29.U11
PCIE_RC_PRSNTN: J14.B17 J14.B31 J14.B48 J14.B81 R240.2 R351.1 U23.P18 U29.B3
PCIE_RC_REFCLKN: J14.A14 R969.1
PCIE_RC_REFCLKP: J14.A13 R968.1
PCIE_RC_RXN0: J14.A17 U1.BR62
PCIE_RC_RXN1: J14.A22 U1.BM59
PCIE_RC_RXN2: J14.A26 U1.BL62
PCIE_RC_RXN3: J14.A30 U1.BH59
PCIE_RC_RXN4: J14.A36 U1.BG62
PCIE_RC_RXN5: J14.A40 U1.BD59
PCIE_RC_RXN6: J14.A44 U1.BC62
PCIE_RC_RXN7: J14.A48 U1.AY59
PCIE_RC_RXN8: J14.A53 U1.AW62
PCIE_RC_RXN9: J14.A57 U1.AT59
PCIE_RC_RXN10: J14.A61 U1.AR62
PCIE_RC_RXN11: J14.A65 U1.AM59
PCIE_RC_RXN12: J14.A69 U1.AL62
PCIE_RC_RXN13: J14.A73 U1.AH59
PCIE_RC_RXN14: J14.A77 U1.AG62
PCIE_RC_RXN15: J14.A81 U1.AD59
PCIE_RC_RXP0: J14.A16 U1.BP61
PCIE_RC_RXP1: J14.A21 U1.BN58
PCIE_RC_RXP2: J14.A25 U1.BK61
PCIE_RC_RXP3: J14.A29 U1.BJ58
PCIE_RC_RXP4: J14.A35 U1.BF61
PCIE_RC_RXP5: J14.A39 U1.BE58
PCIE_RC_RXP6: J14.A43 U1.BB61
PCIE_RC_RXP7: J14.A47 U1.BA58
PCIE_RC_RXP8: J14.A52 U1.AV61
PCIE_RC_RXP9: J14.A56 U1.AU58
PCIE_RC_RXP10: J14.A60 U1.AP61
PCIE_RC_RXP11: J14.A64 U1.AN58
PCIE_RC_RXP12: J14.A68 U1.AK61
PCIE_RC_RXP13: J14.A72 U1.AJ58
PCIE_RC_RXP14: J14.A76 U1.AF61
PCIE_RC_RXP15: J14.A80 U1.AE58
PCIE_RC_TXN0: C586.1 U1.BR56
PCIE_RC_TXN1: C588.1 U1.BM53
PCIE_RC_TXN2: C590.1 U1.BL56
PCIE_RC_TXN3: C592.1 U1.BH53
PCIE_RC_TXN4: C594.1 U1.BG56
PCIE_RC_TXN5: C596.1 U1.BD53
PCIE_RC_TXN6: C598.1 U1.BC56
PCIE_RC_TXN7: C600.1 U1.AY53
PCIE_RC_TXN8: C602.1 U1.AW56
PCIE_RC_TXN9: C604.1 U1.AT53
PCIE_RC_TXN10: C606.1 U1.AR56
PCIE_RC_TXN11: C615.1 U1.AM53
PCIE_RC_TXN12: C617.1 U1.AL56
PCIE_RC_TXN13: C619.1 U1.AH53
PCIE_RC_TXN14: C621.1 U1.AG56
PCIE_RC_TXN15: C623.1 U1.AD53
PCIE_RC_TXP0: C581.1 U1.BP55
PCIE_RC_TXP1: C587.1 U1.BN52
PCIE_RC_TXP2: C589.1 U1.BK55
PCIE_RC_TXP3: C591.1 U1.BJ52
PCIE_RC_TXP4: C593.1 U1.BF55
PCIE_RC_TXP5: C595.1 U1.BE52
PCIE_RC_TXP6: C597.1 U1.BB55
PCIE_RC_TXP7: C599.1 U1.BA52
PCIE_RC_TXP8: C601.1 U1.AV55
PCIE_RC_TXP9: C603.1 U1.AU52
PCIE_RC_TXP10: C605.1 U1.AP55
PCIE_RC_TXP11: C607.1 U1.AN52
PCIE_RC_TXP12: C616.1 U1.AK55
PCIE_RC_TXP13: C618.1 U1.AJ52
PCIE_RC_TXP14: C620.1 U1.AF55
PCIE_RC_TXP15: C622.1 U1.AE52
PCIE_RC_WAKEN: J14.B11(WAKE_N) R239.2 U23.U1
PCIE_TXN0: C586.2 J14.B15
PCIE_TXN1: C588.2 J14.B20
PCIE_TXN2: C590.2 J14.B24
PCIE_TXN3: C592.2 J14.B28
PCIE_TXN4: C594.2 J14.B34
PCIE_TXN5: C596.2 J14.B38
PCIE_TXN6: C598.2 J14.B42
PCIE_TXN7: C600.2 J14.B46
PCIE_TXN8: C602.2 J14.B51
PCIE_TXN9: C604.2 J14.B55
PCIE_TXN10: C606.2 J14.B59
PCIE_TXN11: C615.2 J14.B63
PCIE_TXN12: C617.2 J14.B67
PCIE_TXN13: C619.2 J14.B71
PCIE_TXN14: C621.2 J14.B75
PCIE_TXN15: C623.2 J14.B79
PCIE_TXP0: C581.2 J14.B14
PCIE_TXP1: C587.2 J14.B19
PCIE_TXP2: C589.2 J14.B23
PCIE_TXP3: C591.2 J14.B27
PCIE_TXP4: C593.2 J14.B33
PCIE_TXP5: C595.2 J14.B37
PCIE_TXP6: C597.2 J14.B41
PCIE_TXP7: C599.2 J14.B45
PCIE_TXP8: C601.2 J14.B50
PCIE_TXP9: C603.2 J14.B54
PCIE_TXP10: C605.2 J14.B58
PCIE_TXP11: C607.2 J14.B62
PCIE_TXP12: C616.2 J14.B66
PCIE_TXP13: C618.2 J14.B70
PCIE_TXP14: C620.2 J14.B74
PCIE_TXP15: C622.2 J14.B78
PG_1.2V: R792.2 U23.T2 U72.C2
PG_1.8V: R776.1 U23.P3 U70.C7
PG_2.5V: R785.1 U23.M7 U71.C7
PG_3.3V: R5311.1 U23.H6 U53.D9 U53.J7
PG_5V: R2295.2 U23.D2 U52.C2
PG_12V: R542.1 U23.E4 U51.7
PG_12VIN: R516.2 R928.2 U23.C2 U48.10
PG_FPGA: U23.U8 U29.E5
PG_SYSMAX: U23.R5 U29.F5
PG_VCC_FPGA_VID: R1066.1 U23.C1 U54.13
PG_VCCCLK_GXE_FPGA_2.5V: R5998.2 U23.M2 U65.C2
PG_VCCFUSEWR_SDM_FPGA_2.4V: R6007.2 U23.L8 U66.C2
PG_VCCH_FPGA_0.9V: R1129.1 U23.D1 U57.D9 U57.J7
PG_VCCH_GXE_FPGA_1.1V: R707.1 U23.K1 U62.C7
PG_VCCIO_FPGA_1.2V: R658.2 U23.G1 U59.E4 U59.F4
PG_VCCIO_FPGA_1.5V: R725.1 U23.L2 U64.C7
PG_VCCIO_FPGA_1.8V: R1019.1 U23.K3 U63.C7
PG_VCCL_HPS_FPGA_0.9V: R687.1 U23.J1 U60.C7
PG_VCCL_SDM_FPGA_0.8V: R697.1 U23.K7 U61.C7
PG_VCCPT_FPGA_1.8V: R636.1 U23.F2 U58.D9 U58.J7
PG_VDD_SODIMM: R757.1 U23.T3 U68.C7
PG_VTT_DDR4_0.6V: R764.2 U23.P1 U69.9
PG_VTT_SODIMM_0.6V: R745.2 U23.N3 U67.9
PHY_SCL: R292.2 U23.G11
PHY_SDA: R293.2 U23.B18
PMBUS_VID_EN: R499.1 R851.1 U29.T9 U43.5
PWRMAX_DEBUGMDN: J18.2 R309.2 R922.2 U23.R1
PWRMAX_LED_G0: D19.1(CATHODE) U23.D7
PWRMAX_LED_G1: D20.1(CATHODE) U23.D8
PWRMAX_LED_R0: D23.1(CATHODE) U23.B5
PWRMAX_LED_R1: D24.1(CATHODE) U23.C6
PWRMAX_PB0: R359.1 S10.2 U23.B8
PWRMAX_PORSTN: R358.1 U23.H12 U28.2
PWRMAX_SW0: SW4.1 U23.D9
PWRMAX_SW1: SW4.2 U23.D10
PWRMAX_SW2: SW4.3 U23.A10
PWRMAX_SW3: SW4.4 U23.A11
PWRMAX_SW4: SW9.1 U23.G10
PWRMAX_SW5: SW9.2 U23.F10
PWRMAX_TCK: J18.1 R304.1 R310.1 U23.J8
PWRMAX_TDI: J18.9 R305.1 R312.1 U23.H3
PWRMAX_TDO: J18.3 R306.1 U23.H4
PWRMAX_TMS: J18.5 R303.1 R311.1 U23.J7
QSFP_I2C_SCL: R226.1 U1.CY7 U14.A3
QSFP_I2C_SDA: R227.1 U1.CR10 U14.A4
QSFP_INITMODE: R216.1 U1.CR8 U14.A1
QSFP_INTN: R217.1 U1.CV7 U13.A4
QSFP_IO_TSN: R228.1 R842.1 U13.B3 U14.B3 U29.A13
QSFP_MODPRSN: R215.1 U1.CT7 U13.A3
QSFP_MODSELN: R213.1 U1.CR6 U13.A1
QSFP_RESETN: R214.1 U1.CU6 U13.A2
QSFPDD_I2C_SCL: R202.1 U1.CT1 U11.A3
QSFPDD_I2C_SDA: R203.1 U1.CY5 U11.A4
QSFPDD_INITMODE: R212.1 U1.CT5 U11.A1
QSFPDD_INTN: R210.1 U1.CU4 U10.A4
QSFPDD_IO_TSN: R189.1 R841.1 U10.B3 U11.B3 U29.A12
QSFPDD_MODPRSN: R209.1 U1.CT3 U10.A3
QSFPDD_MODSELN: R207.1 U1.CR4 U10.A1
QSFPDD_RESETN: R211.1 U1.CV3 U10.A2
QSFPDD_RXN0: U1.BE8 U12.18
QSFPDD_RXN1: U1.BJ8 U12.21
QSFPDD_RXN2: U1.BH11 U12.15
QSFPDD_RXN3: U1.BM11 U12.24
QSFPDD_RXN4: U1.BN8 U12.56
QSFPDD_RXN5: U1.BU8 U12.59
QSFPDD_RXN6: U1.BT11 U12.53
QSFPDD_RXN7: U1.BY11 U12.62
QSFPDD_RXP0: U1.BF7 U12.17
QSFPDD_RXP1: U1.BK7 U12.22
QSFPDD_RXP2: U1.BG10 U12.14
QSFPDD_RXP3: U1.BL10 U12.25
QSFPDD_RXP4: U1.BP7 U12.55
QSFPDD_RXP5: U1.BV7 U12.60
QSFPDD_RXP6: U1.BR10 U12.52
QSFPDD_RXP7: U1.BW10 U12.63
QSFPDD_T_INITMODE: R201.1 U11.C1 U12.31
QSFPDD_T_INTN: R197.1 U10.C4 U12.28
QSFPDD_T_MODPRSN: R195.1 U10.C3 U12.27
QSFPDD_T_MODSELN: R194.1 U10.C1 U12.8
QSFPDD_T_RESETN: R199.1 R200.2 U10.C2 U12.9
QSFPDD_T_SCL: R196.2 U11.C3 U12.11
QSFPDD_T_SDA: R198.2 U11.C4 U12.12
QSFPDD_TEMP4N: C1589.2 Q6.B Q6.C U31.9
QSFPDD_TEMP4P: C1589.1 Q6.E(EMITTER) U31.8
QSFPDD_TXN0: U1.BE2 U12.37
QSFPDD_TXN1: U1.BJ2 U12.2
QSFPDD_TXN2: U1.BH5 U12.34
QSFPDD_TXN3: U1.BM5 U12.5
QSFPDD_TXN4: U1.BN2 U12.75
QSFPDD_TXN5: U1.BU2 U12.40
QSFPDD_TXN6: U1.BT5 U12.72
QSFPDD_TXN7: U1.BY5 U12.43
QSFPDD_TXP0: U1.BF1 U12.36
QSFPDD_TXP1: U1.BK1 U12.3
QSFPDD_TXP2: U1.BG4 U12.33
QSFPDD_TXP3: U1.BL4 U12.6
QSFPDD_TXP4: U1.BP1 U12.74
QSFPDD_TXP5: U1.BV1 U12.41
QSFPDD_TXP6: U1.BR4 U12.71
QSFPDD_TXP7: U1.BW4 U12.44
QSFPDD_VCC: C544.1 C545.1 L10.2 U12.30 U12.68
QSFPDD_VCCRX: C556.1 C557.1 L12.2 U12.10 U12.48
QSFPDD_VCCTX: C554.1 C555.1 L11.2 U12.29 U12.67
REFCLK_GXEN0: C815.2 U1.AP13
REFCLK_GXEN1: C10.1 U1.AN14
REFCLK_GXEN2: C870.2 U1.AH11
REFCLK_GXEN3: C874.2 U1.AH13
REFCLK_GXEP0: C816.2 U1.AT13
REFCLK_GXEP1: C9.1 U1.AR14
REFCLK_GXEP2: C869.2 U1.AJ12
REFCLK_GXEP3: C873.2 U1.AK13
REFCLK_GXPN0: R430.1 U1.AH49
REFCLK_GXPN2: R432.1 U1.AD49
REFCLK_GXPP0: R429.1 U1.AJ48
REFCLK_GXPP2: R431.1 U1.AE48
REFERENCECLK_1: R467.1 R940.1
REFERENCECLK_2: R475.2 R1025.1
REFERENCECLK_3: R947.2 R1026.1
RESERVED_JTAG_BYPASSN: SW3.4 U23.T17
REV0: R1054.1 R1058.1 U23.D15
REV1: R1055.1 R1059.1 U23.E15
REV2: R1056.1 R1060.1 U23.C17
REV3: R1057.1 R1061.1 U23.D17
SC_RX: D17.1(CATHODE) U23.D5
SC_TX: D18.1(CATHODE) U23.D6
SDM_I2C_SCL: R490.2 U29.M9
SDM_I2C_SDA: R491.2 U29.V10
SDM_IO0: R487.2 U1.CF59 U29.U7
SDM_IO1: R965.1 U1.CU60
SDM_IO2: R961.1 U1.CT59
SDM_IO3: R954.2 U1.CK59
SDM_IO4: R953.2 U1.CN60
SDM_IO5: R1.1 R3.2 R957.2 U1.CR60
SDM_IO6: R963.1 U1.CM59
SDM_IO7: R2.1 R4.2 R967.1 U1.CY59
SDM_IO8: R958.2 U1.CL60
SDM_IO9: R7.1 R8.2 R966.1 U1.CV59
SDM_IO10: R964.1 U1.CC58
SDM_IO11: R481.2 R956.2 U1.CE60
SDM_IO12: R488.2 R960.2 U1.CC56
SDM_IO13: R959.2 U1.CB59
SDM_IO14: R480.2 R962.1 U1.CG60
SDM_IO15: R955.2 U1.CA58
SDM_IO16: R482.2 U1.CA60 U29.V7
SH_CLK: R6035.1 U54.29
SHARE_CLK: R5318.1 U53.D11
SHARE_CLK_1: R5340.1 U58.D11
SI549_CLKN: C818.2 R411.2 U34.15
SI549_CLKP: C817.2 R411.1 U34.14
SI5338_0_CLK0P: R444.1 U36.22
SI5338_0_CLK1N: R442.2 U36.17
SI5338_0_CLK1P: R443.2 U36.18
SI5338_0_CLK2N: R439.2 U36.13
SI5338_0_CLK2P: R440.2 U36.14
SI5338_1_CLK0P: R452.2 U37.22
SI5338_1_CLK1N: R450.2 U37.17
SI5338_1_CLK1P: R451.2 U37.18
SI5338_1_CLK2P: R449.2 U37.14
SI5338_INTR: R437.2 R448.2 U29.J3 U36.8 U37.8
SI5338_OEN: R445.2 R849.2 U29.J4 U36.3 U37.3
SI52202_FS: R970.1 R971.1 U35.11
SI52202_OE3N: R974.1 R975.1 U35.27
SI52202_OEN: R436.1 R848.1 U29.J6 U35.14 U35.16 U35.23
SI52202_PWRDNN: R435.1 R847.1 U23.R8 U35.2
SI52202_SA: R972.1 R973.1 U35.7
SI52202_SS_EN: R433.2 R434.2 U35.1
SI52202_XIN: C824.1 U35.3 Y3.3
SI52202_XOUT: C829.1 U35.4(XOUT) Y3.1
SI53311_CLKOUT1N: C809.1 R409.2 R416.1
SI53311_CLKOUT1P: C810.1 R409.1 R418.1
SI53311_CLKSEL: R423.2 R428.2 R845.1 R918.2 U29.L2 U34.8
SI53311_OE: R412.2 R846.2 U29.L1 U34.12
SMA_REFCLKN: C813.2 R410.1 U34.11
SMA_REFCLKP: C811.2 R410.2 U34.10
SODIMM_I2C_SCL: R105.1 U1.CL46 U2.A1
SODIMM_I2C_SDA: R106.1 U1.CL48 U2.A2
SODIMM_IO_TSN: R108.1 R839.1 U2.B3 U29.D17
SODIMM_REFCLKN: C840.2 R54.2 R55.1 R56.1 R903.1 U1.CL38
SODIMM_REFCLKP: C842.2 R54.1 R57.1 R58.1 R904.1 U1.CN38
SODIMM_RZQ: R53.1 U1.CM39
SODIMM_SA0: CON1.256 R113.2
SODIMM_SA1: CON1.260 R114.2
SODIMM_SA2: CON1.166 R115.2
SODIMM_SCL: CON1.253 R102.2 U2.C1
SODIMM_SDA: CON1.254 R103.2 U2.C2
SODIMM_TYPE0: R990.1 U23.B2 U82.1
SODIMM_TYPE1: R991.1 U23.A2 U82.2
SODIMM_VDD_1P3V_SET: Q5.1 R762.2 U23.C5
SODIMM_VDD_1P35V_SET: Q4.1 R763.2 U23.C4
SODIMM_VDDQ_AGND: Q4.2(SOURCE) Q5.2(SOURCE) R756.2 R762.1 R763.1 R5438.2 R6065.1 R6066.2 R6085.2 ST9.1 U68.E1
STBYN: R400.1 U29.C4 U31.14
SYNC: R5977.1 U54.14
SYNC_1: R5341.1 U58.K12
SYNC_24971985: R5319.1 U53.K12
SYSMAX_I2C_SCL: J51.1 R498.2 R500.1 U29.J2 U35.10 U36.12 U37.12 U45.2 U81.2 Y2.8
SYSMAX_I2C_SDA: J51.2 R497.2 R501.1 U29.J1 U35.9 U36.19 U37.19 U45.3 U81.3 Y2.7
SYSMAX_JTAG_BYPASSN: SW3.2 U23.R15
SYSMAX_JTAG_TCK: R374.2 U23.V12 U29.J8
SYSMAX_JTAG_TDI: R372.2 U23.U11 U29.H3
SYSMAX_JTAG_TDO: U23.U6 U29.H4
SYSMAX_JTAG_TMS: R373.2 U23.T10 U29.J7
SYSMAX_LED_G0: D27.1(CATHODE) U29.B9
SYSMAX_LED_G1: D28.1(CATHODE) U29.C9
SYSMAX_LED_G2: D29.1(CATHODE) U29.C10
SYSMAX_LED_G3: D30.1(CATHODE) U29.D7
SYSMAX_LED_G4: D40.1(CATHODE) U29.A9
SYSMAX_LED_Y0: D33.1(CATHODE) U29.D8
SYSMAX_LED_Y1: D34.1(CATHODE) U29.A5
SYSMAX_PB0: R384.1 S13.2 U29.D1
SYSMAX_PB1: R385.1 S14.2 U29.E1
SYSMAX_PB2: R386.1 S15.2 U29.G3
SYSMAX_PB3: R387.1 S16.2 U29.F2
SYSMAX_PB4: R945.1 S17.2 U29.K4
SYSMAX_PB5: R946.1 S18.2 U29.K3
SYSMAX_SW0: SW5.1 U29.A10
SYSMAX_SW1: SW5.2 U29.A11
SYSMAX_SW2: SW5.3 U29.G10
SYSMAX_SW3: SW5.4 U29.F10
SYSMAX_SW4: SW10.1 U29.K2
SYSMAX_SW5: SW10.2 U29.K1
TDIO_0: C2132.1 U87.36
TDIO_2: C2136.1 U89.36
TDIO_3: C2138.1 U90.36
TDIO_4: C2134.1 U88.36
TEMP_ALERTN: R398.1 U29.A7 U31.18
TSNS0: C1719.1 R1101.2 R1106.2 R1110.2 R5893.2 U54.8
TSNS0_R: C2135.1 R1110.1 U89.22
TSNS0_R_0: C2131.1 R1101.1 U87.22
TSNS0_R_3: C2137.1 R5893.1 U90.22
TSNS0_R_4: C2133.1 R1106.1 U88.22
USB_ADDR0: U1.W48 U23.U13
USB_ADDR1: U1.T49 U23.U12
USB_CFG0: U23.T4 U29.E4
USB_CFG1: U23.U3 U29.C2
USB_CFG2: U23.V2 U29.D2
USB_CFG3: U23.P6 U29.G6
USB_CFG4: U23.P5 U29.H6
USB_CFG5: U23.V3 U29.B1
USB_CFG6: U23.V4 U29.C1
USB_DATA0: U1.U48 U23.M10
USB_DATA1: U1.V47 U23.L10
USB_DATA2: U1.T47 U23.R10
USB_DATA3: U1.N52 U23.R11
USB_DATA4: U1.L52 U23.V13
USB_DATA5: U1.P51 U23.V14
USB_DATA6: U1.M51 U23.R12
USB_DATA7: U1.N50 U23.R13
USB_EMPTY: U1.L48 U23.V15
USB_FPGA_CLK: R301.1 U1.L54
USB_FPGA_CLK_R: R301.2 U23.N11
USB_FULL: U1.N48 U23.T15
USB_MAX_CLK: U23.U9 U29.D4
USB_OEN: U1.M49 U23.R14
USB_RDN: U1.P49 U23.T14
USB_RESETN: U1.A54 U23.P10
USB_SCL: U1.V59 U23.U15
USB_SDA: U1.V57 U23.U16
USB_T_CLK: R977.1 U23.K12
USB_WRN: U1.L50 U23.T13
USERMD: R333.1 R334.1 R844.1 U23.U2 U24.23 U25.23
UV_12V_DCIN: C1408.1 C1874.2 R523.2 SW8.2 SW8.5 U48.3 U48.11
VFB0: C2118.1 R5875.2 R5876.1 U54.12
VID_I2C_ALERTN: R574.1 R5285.2 SW6.6 U54.17
VID_I2C_SCL: R576.1 R5283.2 SW6.8 U54.15
VID_I2C_SDA: R575.1 R5284.2 SW6.7 U54.16
VOSNS_N: C1125.2 R667.1 U59.E9
VOSNS_P: C1125.1 R666.1 U59.D9 U59.H9
VREF_DDR4_COMP_0.6V: C406.1 C407.1 C452.1 C453.1 C498.1 R5387.2 U3.M1 U4.M1 U5.M1 U6.M1 U7.M1
VREF_FPGA_0.6V: C312.1 C313.1 C314.1 C315.1 C316.1 C317.1 C318.1 R98.1 R99.1 U1.AA24(VREFB3DN0) U1.AA26 U1.AA36 U1.AA38 U1.CC24 U1.CC36 U1.CC38
VREF_SODIMM_0.6V: C399.2 C400.1 CON1.164 R5379.2
VSENSE_3.3V_PRE: R528.2 R530.1 U32.9
VSENSE_5V: R546.2 R548.1 U32.10
VSENSE_12VIN: R509.1 R512.1 U32.8
VSENSEN_VCC: C1636.1 R95.2 R951.2 R1074.1 U54.6
VSENSEN_VCCH: C1960.2 C2101.2 R97.2 U57.A12 U57.M12
VSENSEP_VCC: R94.2 R950.2 R1073.2
VSENSEP_VCCH: C1960.1 C2101.1 R96.2 U57.A11 U57.M11
VTT_DDR4_COMP_0.6V: C1561.1 C1562.1 C1563.1 C1564.1 C1565.1 C1566.1 C1567.1 C1568.1 C1569.1 C1570.1 C1571.1 C1572.1 C1573.1 C1574.1 C1575.1 C1576.1 C1577.1 C1578.1 C1579.1 C1580.1 C1581.2 C1582.2 C1583.2 C1584.2 C1585.2 C1783.1 C1784.1 C1815.1 R137.2 R144.2 R1029.2 R1030.2 R1031.2 R1032.2 R1033.2 R1034.2 R1035.2 R1036.2 R1037.2 R1038.2 R1039.2 R1040.2 R1041.2 R1042.2 R1043.2 R1044.2 R1045.2 R1046.2 R1047.2 R1048.2 R1049.2 R1050.2 R1051.2 R1052.2 R5388.1 TP183.1(TP) U69.3
VTT_SODIMM_0.6V: C1457.1 C1458.1 C1461.1 C1775.1 C1776.1 C1814.1 CON1.258(VTT) R5380.1 TP182.1(TP) U67.3
ZQSFP_RXN0: J12.18 U1.AU8
ZQSFP_RXN1: J12.21 U1.BA8
ZQSFP_RXN2: J12.15 U1.AY11
ZQSFP_RXN3: J12.24 U1.BD11
ZQSFP_RXP0: J12.17 U1.AV7
ZQSFP_RXP1: J12.22 U1.BB7
ZQSFP_RXP2: J12.14 U1.AW10
ZQSFP_RXP3: J12.25 U1.BC10
ZQSFP_T_INITMODE: J12.31 R221.2 U14.C1
ZQSFP_T_INTN: J12.28 R222.2 U13.C4
ZQSFP_T_MODPRSN: J12.27 R220.2 U13.C3
ZQSFP_T_MODSELN: J12.8 R218.2 U13.C1
ZQSFP_T_RESETN: J12.9 R219.2 R223.2 U13.C2
ZQSFP_T_SCL: J12.11 R224.1 U14.C3
ZQSFP_T_SDA: J12.12 R225.1 U14.C4
ZQSFP_TXN0: J12.37 U1.AU2
ZQSFP_TXN1: J12.2 U1.BA2
ZQSFP_TXN2: J12.34 U1.AY5
ZQSFP_TXN3: J12.5 U1.BD5
ZQSFP_TXP0: J12.36 U1.AV1
ZQSFP_TXP1: J12.3 U1.BB1
ZQSFP_TXP2: J12.33 U1.AW4
ZQSFP_TXP3: J12.6 U1.BC4
ZQSFP_VCC: C569.1 C570.2 C571.2 C572.2 J12.30 L15.2
ZQSFP_VCCR: C565.1 C566.2 C567.2 C568.2 J12.10 L14.2
ZQSFP_VCCT: C561.1 C562.2 C563.2 C564.2 J12.29(VCCTX) L13.2
N23911: R469.1 R472.2 U38.43(XO_P)
N23923: R915.1 U39.3
N23931: C883.1 C884.1 C885.2 L20.2 R476.1 U39.4(VCC)
N23977: C856.1 U38.7
N23983: C855.1 U38.48
N23993: C857.2 U38.47
N23999: C858.2 U38.39
N24063: C1327.1 U38.6
N24075: C895.1 C896.2 C1336.1 R478.2
N24081: C895.2 U38.18
N31156: C8.1 R74.2
N125826: C1.1 C1600.1 D1.6(VOUT) FB1.1 R15.1 R856.2 R1004.1 R5286.1
N130133: J11.58 R179.1
N132125: J10.58 R178.1
N275652: R191.2 U12.69
N275658: R192.2 U12.66
N275660: R204.2 U12.50
N275666: R205.2 U12.49
N275672: R206.2 U12.47
N275674: R208.2 U12.46
N275700: R193.2 U12.65
N396676: R534.2 U50.4
N396772: R534.1 R535.2 U51.5
N396880: R533.2 R539.2 U51.3
N396890: R536.1 R537.1 R538.2 U51.8
N397044: R539.1 R540.1 U51.2
N3916294: R513.1 U47.4
N3918231: C958.2 R518.2
N3967240: C970.1 R535.1
N16786734: R249.2 U15.17 U15.18 U15.19 U15.20
N16786764: R250.2 U15.7 U15.9 U15.11 U15.12 U15.14 U15.16
N16787300: D2.1(CATHODE) R263.2
N16787302: D5.1(CATHODE) R266.2
N16787306: D6.1(CATHODE) R267.2
N16787308: D4.1(CATHODE) R265.2
N16787759: C636.2 R261.1 R262.1
N16787774: C634.2 R257.1 R258.1
N16787789: C633.2 R255.1 R256.1
N16787795: C635.2 R259.1 R260.1
N17395836: R462.2 U38.32
N17488683: D3.1(CATHODE) R264.2
N17488777: R254.2 U15.47
N17498635: C1858.2 R5287.2 U33.8
N17498650: C1859.2 R5288.2 U33.9
N17498657: C1860.2 R5289.2 U33.10
N17498664: C805.1 C806.2 R406.2 R407.2 U33.29
N17498668: C1861.2 R5290.2 U33.11
N17498677: C1862.2 R5291.2 U33.12
N17498690: C1863.2 R5292.2 U33.13
N17498697: C1864.2 R5293.2 U33.14
N17498704: C1865.2 R5294.2 U33.15
N17498716: U33.26 U33.27
N17498720: U33.24 U33.25
N17498798: C807.2 C808.2 R408.1 R5304.2 U33.28(VCC)
N17552728: R446.1 X3.1
N17552752: R447.2 X3.3
N17579378: C811.1 J24.1
N17579380: C813.1 J25.1
N17579486: R421.2 U34.5
N17579540: C821.1 C822.1 FB6.2 U34.18 U34.19
N17579564: C823.1 FB5.2 U34.7
N17579627: R426.2 Y2.5
N17579701: R427.2 Y2.4
N17579748: C819.1 C820.2 FB4.1 Y2.6(VDD)
N17585195: R418.2 U34.32
N17585196: R416.2 U34.31
N17585199: R414.2 U34.30
N17585200: R413.2 U34.29
N17645458: C632.1 FB15.1 X1.4(VCC)
N17645502: R252.1 X1.1
N17771286: C871.2 R941.2
N17771287: C871.1 U38.34
N17771288: C872.2 R942.2
N17771289: C872.1 U38.33
N17771290: R465.2 U38.51
N17771292: R466.2 U38.52
N17958439: R337.1 U23.G9
N17958472: R338.1 U23.H9
N17958492: R335.1 U23.H8
N17958512: R336.1 U23.G8
N18010178: R481.1 R482.1 R483.2 R488.1 R491.1 R493.1 R497.1 U43.3
N18012016: Q2.C R4.1
N18012042: Q2.B R6.1
N18012643: Q1.C R3.1
N18012671: Q1.B R5.1
N18013119: Q3.C R8.1
N18013147: Q3.B R13.1
N18020316: D15.2 R344.2
N18020362: D16.2 R347.2
N18020410: D17.2 R348.2
N18020456: D18.2 R352.2
N18023785: D19.2 R363.2
N18023927: D20.2 R364.2
N18024322: D23.2 R367.2
N18024422: D24.2 R368.2
N18053910: C686.1 R356.2
N18056724: R480.1 R485.2 R487.1 R490.1 R494.1 R498.1 U43.2
N18062592: R371.2 U29.H7
N18062696: R375.1 U29.H8
N18062710: R376.1 U29.G8
N18062736: R377.1 U29.G9
N18062750: R378.1 U29.H9
N18126676: R423.1 Y2.2
N18127220: C809.2 J22.1
N18127283: C810.2 J23.1
N18127388: R420.2 U34.4
N18128409: C825.1 FB7.2 U35.5
N18128416: C826.1 FB8.2 U35.6
N18128423: C827.1 FB9.2 U35.31
N18128430: C828.1 C1592.1 FB10.2 U35.15 U35.24
N18161324: C842.1 R443.1 R904.2
N18161585: R438.1 X2.1
N18161617: R441.2 X2.3
N18161939: C853.1 R451.1 R905.2
N18163063: R514.1 R515.2 U48.13
N18164181: R522.2 SW8.1 SW8.4
N18167209: D38.2 R541.1
N18195244: D27.2 R389.2
N18195269: D28.2 R388.2
N18195294: D29.2 R390.2
N18195319: D30.2 R391.2
N18195394: D33.2 R394.2
N18195419: D34.2 R395.2
N18253290: C1866.2 R5295.2 U33.16
N18253296: C1868.2 R5297.2 U33.18
N18253303: C1870.2 R5299.2 U33.20
N18253309: C1872.2 R5301.2 U33.22
N18253428: C1867.2 R5296.2 U33.17
N18253441: C1869.2 R5298.2 U33.19
N18253449: C1871.2 R5300.2 U33.21
N18253452: C1873.2 R5302.2 U33.23
N18402226: R408.2 U33.36
N18402261: U31.10 U31.11
N18402270: U31.12 U31.13
N18402344: C815.1 R420.1
N18402365: C816.1 R421.1
N18403594: C875.2 R943.2
N18403603: C876.2 R944.2
N18514026: R469.2 R915.2
N18524153: C875.1 U38.54
N18524156: C876.1 U38.53
N18602357: C814.1 R414.1 R900.2
N18602360: C812.1 R413.1 R899.2
N18602409: C838.1 R439.1 R901.2
N18602412: C839.1 R440.1 R902.2
N18606410: C840.1 R442.1 R903.2
N18606472: C852.1 R450.1 R906.2
N18609511: J34.1 R909.2
N18623017: J4.1 R38.2 R44.1
N18624288: C1326.2 J3.1 R43.1
N18624358: C1325.2 J2.1 R33.1
N18624759: J1.1 R35.1 R38.1
N18630621: R502.2 R505.1 U44.7(WP)
N18669847: J31.1 R463.1 R467.2
N18693741: R981.1 U29.K11
N18765279: R511.2 R519.2 U48.12
N18905531: D7.2 R284.2
N18905534: D8.2 R285.2
N18905537: D9.2 R286.2
N18905540: D10.2 R287.2
N18905543: D11.2 R288.2
N18905546: D12.2 R289.2
N18905549: D13.2 R290.2
N18905552: D14.2 R291.2
N18905648: D7.1(CATHODE) U18.A7
N18905651: D8.1(CATHODE) U18.A5
N18905652: D9.1(CATHODE) U18.A3
N18905655: D10.1(CATHODE) U18.A1
N18905658: D11.1(CATHODE) U19.A7
N18905661: D12.1(CATHODE) U19.A5
N18905664: D13.1(CATHODE) U19.A3
N18905667: D14.1(CATHODE) U19.A1
N18946338: C869.1 R461.1
N18946341: C870.1 R462.1
N18946378: C874.1 R466.1
N18946381: C873.1 R465.1
N18946492: C9.2 J6.1
N18946522: C10.2 J7.1
N18947324: C817.1 R427.1
N18947380: C818.1 R426.1
N18990186: J20.4 R401.2
N18990548: J20.3(TACH) R402.1
N18990901: J21.3(TACH) R404.1
N18990913: J21.4 R403.2
N18991424: C801.1 C802.2 R405.2 U32.29
N19408572: U48.16 V2.2(SNS)
N19408581: U48.15 V3.2(SNS)
N19408803: R997.2 R998.2 U47.5 U47.6 U47.7 U47.8 V3.1
N19548147: R463.2 R464.2
N19604200: C854.1 U38.38
N19604697: R461.2 U38.31
N19994036: J50.1 R1053.2
N19994522: C896.1 R909.1
N20035658: C1333.1 C1334.1 C1335.2 L40.2 R916.1 U80.4(VCC)
N20035742: R916.2 R919.1 U80.1
N20035757: R917.2 U80.3
N20035759: C1336.2 R917.1
N20209521: R918.1 Y2.1
N20307193: C1409.2 R294.2 R922.1 U22.3
N20316908: J14.B6 R236.2 R929.2
N20316912: J14.B5 R235.2 R930.2
N20436774: D40.2 R939.2
N20439947: J28.1 R941.1 R943.1
N20439969: J30.1 R942.1 R944.1
N20550259: C861.1 R458.1 R907.2
N20550288: R458.2 U38.57
N20550319: R459.2 U38.58
N20550321: C866.1 R459.1 R908.2
N20604615: R429.2 U35.12
N20604632: R430.2 U35.13
N20604649: R431.2 U35.17
N20604666: R432.2 U35.18
N20604729: R968.2 U35.21
N20604746: R969.2 U35.22
N20605183: C1590.1 C1591.1 FB14.2 U35.19 U35.29
N20633771: D36.2 R520.1
N20675466: R976.2 U15.8
N20675700: R977.2 U21.13
N20718622: R984.1 R985.1 U32.7
N20723038: R987.1 R988.2 U82.4
N20723060: R992.1 U82.14
N20723062: R993.1 U82.13
N20723064: R994.1 U82.11
N20723066: R995.1 U82.9
N20723111: R988.1 R989.2 U82.6
N20759675: U83.4 U84.3
N20841727: J14.B12 R1001.2
N20876118: R1003.2 U34.13
N20976353: C957.2 U48.6
N21145502: R1006.2 U3.T7
N21146103: R1007.2 U4.T7
N21146535: R1008.2 U5.T7
N21146960: R1009.2 U6.T7
N21147395: R1010.2 U7.T7
N21454939: R1053.1 U38.61
N21652883: TP21.1(TP) U35.25
N21652886: TP22.1(TP) U35.26
N22210877: R1064.2 R1065.2 U79.B3
N22372085: D37.2 R529.2
N22589790: R12.2 U1.CA54
N22603807: R59.1 R60.1 R940.2 U1.CN52
N22603824: R61.2 R62.1 R1025.2 U1.CG50
N22614955: R937.1 U1.M41
N22614989: R948.2 R949.1 R1026.2 U1.L40
N22615026: R69.2 R70.1 R1027.2 U1.U38
N22627676: R85.2 U1.AN20
N22627752: R858.2 U1.AJ14
N22627766: R859.2 U1.AL14
N22627780: R860.2 U1.AR16
N22627794: R861.2 U1.AN16
N22627808: R862.2 U1.AJ16
N22627822: R863.2 U1.AL16
N22627836: R864.2 U1.AH15
N22627850: R865.2 U1.AK15
N22627864: R866.2 U1.AH17
N22627870: R867.2 U1.AK17
N22633196: R87.2 U1.BH49
N22633206: R86.1 U1.BM43
N22823355: R938.1 U1.M55
N22823445: R71.2 R72.1 R1028.2 U1.U52
N23258622: J35.9 TP32.1(TP)
N23258640: J35.10 TP33.1(TP)
N23628441: C519.2 R145.2 R146.2
N24167599: C803.2 C804.2 R5303.2 U32.28(VCC)
N24972008: TP191.1(TP) U53.D12
N24972013: C989.2 C990.2 C991.2 C992.2 C993.2 C994.2 C995.2 R5312.1 U53.E1 U53.E2 U53.E3 U53.E4 U53.F1 U53.F2 U53.F3 U53.F4 U53.G1 U53.G2 U53.G3 U53.G4 U53.H1 U53.H2 U53.H3 U53.H4 U53.K1
N24972044: R553.1 U53.F12
N24972552: C987.1 R559.2 U53.A12 U53.M12
N24972568: C987.2 R558.2 U53.A11 U53.M11
N24972677: U53.J8 U53.J11
N24972695: U53.D8 U53.J10
N24972725: R5322.2 U53.E11 U53.E12
N24972803: C988.1 U53.E7
N24972848: R5320.2 U53.E9
N24972862: C1900.2 U53.D10 U53.J9
N24972885: C1899.2 U53.C10 U53.H9
N24973349: D39.2 R573.2
N24979883: TP192.1(TP) U58.D12
N24979885: C1107.2 C1108.2 C1109.2 C1110.2 C1111.2 C1112.2 C1113.2 R5323.1 U58.E1 U58.E2 U58.E3 U58.E4 U58.F1 U58.F2 U58.F3 U58.F4 U58.G1 U58.G2 U58.G3 U58.G4 U58.H1 U58.H2 U58.H3 U58.H4 U58.K1
N24979910: R5324.1 U58.F12
N24980412: C1105.1 R644.2 U58.A12 U58.M12
N24980428: C1105.2 R643.2 U58.A11 U58.M11
N24980537: U58.J8 U58.J11
N24980555: U58.D8 U58.J10
N24980585: R5330.2 U58.E11 U58.E12
N24980595: R6038.2 U58.C12 U58.E10
N24980663: C1921.1 U58.E7
N24980708: R5333.2 U58.E9
N24980722: C1922.2 U58.D10 U58.J9
N24980745: C1923.1 U58.C10 U58.H9
N24984146: R744.2 R746.1 R747.2 U67.7
N24984160: C1779.1 R1151.2 R1152.1 U67.1
N24984332: C1777.1 R5379.1 U67.6
N24984340: R5380.2 U67.5(VTTS)
N24985018: R765.2 R766.1 R767.2 U69.7
N24985032: C1782.1 R1153.2 R1154.1 U69.1
N24985204: C1843.1 R5387.1 U69.6
N24985212: R5388.2 U69.5(VTTS)
N25067542: C1138.1 C1140.1 C1141.1 R681.1 U60.C10 U60.C11 U60.D10 U60.D11 U60.E9 U60.E10 U60.E11 U60.F9 U60.F10(VOUT_9) U60.F11 U60.G9 U60.G10 U60.G11 V8.1
N25071143: TP39.1(TP) U60.B3
N25071146: TP40.1(TP) U60.F2
N25073319: C1937.2 R5393.1 U60.F5
N25073405: C1937.1 U60.F6
N25074810: R680.1 R682.1 R686.1 U60.F1
N25075439: R6090.1 U60.E3
N25076947: R693.1 R694.1 R695.1 U61.F1
N25077139: C1939.2 R5402.1 U61.F5
N25077159: C1939.1 U61.F6
N25077254: TP41.1(TP) U61.B3
N25077268: TP42.1(TP) U61.F2
N25077282: C1148.1 C1149.1 C1150.1 R690.2 U61.C10 U61.C11 U61.D10 U61.D11 U61.E9 U61.E10 U61.E11 U61.F9 U61.F10(VOUT_9) U61.F11 U61.G9 U61.G10 U61.G11 V10.1
N25080456: R701.1 R702.1 R704.1 U62.F1
N25080712: R6088.1 U62.E3
N25080763: TP43.1(TP) U62.B3
N25080777: TP44.1(TP) U62.F2
N25080791: C1156.1 C1157.1 C1158.1 R703.1 U62.C10 U62.C11 U62.D10 U62.D11 U62.E9 U62.E10 U62.E11 U62.F9 U62.F10(VOUT_9) U62.F11 U62.G9 U62.G10 U62.G11 V12.1
N25083983: R1013.1 R1014.1 R1018.1 U63.F1
N25084239: R6087.1 U63.E3
N25084282: TP45.1(TP) U63.B3
N25084289: TP46.1(TP) U63.F2
N25084297: C1614.1 C1615.1 C1616.1 R1024.2 U63.C10 U63.C11 U63.D10 U63.D11 U63.E9 U63.E10 U63.E11 U63.F9 U63.F10(VOUT_9) U63.F11 U63.G9 U63.G10 U63.G11 V24.1
N25087496: R719.1 R722.1 R724.1 U64.F1
N25087752: R6086.1 U64.E3
N25087795: TP47.1(TP) U64.B3
N25087802: TP48.1(TP) U64.F2
N25087810: C1171.1 C1172.1 C1173.1 R718.2 U64.C10 U64.C11 U64.D10 U64.D11 U64.E9 U64.E10 U64.E11 U64.F9 U64.F10(VOUT_9) U64.F11 U64.G9 U64.G10 U64.G11 V16.1
N25089948: Q5.3 R759.2
N25089950: Q4.3 R760.1
N25093122: R751.1 R754.1 R756.1 U68.F1
N25093395: R6085.1 U68.E3
N25093446: TP49.1(TP) U68.B3
N25093460: TP50.1(TP) U68.F2
N25093474: C1201.1 C1202.1 C1203.1 R750.1 U68.C10 U68.C11 U68.D10 U68.D11 U68.E9 U68.E10 U68.E11 U68.F9 U68.F10(VOUT_9) U68.F11 U68.G9 U68.G10 U68.G11 V22.1
N25097889: R770.1 R771.1 R775.1 U70.F1
N25098162: R6084.1 U70.E3
N25098205: TP51.1(TP) U70.B3
N25098212: TP52.1(TP) U70.F2
N25103528: R779.1 R780.1 R784.1 U71.F1
N25103769: R6083.1 U71.E3
N25103808: TP53.1(TP) U71.B3
N25103813: TP54.1(TP) U71.F2
N25185713: U57.D8 U57.J10
N25191935: R1134.2 U57.F12
N25191949: R5964.2 U57.E9
N25191963: R5963.2 U57.E10
N25191977: R5692.2 U57.C12
N25192006: R5690.2 U57.E11 U57.E12
N25192932: R5461.2 U57.C11(WP)
N25195277: TP56.1(TP) U57.D12
N25195480: C1962.2 U57.C10 U57.H9
N25195483: C1961.1 U57.D10 U57.J9
N25196395: C2063.1 U57.E7
N25201801: C1788.2 C1789.2 C1790.2 C1791.2 C1792.2 C1793.2 C1794.2 C1795.2 R5996.1 U57.E1 U57.E2 U57.E3 U57.E4 U57.F1 U57.F2 U57.F3 U57.F4 U57.G1 U57.G2 U57.G3 U57.G4 U57.H1 U57.H2 U57.H3 U57.H4 U57.K1
N25221363: U59.G1 U59.G2
N25221372: U59.H1 U59.H2
N25221411: TP60.1(TP) U59.J9
N25221426: R5466.2 U59.K5
N25221435: R5466.1 U59.J5
N25222718: R5467.2 U59.M5
N25223016: R5468.2 U59.A5
N25223355: U59.E1 U59.E2
N25223364: U59.F1 U59.F2
N25223394: TP62.1(TP) U59.E10
N25223409: TP63.1(TP) U59.D10
N25223521: R5470.2 U59.D8
N25223524: C1966.1 C1967.1 R5470.1 R5472.2 U59.E8 U59.H8
N25223625: C1967.2 R5469.1
N25223886: U59.C5 U59.D5
N25223987: R670.1 U59.J7
N25224168: R671.1 R676.1 U59.E5
N25224802: R5473.1 U59.E7
N25224806: R5474.1 U59.H7
N25224899: TP64.1(TP) U59.J6
N25225151: R661.1 R662.2 R663.1 U59.F5 U59.F6
N25225249: R5475.2 U59.K6(WP)
N25225605: R668.2 U59.G4
N25225851: R5476.2 U59.H4
N25225898: R5479.1 U59.G5 U59.G6
N25226074: R5480.2 U59.H6
N25559442: R2298.1 U52.A4
N25559469: C2047.2 R5994.1 U52.B1
N25559519: C1827.2 U52.A2
N25560953: R543.1 R544.1 R547.2 U52.A3
N25561938: R5995.2 U52.B2
N25724466: C1636.2 R1073.1 R1074.2 U54.7
N25726246: C2001.1 U54.28
N25726251: C2000.1 U54.30
N25726256: C2002.1 U54.31
N25727503: R5978.2 U54.22
N25727508: R5979.2 U54.23
N25727513: R5980.2 U54.24
N25727518: R5981.2 U54.25
N25727970: R6042.2 U54.21
N25730178: C2114.1 C2115.1 C2116.1 C2117.1 R5881.1 R5882.1 R5883.1 R5997.1 R6041.2
N25850730: L1.1 U87.1 U87.2 U87.3 U87.4 U87.5 U87.6 U87.10 U87.11 U87.12 U87.13 U87.14 U87.15 U87.16 U87.42
N25855201: R1100.2 U87.35
N25856429: C1652.1 R1098.1 R6092.2 U87.30
N25858612: L47.1 U88.1 U88.2 U88.3 U88.4 U88.5 U88.6 U88.10 U88.11 U88.12 U88.13 U88.14 U88.15 U88.16 U88.42
N25863309: R1105.2 U88.35
N25864351: C1978.1 R5971.1 R6099.2 U88.30
N25870219: C1997.1 R5972.1 R6097.2 U89.30
N25870304: R1111.2 U89.35
N25870339: L48.1 U89.1 U89.2 U89.3 U89.4 U89.5 U89.6 U89.10 U89.11 U89.12 U89.13 U89.14 U89.15 U89.16 U89.42
N25872874: L49.1 U90.1 U90.2 U90.3 U90.4 U90.5 U90.6 U90.10 U90.11 U90.12 U90.13 U90.14 U90.15 U90.16 U90.42
N25876113: R5894.2 U90.35
N25876514: C2016.1 R5973.1 R6098.2 U90.30
N25909303: C1181.1 C1182.1 C2076.1 R728.1 U65.C1 U65.D1 U65.D2 U65.E1 U65.E2(VOUT_4) V18.1
N25909350: R5999.2 U65.B2
N25909438: C2076.2 R6006.1 U65.B1
N25909453: R731.1 R732.1 R734.2 U65.A3
N25909472: C2079.2 U65.A2
N25909496: R6005.1 U65.A4
N25913434: C1184.1 C1186.1 C1976.1 R736.1 U66.C1 U66.D1 U66.D2 U66.E1 U66.E2(VOUT_4) V20.1
N25913473: R739.1 R740.1 R742.2 U66.A3
N25913475: R6009.2 U66.B2
N25913538: C1976.2 Q7.3 R5970.1 U66.B1
N25913563: C1975.2 U66.A2
N25913583: R6013.1 U66.A4
N25915448: Q7.2(SOURCE) R6040.1
N25917150: R791.1 R6015.1 R6019.2 U72.A3
N25917152: R6016.2 U72.B2
N25917215: C2091.2 R794.1 U72.B1
N25917240: C2094.2 U72.A2
N25917264: R5484.1 U72.A4
N26156636: R6020.2 U52.C4
N26156701: C2097.1 U52.A1
N26158546: C2098.1 U72.A1
N26159018: R6021.2 U72.C4
N26162210: C2099.1 U66.A1
N26162577: R6022.2 U66.C4
N26162974: R6023.2 U65.C4
N26163028: C2100.1 U65.A1
N26226036: R6089.1 U61.E3
N26297360: U57.J8 U57.J11
N26399332: R6097.1 U89.32
N26399369: R6098.1 U90.32
N26399427: R6099.1 U88.32
N26399451: R6092.1 U87.32
N26497673: R1125.2 U49.C2
N26497696: R6027.2 U49.B2
N26497698: R6028.2 U49.C4
N26497767: C489.2 R1121.1 U49.B1
N26497799: R1119.2 R1126.2 U49.A3
N26497801: C497.2 U49.A2
N26497825: R6034.1 U49.A4
N26497837: C2108.1 U49.A1
N26695392: R6036.2 U54.27
N26845113: TP65.1(TP) U61.C3 U61.C4 U61.C5
N26845603: TP73.1(TP) U49.B5
N26845606: TP72.1(TP) U49.A5
N26846478: TP79.1(TP) U59.B10
N26847129: TP80.1(TP) U59.L10
N26848007: TP91.1(TP) U53.L2 U53.M1 U53.M2
N26848031: TP92.1(TP) U53.A1 U53.A2 U53.B2
N26848630: TP97.1(TP) U58.L2 U58.M1 U58.M2
N26848647: TP98.1(TP) U58.A1 U58.A2 U58.B2
N26850674: TP107.1(TP) U57.L2 U57.M1 U57.M2
N26850713: TP108.1(TP) U57.A1 U57.A2 U57.B2
N26850842: TP109.1(TP) U60.C3 U60.C4 U60.C5
N26851640: TP122.1(TP) U62.C3 U62.C4 U62.C5
N26851765: TP123.1(TP) U63.C3 U63.C4 U63.C5
N26852289: TP132.1(TP) U64.C3 U64.C4 U64.C5
N26852333: TP133.1(TP) U65.A5
N26852348: TP134.1(TP) U65.B5
N26852460: TP138.1(TP) U66.B5
N26852462: TP139.1(TP) U66.A5
N26853301: TP154.1(TP) U68.C3 U68.C4 U68.C5
N26854304: TP163.1(TP) U70.C3 U70.C4 U70.C5
N26854498: TP164.1(TP) U71.C3 U71.C4 U71.C5
N26999540: TP187.1(TP) U72.A5
N26999551: TP188.1(TP) U72.B5
N27071338: R5472.1 U59.J8
N27114897: R5478.2 U59.H5
N27378058: TP189.1(TP) U52.B5
N27378060: TP190.1(TP) U52.A5
N27525479: C1941.2 R5411.1 U62.F5
N27525532: C1941.1 U62.F6
N27527172: C1943.2 R5420.1 U63.F5
N27527188: C1943.1 U63.F6
N27529227: C1945.2 R5429.1 U64.F5
N27529243: C1945.1 U64.F6
N27530223: C1953.2 R5438.1 U68.F5
N27530239: C1953.1 U68.F6
N27532729: C1956.2 R5447.1 U70.F5
N27532745: C1956.1 U70.F6
N27536476: C1959.2 R5456.1 U71.F5
N27536492: C1959.1 U71.F6
N27875059: R6093.2 U87.34
N27875090: R6094.2 U88.34
N27875121: R6095.2 U89.34
N27875145: R6096.2 U90.34
N28019144: R116.1 U3.F9(ZQ0)
N28022993: R117.1 U4.F9(ZQ0)
N30715060: R120.1 U5.F9(ZQ0)
N30715756: R121.1 U6.F9(ZQ0)
N30729048: R135.1 U7.F9(ZQ0)
N30732060: R124.2 U7.A3
N30732063: R125.2 U7.B8
N30732066: R126.2 U7.C3
N30732069: R127.2 U7.C7
N30732072: R128.2 U7.C2
N30732075: R129.2 U7.C8
N30732078: R130.2 U7.D3
N30732081: R131.2 U7.D7
N30732436: R132.2 U7.E2
N30732839: R133.2 U7.B7
N30732842: R134.2 U7.A7
N31213276: C837.1 U36.2 Y4.1
N31213293: C830.1 U36.1 Y4.3
N31214782: C847.1 U37.2 Y5.1
N31214799: C843.1 U37.1 Y5.3
N31558092: R118.1 U3.E9
N31558448: R119.1 U4.E9
N31558945: R122.1 U5.E9
N31559300: R123.1 U6.E9
N31559457: R136.1 U7.E9
N31873956: U32.26 U32.27
N31873974: U32.24 U32.25
N32494365: R415.2 R417.2 U34.22
N32494380: R422.2 R424.2 U34.3
N32575920: R419.2 U34.23
N32575923: R425.2 U34.2
N34015045: C956.2 U48.5
N34015049: R513.2 R518.1 U48.9
N2499545414: R313.1 U24.22
N2499545415: R315.1 U24.21
N2499545416: R317.1 U24.20
N2499545417: R319.1 U24.19
N2499545418: R321.1 U24.18
N2499545419: R323.1 U24.17
N2499545420: R325.1 U24.16
N2499545421: R327.1 U24.15
N2499545422: R329.1 U24.14
N2499545423: R331.1 U24.13
N2499548814: R314.1 U25.22
N2499548815: R316.1 U25.21
N2499548816: R318.1 U25.20
N2499548817: R320.1 U25.19
N2499548818: R322.1 U25.18
N2499548819: R324.1 U25.17
N2499548820: R326.1 U25.16
N2499548821: R328.1 U25.15
N2499548822: R330.1 U25.14
N2499548823: R332.1 U25.13
