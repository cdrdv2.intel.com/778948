# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_A11: length 133.1
  TOP w0.109: U5.T2 113.38,153.32 v2(112.82,153.87) ; U6.T2 v2(124.43,153.72) ; U4.T2 v2(101.57,153.72) ; U7.T2 v2(79.52,153.73) ; U3.T2 v2(90.14,153.72)
  TOP w0.175: R1039.1 v2(125.19,156.34)
  ART03 w0.114: v2(90.14,153.72) 88.82,155.04 84.83,155.04 84.45,154.66 79.63,154.66 79.52,154.55 v2(79.52,153.73)
  ART03 w0.165: v2(79.52,153.73) 80.04,154.25 80.69,154.25 83.56,151.38 83.56,149.2 82.41,148.04 82.41,143.35 83.53,142.22 83.53,141.18 84.25,140.46 88.16,140.46 88.76,139.86 88.99,139.86 89.28,140.15 89.51,140.15 89.72,139.94 89.72,139.71 89.43,139.42 89.43,139.19 89.64,138.98 89.87,138.98 90.16,139.27 90.39,139.27 90.6,139.06 90.6,138.83 90.31,138.54 90.31,138.31 90.52,138.1 90.75,138.1 91.04,138.39 91.27,138.39 91.48,138.18 91.48,137.95 91.19,137.66 91.19,137.43 91.4,137.22 91.63,137.22 91.92,137.51 92.15,137.51 92.36,137.3 92.36,137.07 92.07,136.78 92.07,136.55 92.28,136.34 92.51,136.34 92.8,136.63 93.03,136.63 93.24,136.42 93.24,136.19 92.95,135.9 92.95,135.67 93.16,135.46 93.39,135.46 93.68,135.75 93.92,135.75 94.12,135.54 94.12,135.31 93.83,135.02 93.83,134.79 94.04,134.58 94.27,134.58 94.56,134.87 94.8,134.87 95,134.66 95,134.43 94.71,134.14 94.71,133.91 94.92,133.7 95.15,133.7 95.44,133.99 95.68,133.99 95.88,133.78 95.88,133.55 95.59,133.26 95.59,133.03 95.8,132.82 96.03,132.82 96.32,133.11 96.56,133.11 96.76,132.9 96.76,132.67 96.47,132.38 96.47,132.15 98.96,129.66 98.96,129.43 98.57,129.04 98.57,128.81 98.78,128.6 99.01,128.6 99.4,128.99 99.63,128.99 99.84,128.78 99.84,128.55 99.45,128.16 99.45,127.93 99.66,127.72 99.89,127.72 100.28,128.11 100.51,128.11 101.37,127.25 101.37,115.38 101.1,115.11 100.73,115.11 100.23,114.6 99.9,114.6 99.34,114.05 98.98,114.05 98.47,113.54 98.12,113.54 97.59,113.01 97.2,113.01 96.84,112.65 96.33,112.65 95.88,113.1 v2(94.87,113.1)
  ART05 w0.114: v2(124.43,153.72) 124.14,153.72 123.99,153.57 123.99,153.57 123.78,153.36 123.46,153.36 123.14,153.68 123.14,154.33 122.41,155.05 118.72,155.75 116.38,155.75 115.85,155.22 114.17,155.22 v2(112.82,153.87) 112.37,153.42 111.95,153.42 109.63,155.73 105.84,155.73 105.72,155.62 105.72,155.31 105.61,155.19 105.26,155.19 105.15,155.31 105.15,155.62 105.04,155.73 103.74,155.73 101.72,153.72 v2(101.57,153.72) 101.37,153.72 100.99,153.34 100.61,153.34 99.49,154.46 98.3,155.35 97.58,155.78 93.88,155.78 93.22,155.12 92.68,155.12 92.57,155.23 92.57,155.41 92.45,155.52 92.11,155.52 91.99,155.41 91.99,155.23 91.88,155.12 91.26,155.12 90.14,154 v2(90.14,153.72)
  ART05 w0.165: v2(124.43,153.72) 125.05,154.35 125.05,156.2 v2(125.19,156.34)
DDR4_COMP_A12: length 132.1
  TOP w0.109: U5.M7 v2(109.8,150.52) ; U3.M7 v2(86.94,150.52) ; v2(75.57,149.66) U7.M7 ; U6.M7 v2(121.23,150.52) ; U4.M7 v2(98.37,150.52)
  ART03 w0.165: v2(75.57,149.66) 75.11,149.2 75.11,148.68 74.94,148.51 73.51,148.51 73.4,148.41 72.81,148.41 72.64,148.25 72.64,140.59 72.84,140.38 73.14,140.38 73.3,140.22 73.3,140.04 73.47,139.88 73.76,139.88 73.92,140.04 73.92,140.22 74.09,140.38 74.46,140.38 74.67,140.18 74.67,139.94 73.98,139.26 73.98,139.02 74.19,138.82 74.42,138.82 75.11,139.5 75.34,139.5 75.55,139.3 75.55,139.06 74.86,138.38 74.86,138.14 75.07,137.94 75.3,137.94 75.75,138.39 76.19,138.39 82.06,132.51 82.06,132.08 80.94,130.95 80.94,130.72 81.14,130.51 81.38,130.51 82.5,131.64 82.74,131.64 82.94,131.43 82.94,131.2 81.82,130.07 81.82,129.84 82.02,129.63 82.26,129.63 83.38,130.76 83.62,130.76 83.82,130.55 83.82,130.32 82.7,129.19 82.7,128.96 82.9,128.75 83.14,128.75 84.26,129.88 84.5,129.88 84.7,129.67 84.7,129.44 83.58,128.31 83.58,128.08 83.78,127.87 84.02,127.87 85.14,129 85.38,129 86.28,128.09 86.28,125.86 89.25,122.88 89.25,120.9 89.56,120.6 89.94,120.6 90.45,120.09 90.68,120.09 91.11,119.66 91.56,119.66 91.84,119.38 91.84,118.41 92.2,118.06 92.43,118.06 92.71,117.78 92.71,116.31 92.28,115.87 v2(92.28,115.6)
  ART07 w0.109: 86.26,150.13 86.54,150.13 v2(86.94,150.52) 86.96,150.54 87.83,150.54
  ART07 w0.114: 86.26,150.13 84.02,150.13 83.99,150.15 82.92,150.15 82.29,150.78 81.82,150.78 81.7,150.9 81.7,151.03 81.59,151.15 81.25,151.15 81.13,151.03 81.13,150.94 81.02,150.83 80.77,150.83 80.69,150.74 80.6,150.74 80.48,150.62 80.03,150.62 79.75,150.9 78.59,150.9 78.36,150.67 78.36,150.39 78.26,150.29 77.86,150.29 77.74,150.41 77.74,150.47 77.63,150.59 77.29,150.59 77.17,150.47 77.17,150.41 77.06,150.29 76.75,150.29 76.64,150.18 76.64,150.15 76.52,150.04 76.18,150.04 76.07,150.15 76.07,150.18 75.95,150.29 75.66,150.29 75.44,150.07 75.44,149.79 v2(75.57,149.66) ; 87.83,150.54 87.91,150.46 88.37,150.46 88.7,150.14 92.17,150.14 92.29,150.25 92.29,150.43 92.4,150.54 92.74,150.54 92.86,150.43 92.86,150.25 92.97,150.14 93.32,150.14 93.43,150.25 93.43,150.43 93.54,150.54 94.03,150.54 94.09,150.61 94.39,150.61 94.49,150.51 94.49,149.91 95.1,149.3 96.9,149.3 97.15,149.55 97.15,149.83 97.46,150.14 97.99,150.14 v2(98.37,150.52) 98.7,150.52 98.85,150.37 98.89,150.37 99,150.25 99,150.05 99.12,149.94 99.46,149.94 99.57,150.05 99.57,150.25 99.69,150.37 100.05,150.37 100.35,150.67 100.35,151.1 100.51,151.26 100.99,151.26 101.32,150.93 103.64,150.93 103.75,151.04 103.75,151.26 103.86,151.37 104.21,151.37 104.32,151.26 104.32,151.04 104.44,150.93 105.16,150.93 106.05,150.04 106.98,150.04 107.06,150.11 109.1,150.11 109.15,150.15 109.15,150.15 109.52,150.52 v2(109.8,150.52) 110.28,150.52 110.61,150.85 110.85,150.85 111.03,150.67 111.48,150.67 111.65,150.85 111.91,150.85 111.99,150.93 112.56,150.93 112.67,151.04 112.67,151.34 112.73,151.41 113.18,151.41 113.24,151.34 113.24,151.04 113.36,150.93 115.19,150.93 115.38,151.12 115.76,151.12 115.95,150.93 116.37,150.93 116.49,151.04 116.49,151.4 116.6,151.51 116.9,151.51 117.06,151.35 117.06,151.04 117.17,150.93 117.45,150.93 118.23,150.14 120.62,150.14 121,150.52 v2(121.23,150.52)
  ART07 w0.165: v2(121.23,150.52) 122.86,150.52 123.5,150.91 126.68,150.91 127.13,150.7 127.28,150.55 v2(127.29,150.55)
  BOTTOM w0.175: v2(127.29,150.55) 127.3,150.56 128.17,150.56 128.19,150.58 128.26,150.58 R1042.1
DDR4_COMP_A13: length 126.4
  TOP w0.109: U6.T8 v2(119.63,153.72) ; U5.T8 v2(108.2,153.72) ; U3.T8 v2(85.34,153.72) ; U7.T8 v2(73.91,153.72) ; U4.T8 v2(96.77,153.72)
  TOP w0.175: R1048.1 v2(119.86,156.34)
  ART03 w0.165: v2(119.86,156.34) 120.1,156.1 120.1,154.19 v2(119.63,153.72) ; v2(91.41,117.1) 91.41,116.78 91.84,116.35 arc(91.84,115.85) 91.41,115.6 91.41,115.6 arc(91.16,115.53) 90.98,115.35 90.97,115.35 arc(90.79,115.17) 90.54,115.1 arc(90.3,115.03) 90.11,114.85 90.11,114.85 arc(89.93,114.67) 89.68,114.6 89.47,114.6 89.01,115.06 88.62,115.06 88.24,114.68 87.6,114.68 87.19,115.09 86.94,115.09 86.46,115.57 86.04,115.57 85.56,116.05 85.13,116.05 83.33,117.85 83.33,120.13 80.64,122.83 77.04,122.83 75.77,124.1 75.59,124.1 75.3,124.38 75.3,124.8 74.29,125.81 74.05,125.81 73.87,125.63 73.63,125.63 73.43,125.83 73.43,126.07 73.61,126.25 73.61,126.48 73.41,126.69 73.17,126.69 72.99,126.51 72.75,126.51 72.55,126.71 72.55,126.95 72.73,127.13 72.73,127.36 72.53,127.57 72.29,127.57 72.11,127.39 71.87,127.39 71.67,127.59 71.67,127.83 71.85,128.01 71.85,128.24 71.65,128.45 71.41,128.45 71.23,128.27 70.99,128.27 70.79,128.47 70.79,128.71 70.97,128.89 70.97,129.12 70.77,129.33 70.53,129.33 70.35,129.15 70.11,129.15 69.91,129.35 69.91,129.59 70.09,129.77 70.09,130 69.89,130.21 69.65,130.21 69.47,130.03 69.23,130.03 69.03,130.23 69.03,130.47 69.21,130.65 69.21,130.89 68.79,131.3 68.79,149.25 71.73,152.19 71.73,152.96 71.99,153.22 72.35,153.22 72.45,153.12 72.68,153.12 72.86,153.3 73.04,153.3 73.05,153.31 73.5,153.31 v2(73.91,153.72)
  ART07 w0.114: v2(73.91,153.72) 73.91,153.97 74,154.06 74,154.06 74.59,154.65 74.59,154.69 75.96,156.06 77.02,156.06 77.14,156.18 77.14,156.22 77.25,156.34 77.59,156.34 77.71,156.22 77.71,156.18 77.82,156.06 81.91,156.06 83.16,154.81 84.49,154.81 85.34,153.97 v2(85.34,153.72) 85.49,153.72 87.2,155.42 88.59,155.42 88.71,155.54 88.71,155.69 88.82,155.8 89.16,155.8 89.28,155.69 89.28,155.54 89.39,155.42 89.73,155.42 89.85,155.54 89.85,155.64 89.96,155.75 90.31,155.75 90.42,155.64 90.42,155.54 90.53,155.42 94.1,155.42 94.62,154.91 96.03,154.91 96.38,154.56 96.38,154.27 96.77,153.88 v2(96.77,153.72) 98.72,155.68 99.3,155.68 99.41,155.79 99.41,155.89 99.52,156.01 99.87,156.01 99.98,155.89 99.98,155.79 100.1,155.68 100.44,155.68 100.55,155.79 100.55,155.97 100.67,156.08 101.01,156.08 101.12,155.97 101.12,155.79 101.24,155.68 104.65,155.68 105.47,154.85 107.07,154.85 v2(108.2,153.72) 110.46,155.98 115.62,155.98 118.18,155.86 118.96,155.76 119.2,155.52 119.2,154.45 119.27,154.38 119.27,154.37 119.63,154.01 v2(119.63,153.72)
DDR4_COMP_A14: length 129.9
  TOP w0.109: U5.L2 v2(113,149.72) ; U4.L2 v2(101.57,149.72) ; U3.L2 90.9,149.68 90.9,149.69 v2(90.91,149.7) ; U7.L2 v2(78.71,149.72) ; U6.L2 v2(124.43,149.72)
  ART05 w0.114: v2(78.71,149.72) 79.18,149.29 79.69,149.29 79.91,149.07 79.91,148.59 80.26,148.23 80.54,148.13 80.73,148.1 81.29,148.03 83.81,147.82 85.9,147.7 87.2,147.7 88.7,148.06 90.14,148.44 90.26,148.5 90.55,148.79 90.55,149.09 90.78,149.33 v2(90.91,149.7) 91.19,149.7 91.56,149.33 92.21,149.33 92.32,149.44 92.32,149.64 92.44,149.76 92.78,149.76 92.9,149.64 92.9,149.44 93.01,149.33 93.35,149.33 93.47,149.44 93.47,149.64 93.58,149.76 93.92,149.76 94.04,149.64 94.04,149.44 94.15,149.33 94.61,149.33 95.45,148.49 98.32,148.49 98.47,148.34 98.71,148.34 98.83,148.22 98.83,148.17 98.94,148.06 99.29,148.06 99.4,148.17 99.4,148.22 99.51,148.34 99.86,148.34 99.97,148.22 99.97,148.17 100.09,148.06 100.43,148.06 100.54,148.17 100.54,148.22 100.66,148.34 100.91,148.34 101.17,148.59 101.17,149.25 101.37,149.45 101.37,149.52 v2(101.57,149.72) 101.96,149.33 103.4,149.33 104.19,148.54 104.46,148.54 104.57,148.65 104.57,148.86 104.68,148.97 105.03,148.97 105.14,148.86 105.14,148.55 105.26,148.44 105.6,148.44 105.71,148.55 105.71,148.86 105.83,148.97 106.17,148.97 106.28,148.86 106.28,148.65 106.4,148.54 109.95,148.54 110.18,148.76 110.18,149.2 110.3,149.32 112.41,149.32 112.51,149.42 112.62,149.52 112.62,149.52 112.82,149.72 v2(113,149.72) 113.27,149.72 113.66,149.33 115.25,149.33 115.36,149.44 115.36,149.63 115.48,149.74 115.82,149.74 115.93,149.63 115.93,149.44 116.05,149.33 116.39,149.33 116.51,149.44 116.51,149.85 116.62,149.96 116.96,149.96 117.08,149.85 117.08,149.44 117.19,149.33 117.53,149.33 117.65,149.44 117.65,149.69 117.76,149.81 118.11,149.81 118.22,149.69 118.22,149.44 118.33,149.33 123.81,149.33 124.21,149.72 v2(124.43,149.72)
  ART05 w0.165: v2(78.71,149.72) 78.59,149.72 78.54,149.67 78.44,149.67 78.1,149.33 77.71,149.33 77.44,149.6 76.17,149.6 75.79,149.22 75.29,149.22 75.12,149.06 75.12,148.73 74.91,148.51 72.9,148.51 70.86,146.47 70.86,135.03 71.38,134.5 71.38,134.27 71.05,133.93 71.05,133.7 71.21,133.53 71.45,133.53 71.81,133.89 72.05,133.89 72.25,133.69 72.25,133.45 71.98,133.18 71.98,132.87 72.17,132.68 72.4,132.68 72.72,132.99 72.95,132.99 73.16,132.78 73.16,132.55 72.86,132.25 72.86,131.99 73.04,131.81 73.27,131.81 73.6,132.13 73.83,132.13 74.04,131.93 74.04,131.69 73.74,131.39 73.74,131.11 73.93,130.92 74.16,130.92 74.48,131.23 74.71,131.23 74.92,131.02 74.92,130.79 74.62,130.49 74.62,130.23 74.81,130.04 75.04,130.04 75.36,130.35 75.59,130.35 75.8,130.14 75.8,129.91 75.5,129.61 75.5,129.35 75.68,129.17 75.94,129.17 76.24,129.47 76.47,129.47 76.68,129.26 76.68,129.03 76.38,128.73 76.38,128.47 76.55,128.3 76.78,128.3 77.09,128.61 77.33,128.61 77.53,128.41 77.53,128.17 77.26,127.9 77.26,127.61 77.42,127.44 77.66,127.44 77.92,127.71 78.15,127.71 78.36,127.5 78.36,127.27 78.04,126.94 78.04,126.63 78.24,126.43 78.5,126.43 79,126.93 79.24,126.93 79.49,126.68 79.49,126.45 79.23,126.19 79.23,125.93 79.46,125.71 79.69,125.71 79.96,125.98 80.19,125.98 81.91,124.26 81.91,122.63 82.43,122.11 82.43,121.65 83.19,120.9 83.48,120.9 84.03,121.46 84.27,121.46 84.43,121.29 84.43,120.92 83.94,120.43 83.94,120.2 84.88,119.26 84.88,118.34 85.16,118.06 85.6,118.06 85.98,117.68 86.31,117.68 86.92,117.07 87.27,117.07 87.48,116.86 87.55,116.86 87.88,116.53 88.18,116.53 88.56,116.15 89.08,116.15 89.46,116.53 89.89,116.53 90.27,116.15 91.36,116.15 v2(91.41,116.1) ; v2(124.43,149.72) 124.65,149.72 125.04,149.33 126.24,149.33 126.46,149.1 126.46,148.22 v2(127.28,147.41)
  BOTTOM w0.175: R1036.1 128.24,147.89 127.76,147.89 v2(127.28,147.41)
DDR4_COMP_A15: length 132.7
  TOP w0.109: v2(85.29,149.75) 85.66,150.12 U3.M8 ; U4.M8 v2(96.77,149.72) ; U5.M8 v2(108.2,149.72) ; U6.M8 v2(119.63,149.72) ; U7.M8 v2(73.91,149.72)
  TOP w0.175: R1043.1 v2(127.99,149.22)
  ART03 w0.114: v2(85.29,149.75) 85.31,149.75 85.73,149.33 87.56,149.33 87.67,149.44 87.67,149.74 87.79,149.85 88.13,149.85 88.25,149.74 88.25,149.44 88.37,149.31 92.15,149.31 92.27,149.2 92.27,149 92.38,148.88 92.72,148.88 92.84,149 92.84,149.26 92.95,149.38 93.33,149.38 93.45,149.26 93.45,148.96 93.56,148.84 93.9,148.84 94.02,148.96 94.02,149.19 94.16,149.33 96.37,149.33 v2(96.77,149.72) 97.16,149.33 103.69,149.33 103.81,149.21 103.81,148.93 103.92,148.82 104.26,148.82 104.38,148.93 104.38,149.24 104.49,149.35 104.81,149.35 104.95,149.21 104.95,148.96 105.06,148.84 105.41,148.84 105.52,148.96 105.52,149.24 105.63,149.35 105.95,149.35 106.07,149.24 106.07,148.97 106.18,148.86 106.52,148.86 106.64,148.97 106.64,149.21 106.75,149.33 107.8,149.33 v2(108.2,149.72) 111.67,149.72 112.04,149.35 115.11,149.35 115.22,149.47 115.22,149.67 115.34,149.78 115.68,149.78 115.82,149.64 115.82,149.34 115.94,149.22 116.28,149.22 116.39,149.34 116.39,149.67 116.51,149.78 116.82,149.78 116.96,149.64 116.96,149.34 117.08,149.22 117.4,149.22 117.51,149.34 117.51,149.67 117.62,149.78 117.97,149.78 118.08,149.67 118.08,149.47 118.2,149.35 119.26,149.35 v2(119.63,149.72)
  ART03 w0.165: v2(127.99,149.22) 127.44,149.22 127.43,149.24 127.02,149.24 126.62,149.26 126.62,149.26 126.22,149.28 126.19,149.31 125.65,149.31 125.37,149.33 120.28,149.33 v2(119.63,149.72) ; v2(73.91,149.72) 73.5,150.13 72.71,150.13 70.76,148.18 70.76,147.84 70.93,147.68 71.64,147.68 71.8,147.51 71.8,147.22 71.64,147.05 70.93,147.05 70.76,146.89 70.76,146.6 70.93,146.43 71.64,146.43 71.8,146.27 71.8,145.97 71.64,145.81 70.93,145.81 70.76,145.64 70.76,145.35 70.93,145.19 71.64,145.19 71.8,145.02 71.8,144.73 71.64,144.56 70.93,144.56 70.76,144.4 70.76,144.11 70.93,143.94 71.64,143.94 71.8,143.78 71.8,143.49 71.64,143.32 70.93,143.32 70.76,143.16 70.76,142.86 70.93,142.7 71.64,142.7 71.8,142.53 71.8,142.24 71.64,142.08 70.93,142.08 70.76,141.91 70.76,141.62 70.93,141.45 71.63,141.45 71.8,141.29 71.8,139.04 72.16,138.68 72.16,138.44 72.06,138.33 72.06,138.1 72.26,137.89 72.5,137.89 72.6,138 72.84,138 73.07,137.77 73.07,137.27 72.91,137.11 71.71,137.11 71.55,136.94 71.55,136.65 71.71,136.48 72.91,136.48 73.07,136.32 73.07,136.03 72.91,135.86 71.77,135.86 71.6,135.7 71.6,135.4 71.77,135.24 72.91,135.24 73.07,135.07 73.07,133.64 78.64,128.07 78.87,128.07 79.36,128.56 79.59,128.56 79.8,128.35 79.8,128.12 79.31,127.63 79.31,127.4 79.52,127.19 79.75,127.19 80.24,127.68 80.47,127.68 80.68,127.47 80.68,127.24 80.19,126.75 80.19,126.52 80.4,126.31 80.63,126.31 81.12,126.8 81.35,126.8 83.85,124.3 83.85,122.87 84.69,122.02 85.52,122.02 85.8,121.74 85.8,120.93 86.04,120.69 86.36,120.69 86.86,120.19 87.13,120.19 87.8,119.51 88.12,119.51 88.5,119.13 88.87,119.13 89.34,118.66 89.81,118.66 90.09,118.38 90.09,117.05 v2(90.54,116.6)
  ART05 w0.114: v2(73.91,149.72) 73.91,149.93 74.19,150.22 75.08,150.22 75.28,150.41 75.29,150.41 75.33,150.45 78.18,150.45 78.88,151.14 79.99,151.14 80.39,150.74 80.69,150.74 81.03,151.08 81.29,151.08 81.41,150.96 81.41,150.84 81.52,150.72 81.86,150.72 81.99,150.85 81.99,151.27 82.1,151.38 82.43,151.38 82.55,151.27 82.55,151.19 82.66,151.08 83.25,151.08 83.7,150.63 83.99,150.63 84.15,150.47 84.15,150.23 84.26,150.11 84.93,150.11 v2(85.29,149.75)
DDR4_COMP_A16: length 132.4
  TOP w0.109: v2(74.71,148.92) U7.L8 ; v2(109,148.92) U5.L8 ; v2(86.14,148.92) U3.L8 ; v2(97.57,148.92) U4.L8 ; v2(120.43,148.92) U6.L8
  TOP w0.175: R1030.1 v2(127.99,148.34)
  ART03 w0.165: v2(74.71,148.92) 74.63,149 73.94,149 73.61,149.33 72.62,149.33 72.29,149 72.29,148.4 72.28,148.39 72.28,140.44 72.29,140.44 72.29,140.28 73.53,139.04 73.53,133.71 74.49,132.74 74.73,132.74 75.18,133.19 75.41,133.19 75.62,132.99 75.62,132.75 75.17,132.3 75.17,132.07 78.08,129.16 79.67,129.16 79.99,128.84 80.22,128.84 81.11,129.73 81.34,129.73 81.55,129.52 81.55,129.29 80.66,128.4 80.66,128.17 80.87,127.96 81.1,127.96 81.99,128.85 82.22,128.85 82.43,128.64 82.43,128.41 81.54,127.52 81.54,127.29 81.9,126.93 82.13,126.93 82.42,127.22 82.65,127.22 82.86,127.02 82.86,126.78 82.57,126.49 82.57,126.26 84.09,124.74 84.4,124.74 84.85,125.19 85.09,125.19 85.29,124.99 85.29,124.75 84.37,123.83 84.37,123.6 84.58,123.39 84.81,123.39 86.24,124.82 86.48,124.82 86.68,124.62 86.68,124.38 85.18,122.88 85.18,122.64 85.38,122.44 85.62,122.44 87.12,123.94 87.36,123.94 87.56,123.74 87.56,123.5 86.6,122.54 86.6,122.31 86.86,122.05 87.22,122.05 87.53,121.73 87.53,120.93 87.91,120.55 88.16,120.55 88.62,120.09 88.96,120.09 89.42,119.63 89.79,119.63 90.32,119.1 90.7,119.1 90.98,118.82 90.98,116.33 90.54,115.89 v2(90.54,115.6)
  ART07 w0.114: v2(120.43,148.92) 119.45,148.92 119.09,148.55 118.63,148.55 118.46,148.72 118.03,148.72 117.4,149.35 117.15,149.35 117.03,149.47 117.03,149.52 116.92,149.63 116.58,149.63 116.46,149.52 116.46,149.47 116.35,149.35 116,149.35 115.89,149.47 115.89,149.49 115.78,149.61 115.43,149.61 115.32,149.49 115.32,149.47 115.2,149.35 113.56,149.35 113.37,149.16 113.37,148.67 113.22,148.51 111.94,148.51 111.76,148.34 111.1,148.34 110.94,148.49 110.94,149.02 110.61,149.35 109.67,149.35 109.38,149.07 109.37,149.07 109.22,148.92 v2(109,148.92) 108.62,148.54 108.1,148.54 107.67,148.11 106.58,148.11 106.14,148.54 105.62,148.54 105.51,148.65 105.51,148.86 105.39,148.97 105.05,148.97 104.94,148.86 104.94,148.65 104.82,148.54 104.48,148.54 104.37,148.65 104.37,148.86 104.25,148.97 103.91,148.97 103.79,148.86 103.79,148.65 103.68,148.54 100.48,148.54 100.3,148.72 100.3,149.02 100,149.32 99.53,149.32 99.32,149.11 98.95,149.11 98.74,149.32 98.19,149.32 97.86,148.99 97.86,148.99 97.79,148.92 v2(97.57,148.92) 97.13,148.49 96.62,148.49 96.21,148.08 95.05,148.08 94.65,148.49 94.15,148.49 94.03,148.6 94.03,148.75 93.92,148.87 93.58,148.87 93.46,148.75 93.46,148.6 93.35,148.49 93,148.49 92.89,148.6 92.89,148.73 92.78,148.84 92.43,148.84 92.32,148.73 92.32,148.6 92.2,148.49 90.22,148.49 89.79,148.06 88.35,148.06 88.13,148.29 88.13,148.97 87.96,149.13 86.42,149.13 86.21,148.92 v2(86.14,148.92) 86.06,148.84 85.84,148.84 85.81,148.81 85.74,148.81 85.56,148.64 84.14,148.64 83.95,148.45 83.68,148.45 83.67,148.46 83.66,148.46 83.17,148.96 80.13,148.96 79.7,148.53 77.69,148.53 77.51,148.72 77.51,149.59 77.39,149.71 77.15,149.71 77.04,149.59 77.04,149.41 76.92,149.3 76.58,149.3 76.46,149.41 76.46,149.59 76.35,149.71 76.06,149.71 75.94,149.59 75.94,149.31 75.83,149.2 74.99,149.2 v2(74.71,148.92)
  ART07 w0.165: v2(127.99,148.34) 126.57,148.34 126.45,148.45 124.12,148.45 123.47,148.49 123.14,148.81 123.14,148.95 122.92,149.18 122.89,149.18 122.32,149.33 121.07,149.33 120.76,149.02 120.65,149.02 120.55,148.92 v2(120.43,148.92)
DDR4_COMP_ACTN: length 136.6
  TOP w0.109: U6.L3 v2(123.63,148.92) ; U7.L3 v2(77.91,148.92) ; U4.L3 v2(100.77,148.92) ; U3.L3 v2(89.34,148.92) ; U5.L3 v2(112.2,148.92)
  TOP w0.175: R1029.1 v2(127.99,145.54)
  ART03 w0.114: v2(123.63,148.92) 123.47,148.92 122.88,148.34 121,148.34 120.83,148.51 120.22,148.51 119.83,148.89 119.35,148.89 118.92,148.46 118.05,148.46 117.93,148.58 117.93,148.78 117.82,148.89 117.47,148.89 117.36,148.78 117.36,148.58 117.25,148.46 116.9,148.46 116.79,148.58 116.79,148.78 116.67,148.89 116.33,148.89 116.22,148.78 116.22,148.58 116.1,148.46 115.76,148.46 115.65,148.58 115.65,148.78 115.53,148.89 115.19,148.89 115.07,148.78 115.07,148.58 114.96,148.46 112.66,148.46 v2(112.2,148.92) 112.2,148.8 111.78,148.39 111.06,148.39 110.94,148.5 110.94,149.25 110.79,149.4 108.68,149.4 108.2,148.92 107.92,148.92 107.54,148.54 106.19,148.54 106.07,148.41 104.87,148.41 104.75,148.3 104.75,148.2 104.64,148.08 104.3,148.08 104.18,148.2 104.18,148.3 103.99,148.49 103.39,148.49 103.16,148.26 102.81,148.26 102.59,148.49 102.24,148.49 102.01,148.26 101.67,148.26 101.44,148.49 101.2,148.49 v2(100.77,148.92) 100.77,148.42 100.65,148.31 98.19,148.31 97.97,148.54 97.38,148.54 97.11,148.82 96.39,148.82 96.06,148.49 95.27,148.49 95.16,148.6 95.16,148.89 95.04,149.01 94.7,149.01 94.59,148.89 94.59,148.6 94.47,148.49 93.94,148.49 93.78,148.32 93.36,148.32 93.2,148.49 92.8,148.49 92.63,148.32 92.22,148.32 92.05,148.49 91.66,148.49 91.48,148.31 91.08,148.31 90.91,148.49 90.51,148.49 90.34,148.31 89.94,148.31 89.77,148.49 89.45,148.49 89.34,148.6 v2(89.34,148.92)
  ART03 w0.165: v2(127.99,145.54) 126.46,147.07 126.46,147.45 125.75,148.16 124.39,148.16 v2(123.63,148.92)
  ART05 w0.114: 96.04,116.13 96.41,116.5 96.6,116.5 arc(96.81,116.45) 96.95,116.31 96.96,116.3 arc(97.17,116.09) 97.47,116 98.24,116 v2(98.34,116.1)
  ART05 w0.165: v2(77.91,148.92) 77.54,148.92 77.28,149.19 76.82,149.19 76.65,149.02 76.65,148.36 75.92,147.63 75.92,147.13 75.7,146.91 74.55,146.91 74.55,146.91 72.95,146.91 72.72,146.68 72.72,146.67 71.67,145.62 71.67,145.33 71.83,145.17 72.3,145.17 72.46,145 72.46,144.71 72.3,144.55 71.83,144.55 71.67,144.38 71.67,144.09 71.83,143.92 72.3,143.92 72.46,143.76 72.46,143.47 72.3,143.3 71.83,143.3 71.67,143.14 71.67,142.84 71.83,142.68 72.3,142.68 72.46,142.51 72.46,142.22 72.3,142.06 71.83,142.06 71.67,141.89 71.67,141.6 71.83,141.43 72.3,141.43 72.46,141.27 72.46,140.98 72.3,140.81 71.83,140.81 71.67,140.65 71.67,138.48 71.83,138.32 73.01,138.32 73.17,138.15 73.17,137.86 73.01,137.69 71.83,137.69 71.67,137.53 71.67,137.24 71.83,137.07 73.01,137.07 73.17,136.91 73.17,136.61 73.01,136.45 71.83,136.45 71.67,136.28 71.67,135.46 77.67,129.46 80.87,129.46 81.18,129.78 81.18,130.9 81.35,131.06 81.64,131.06 81.81,130.9 81.81,129.75 81.97,129.59 82.64,129.59 82.8,129.42 82.8,124.94 85.8,121.94 85.8,120.9 86.12,120.59 86.38,120.59 86.63,120.35 86.63,119.44 86.92,119.15 87.24,119.15 87.78,118.61 88.05,118.61 88.49,118.16 88.97,118.16 89.43,118.62 89.84,118.62 90.42,118.03 90.8,118.03 91.18,117.65 91.63,117.65 92.15,117.13 92.47,117.13 92.96,116.64 93.37,116.64 93.83,117.09 94.16,117.09 94.64,116.61 95.02,116.61 95.5,116.13 96.04,116.13
  ART07 w0.114: v2(89.34,148.92) 89.34,149.06 88.24,150.16 87.27,150.16 86.92,149.81 85.87,149.81 85.44,149.39 85.44,149.39 85.33,149.28 84.42,149.28 83.86,149.83 82.33,149.83 82.22,149.95 82.22,150.13 82.1,150.24 81.76,150.24 81.64,150.13 81.64,149.95 81.53,149.83 81.28,149.83 81.05,150.06 80.72,150.06 80.69,150.09 78.5,150.09 78.32,149.91 78.32,149.33 v2(77.91,148.92)
DDR4_COMP_ALERTN: length 130.4
  TOP w0.109: U5.P9 v2(107.4,152.12) ; U4.P9 v2(95.97,152.12) ; v2(84.5,152.17) 84.5,152.16 U3.P9 ; U6.P9 119.61,152.1 v2(119.61,152.12) ; U7.P9 v2(73.11,152.12)
  TOP w0.175: R138.1 v2(127.99,151.89)
  ART03 w0.165: v2(73.11,152.12) 73.06,152.07 72.67,152.07 72.53,151.93 72.51,151.93 69.56,148.97 69.56,133.92 70.16,133.31 70.16,133.08 69.79,132.7 69.79,132.47 70,132.26 70.23,132.26 70.61,132.64 70.84,132.64 71.05,132.43 71.05,132.2 70.67,131.82 70.67,131.59 70.88,131.38 71.11,131.38 71.49,131.76 71.72,131.76 71.93,131.55 71.93,131.32 71.55,130.94 71.55,130.71 71.76,130.5 71.99,130.5 72.37,130.88 72.6,130.88 72.81,130.67 72.81,130.44 72.43,130.06 72.43,129.83 72.64,129.62 72.87,129.62 73.25,130 73.48,130 73.69,129.79 73.69,129.56 73.31,129.18 73.31,128.95 73.52,128.74 73.75,128.74 74.13,129.12 74.36,129.12 74.57,128.91 74.57,128.68 74.19,128.3 74.19,128.07 74.4,127.86 74.63,127.86 75.01,128.24 75.24,128.24 75.45,128.03 75.45,127.8 75.07,127.42 75.07,127.19 75.28,126.98 75.51,126.98 75.89,127.36 76.12,127.36 76.33,127.15 76.33,126.92 75.95,126.54 75.95,126.31 76.16,126.1 76.39,126.1 76.77,126.48 77,126.48 77.21,126.27 77.21,126.04 76.83,125.66 76.83,125.43 77.04,125.22 77.27,125.22 77.65,125.6 77.88,125.6 78.4,125.07 79.56,125.07 84.08,120.55 84.08,119.12 85.15,118.05 85.66,118.05 86.14,117.57 86.46,117.57 87.01,117.01 87.25,117.01 87.64,116.62 88.1,116.62 88.69,116.03 89.1,116.03 89.42,115.71 arc(89.49,115.66) 89.57,115.65 89.82,115.65 arc(89.9,115.66) 89.97,115.7 arc(90.17,116) 90.11,116.35 90.11,116.35 89.68,116.78 v2(89.68,117.1) ; v2(127.99,151.89) 126.49,151.84 126.16,151.71 123.73,151.71 123.07,151.78 122.74,151.85 121.34,152.53 120.51,152.53 120.19,152.49 v2(119.61,152.12)
  ART07 w0.114: v2(119.61,152.12) 119.07,152.42 118.75,152.42 118.39,152.78 118.39,152.97 118.1,153.26 115.34,154.08 115,154.42 113.88,154.42 113.72,154.26 111.81,154.26 111.26,153.71 110.69,153.47 109.41,152.61 109.17,152.55 108.86,152.55 108.53,152.22 107.97,152.12 v2(107.4,152.12) 106.25,152.12 104.26,154.1 103.05,154.1 103.02,154.08 102.79,154.08 102.67,154.19 102.67,154.38 102.56,154.5 102.22,154.5 102.1,154.38 102.1,154.23 101.99,154.11 101.09,154.11 100.88,154.33 100.53,154.33 100.42,154.22 100.42,154.19 100.3,154.08 100.15,154.08 99.58,153.5 99.1,153.5 98.07,152.48 97.42,152.48 97.06,152.12 v2(95.97,152.12) 95.61,152.48 95.61,152.85 95.15,153.31 94.09,153.31 93.98,153.43 93.98,153.58 93.86,153.69 93.52,153.69 93.41,153.58 93.41,153.43 93.29,153.31 92.9,153.31 92.78,153.43 92.78,153.78 92.67,153.9 92.33,153.9 92.21,153.78 92.21,153.45 92.1,153.34 87.27,153.34 86.41,152.48 85.99,152.48 85.81,152.29 85.6,152.29 85.6,152.29 85.04,152.29 85.04,152.29 84.66,152.29 84.53,152.17 v2(84.5,152.17) 84.5,152.33 84.17,152.65 84.17,152.88 83.81,153.24 82,153.24 80.36,154.88 76.9,154.88 75.49,153.47 75.49,153.19 75.07,152.77 75.07,152.77 74.86,152.56 74.83,152.56 74.8,152.53 73.52,152.53 v2(73.11,152.12)
DDR4_COMP_BA0: length 126.5
  TOP w0.109: v2(78.76,150.49) 78.76,150.57 U7.N2 ; U5.N2 v2(113,150.52) ; U4.N2 v2(101.57,150.52) ; U6.N2 v2(124.43,150.52) ; U3.N2 v2(90.14,150.52)
  ART03 w0.114: v2(90.14,150.52) 90.35,150.52 90.75,150.93 92.28,150.93 92.42,150.79 92.42,150.56 92.53,150.44 92.88,150.44 92.99,150.56 92.99,150.81 93.1,150.93 93.42,150.93 93.56,150.79 93.56,150.56 93.68,150.44 94.02,150.44 94.13,150.56 94.13,150.81 94.25,150.93 94.56,150.93 94.7,150.79 94.7,150.56 94.82,150.44 95.16,150.44 95.28,150.56 95.28,150.81 95.39,150.93 98.65,150.93 98.91,150.67 100.15,150.67 100.4,150.93 100.91,150.93 101.31,150.52 v2(101.57,150.52)
  ART03 w0.165: v2(89.68,116.1) 89.43,116.1 89.24,116.29 89.24,117.81 88.98,118.07 88.56,118.07 88.12,118.51 87.98,118.51 87.8,118.69 87.77,118.69 87.35,119.11 86.89,119.11 86.4,119.61 85.95,119.61 85.37,120.19 85.18,120.19 84.93,120.43 84.93,120.79 82.82,122.9 82.82,123.14 83.35,123.67 83.35,123.91 83.15,124.11 82.91,124.11 82.38,123.58 82.15,123.58 81.94,123.78 81.94,124.02 82.56,124.64 82.56,124.88 82.36,125.08 82.12,125.08 81.5,124.46 81.27,124.46 81.06,124.66 81.06,124.9 81.67,125.51 81.67,125.74 81.46,125.95 81.23,125.95 80.62,125.34 80.39,125.34 80.18,125.54 80.18,125.95 70.3,135.83 70.3,137.17 70.47,137.34 71.26,137.34 71.43,137.5 71.43,137.8 71.26,137.96 70.47,137.96 70.3,138.13 70.3,138.42 70.47,138.58 71.26,138.58 71.43,138.75 71.43,139.04 71.26,139.21 70.47,139.21 70.3,139.37 70.3,139.9 70.52,140.12 71.23,140.12 71.4,140.29 71.4,140.58 71.23,140.74 70.47,140.74 70.3,140.91 70.3,148.59 72.63,150.91 74.71,150.91 75.51,150.11 78.38,150.11 v2(78.76,150.49)
  ART05 w0.114: v2(78.76,150.49) 79.09,150.82 79.81,150.82 80.58,150.05 81.11,150.05 81.23,150.18 81.23,150.29 81.34,150.41 81.69,150.41 81.8,150.29 81.8,150.18 81.92,150.06 82.2,150.06 82.32,150.18 82.32,150.48 82.41,150.58 82.54,150.58 83.06,150.06 83.64,150.06 84.45,149.25 85.38,149.25 86.02,149.89 87.45,149.89 87.99,150.42 88.74,150.42 89.1,150.79 89.58,150.79 89.85,150.52 v2(90.14,150.52)
  ART05 w0.165: v2(124.43,150.52) 124.84,150.11 126.38,150.11 126.79,149.7 v2(126.8,149.7)
  ART07 w0.114: v2(101.57,150.52) 101.57,150.25 101.68,150.14 103.74,150.14 103.85,150.25 103.85,150.48 103.97,150.6 104.31,150.6 104.43,150.48 104.43,150.25 104.54,150.14 105.48,150.14 106.22,149.4 106.39,149.4 106.5,149.51 106.5,149.55 106.6,149.66 106.93,149.66 107.24,149.35 108.43,149.35 108.76,149.68 109.13,149.68 109.49,150.04 110.13,150.04 110.23,150.14 110.98,150.14 111.1,150.02 111.1,149.85 111.24,149.71 111.63,149.71 111.76,149.83 111.76,150.04 111.86,150.14 112.62,150.14 v2(113,150.52) 113,150.32 113.23,150.09 115.13,150.09 115.24,150.2 115.24,150.49 115.35,150.61 115.7,150.61 115.81,150.49 115.81,150.2 115.93,150.09 116.27,150.09 116.38,150.2 116.38,150.49 116.5,150.61 116.84,150.61 116.95,150.49 116.95,150.2 117.07,150.09 117.32,150.09 118.06,149.35 120.62,149.35 120.99,149.72 122.67,149.72 123.06,150.11 123.77,150.11 124.18,150.52 v2(124.43,150.52)
  BOTTOM w0.175: R1041.1 128.28,149.63 128.21,149.63 128.17,149.67 126.83,149.67 v2(126.8,149.7)
DDR4_COMP_BA1: length 129.2
  TOP w0.109: U3.N8 v2(85.34,151.32) ; U5.N8 v2(108.2,151.32) ; U6.N8 v2(119.63,151.32) ; U4.N8 v2(96.77,151.32) ; U7.N8 v2(73.91,151.32)
  TOP w0.175: R1032.1 v2(123.42,156.34)
  ART03 w0.114: v2(85.34,151.32) 85.73,151.71 89.13,151.71 89.91,150.93 90.32,150.93 90.7,151.31 91.18,151.31 91.56,151.69 92.47,151.69 92.59,151.57 92.59,151.37 92.7,151.26 93.05,151.26 93.16,151.37 93.16,151.57 93.27,151.69 93.62,151.69 93.73,151.57 93.73,151.41 93.85,151.29 94.19,151.29 94.3,151.41 94.3,151.57 94.42,151.69 94.76,151.69 94.87,151.57 94.87,151.41 94.99,151.29 95.33,151.29 95.45,151.41 95.45,151.57 95.56,151.69 96.4,151.69 v2(96.77,151.32) 97.19,151.74 98.63,151.74 98.75,151.61 99.95,151.61 100.25,151.31 100.96,151.31 101.37,150.9 102.48,150.9 102.77,151.19 102.77,151.56 102.92,151.71 103.43,151.71 103.73,152.02 103.97,152.02 104.09,151.9 104.09,151.73 104.2,151.61 104.54,151.61 104.66,151.73 104.66,151.9 104.77,152.02 105.12,152.02 105.23,151.9 105.23,151.7 105.34,151.59 105.69,151.59 105.8,151.7 105.8,151.9 105.92,152.02 106.83,152.02 107.53,151.32 v2(108.2,151.32)
  ART03 w0.165: v2(73.91,151.32) 73.51,151.71 72.82,151.71 69.94,148.83 69.94,135.65 70.69,134.9 70.69,134.66 70.16,134.14 70.16,133.9 70.36,133.7 70.6,133.7 71.13,134.22 71.36,134.22 71.57,134.02 71.57,133.78 71.04,133.26 71.04,133.02 71.24,132.82 71.48,132.82 72.01,133.34 72.24,133.34 72.45,133.14 72.45,132.9 71.92,132.38 71.92,132.14 72.12,131.94 72.36,131.94 72.89,132.46 73.12,132.46 73.33,132.26 73.33,132.02 72.8,131.5 72.8,131.26 73,131.06 73.24,131.06 73.77,131.58 74,131.58 74.21,131.38 74.21,131.14 73.68,130.62 73.68,130.38 73.88,130.18 74.12,130.18 74.65,130.7 74.88,130.7 75.09,130.5 75.09,130.26 74.56,129.74 74.56,129.5 74.76,129.3 75,129.3 75.53,129.82 75.76,129.82 75.97,129.62 75.97,129.38 75.44,128.86 75.44,128.62 75.64,128.42 75.88,128.42 76.41,128.94 76.64,128.94 76.85,128.74 76.85,128.5 76.32,127.98 76.32,127.74 76.52,127.54 76.76,127.54 77.29,128.06 77.52,128.06 77.73,127.86 77.73,127.62 77.2,127.1 77.2,126.86 77.4,126.66 77.64,126.66 78.17,127.18 78.4,127.18 79.8,125.78 79.8,125.35 84.55,120.6 84.55,119.71 85.12,119.14 85.48,119.14 85.94,118.69 86.31,118.69 86.92,118.08 87.27,118.08 87.75,117.6 88.06,117.6 88.69,116.97 88.69,116.81 88.81,116.7 v2(88.81,116.6)
  ART05 w0.114: v2(119.63,151.32) 119.16,151.32 118.79,150.95 118.15,150.95 118.04,151.07 118.04,151.18 117.92,151.29 117.58,151.29 117.46,151.18 117.46,151.07 117.35,150.95 116.99,150.95 116.88,151.07 116.88,151.18 116.76,151.29 116.42,151.29 116.31,151.18 116.31,151.07 116.19,150.95 115.85,150.95 115.73,151.07 115.73,151.18 115.62,151.29 115.28,151.29 115.16,151.18 115.16,151.07 115.05,150.95 112.83,150.95 112.6,150.72 112.6,150.37 112.37,150.14 111.76,150.14 111.58,150.32 111.14,150.32 110.96,150.14 110.77,150.14 110.01,150.9 108.62,150.9 v2(108.2,151.32)
  ART07 w0.114: v2(85.34,151.32) 85.29,151.27 85.13,151.27 85.05,151.19 84.82,151.19 84.82,151.19 84.26,151.19 84.26,151.19 84.03,151.19 83.99,151.22 83.97,151.22 83.45,151.73 83.17,151.73 82.68,152.22 81.51,152.22 81,152.73 80.67,152.73 80.44,152.5 78.1,152.5 78.1,152.5 77.54,152.5 77.39,152.35 77.39,151.81 77.19,151.61 76.5,151.61 75.82,150.93 74.49,150.93 74.34,151.07 74.34,151.55 74.23,151.66 74,151.66 73.89,151.55 73.89,151.34 v2(73.91,151.32)
  ART07 w0.165: v2(119.63,151.32) 119.86,151.32 120.19,151.65 120.23,151.69 120.25,151.69 120.29,151.73 120.59,151.73 120.6,151.73 121.39,151.73 121.61,151.96 121.61,151.96 121.71,152.06 121.71,154.63 v2(123.42,156.34)
DDR4_COMP_BG0: length 128.6
  TOP w0.109: U4.M2 v2(102.37,150.52) ; v2(79.52,150.46) 79.51,150.46 79.47,150.42 79.41,150.42 U7.M2 ; U3.M2 v2(90.94,150.52) ; U6.M2 v2(125.23,150.52) ; U5.M2 v2(113.8,150.52)
  ART03 w0.114: v2(102.37,150.52) 102.62,150.52 103.05,150.95 103.33,150.95 103.63,151.26 103.87,151.26 103.99,151.14 103.99,150.79 104.1,150.67 104.42,150.67 104.56,150.81 104.56,151.12 104.7,151.26 105.01,151.26 105.13,151.14 105.13,150.81 105.24,150.7 105.56,150.7 105.7,150.84 105.7,151.12 105.84,151.26 106.08,151.26 106.19,151.14 106.19,151.08 106.4,150.88 106.91,150.88 106.96,150.93 110.16,150.93 110.46,150.62 111.35,150.62 111.63,150.9 113.42,150.9 v2(113.8,150.52) 114.18,150.9 115.13,150.9 115.97,151.74 116.21,151.74 116.33,151.62 116.33,151.32 116.44,151.21 116.78,151.21 116.9,151.32 116.9,151.62 117.01,151.74 117.35,151.74 117.47,151.62 117.47,151.32 117.58,151.21 117.84,151.21 117.96,151.09 117.96,150.89 118.07,150.77 118.3,150.77 118.42,150.89 118.42,151.07 118.53,151.18 119.02,151.18 119.12,151.08 119.12,151.03 119.23,150.93 121.49,150.93 121.87,150.54 123.08,150.54 123.45,150.91 124.83,150.91 v2(125.23,150.52)
  ART03 w0.165: v2(125.23,150.52) 125.62,150.91 126.66,150.91 126.67,150.9 127.03,150.9 127.56,151.43 127.8,151.43 127.81,151.44 128.12,151.44 128.13,151.45 128.17,151.45 128.5,151.78 128.5,153.12 v2(127.99,153.63) ; v2(79.52,150.46) 79.36,150.46 78.81,151 77.54,151 76.03,152.51 72.6,152.51 72.39,152.3 72.36,152.3 69.19,149.12 69.19,131.51 69.68,131.02 69.92,131.02 70.12,131.22 70.35,131.22 70.56,131.01 70.56,130.78 70.36,130.58 70.36,130.35 70.56,130.14 70.8,130.14 71,130.34 71.23,130.34 71.44,130.13 71.44,129.9 71.24,129.7 71.24,129.47 71.44,129.26 71.68,129.26 71.88,129.46 72.11,129.46 72.32,129.25 72.32,129.02 72.12,128.82 72.12,128.59 72.32,128.38 72.56,128.38 72.76,128.58 72.99,128.58 73.2,128.37 73.2,128.14 73,127.94 73,127.71 73.2,127.5 73.44,127.5 73.64,127.7 73.87,127.7 74.08,127.49 74.08,127.26 73.88,127.06 73.88,126.83 74.08,126.62 74.32,126.62 74.52,126.82 74.75,126.82 74.96,126.61 74.96,126.38 74.76,126.18 74.76,125.95 75.59,125.11 76.03,125.11 76.42,124.72 76.65,124.72 76.67,124.74 76.91,124.74 77.11,124.53 77.11,124.3 77.09,124.28 77.09,124.05 77.33,123.8 80.18,123.8 83.72,120.27 83.72,118.47 85,117.19 85.5,117.19 86.09,116.6 86.39,116.6 86.91,116.08 87.22,116.08 87.73,115.57 88.78,115.57 v2(88.81,115.6)
  ART05 w0.114: v2(79.52,150.46) 79.73,150.46 80.31,149.88 80.31,149.55 80.57,149.3 81.5,149.3 81.61,149.41 81.61,149.57 81.73,149.68 82.07,149.68 82.18,149.57 82.18,149.41 82.3,149.3 82.64,149.3 82.76,149.41 82.76,149.57 82.87,149.68 83.21,149.68 83.33,149.57 83.33,149.41 83.44,149.3 83.95,149.3 84.43,148.82 85.43,148.82 86.09,149.48 88.43,149.48 89.06,150.11 90.36,150.11 90.63,150.39 90.8,150.39 v2(90.94,150.52) 91.32,150.9 92.1,150.9 92.22,151.01 92.22,151.34 92.33,151.46 92.67,151.46 92.79,151.34 92.79,151.01 92.9,150.9 93.52,150.9 93.64,151.01 93.64,151.29 93.75,151.41 94.1,151.41 94.21,151.29 94.21,151.01 94.32,150.9 94.87,150.9 95.65,150.11 99.77,150.11 100.58,150.92 101.73,150.92 102.13,150.52 v2(102.37,150.52)
  BOTTOM w0.175: R1031.1 128.02,153.67 v2(127.99,153.63)
DDR4_COMP_BG1: length 140.6
  TOP w0.109: U7.M9 v2(73.11,150.52) ; U6.M9 v2(118.83,150.52) ; U4.M9 v2(95.97,150.52) ; U3.M9 v2(84.54,150.52) ; U5.M9 v2(107.4,150.52)
  TOP w0.175: R137.1 v2(127.99,151)
  ART03 w0.114: v2(84.54,150.52) 84.96,150.94 87.19,150.94 87.49,150.63 88.23,150.63 88.71,151.12 88.97,151.12 89.05,151.04 89.05,150.81 88.87,150.63 88.87,150.25 89.01,150.11 92.04,150.11 92.4,149.76 92.74,149.76 92.86,149.87 92.86,150.01 92.97,150.13 93.32,150.13 93.43,150.01 93.43,149.87 93.54,149.76 93.89,149.76 94,149.87 94,150.01 94.12,150.13 94.46,150.13 94.57,150.01 94.57,149.87 94.69,149.76 95.36,149.76 95.97,150.36 v2(95.97,150.52) 96.35,150.14 98.01,150.14 98.13,150.02 98.13,149.87 98.24,149.76 98.58,149.76 98.7,149.87 98.7,150.02 98.81,150.14 99.15,150.14 99.27,150.02 99.27,149.9 99.38,149.78 99.73,149.78 99.84,149.9 99.84,150.02 99.95,150.14 103.79,150.14 103.9,150.02 103.9,149.78 104.02,149.67 104.36,149.67 104.47,149.78 104.47,150.02 104.59,150.14 104.93,150.14 105.05,150.02 105.05,149.78 105.16,149.67 105.5,149.67 105.62,149.78 105.62,150.02 105.73,150.14 107.02,150.14 v2(107.4,150.52) 107.79,150.13 115.53,150.13 115.64,150.24 115.64,150.66 115.76,150.77 116.1,150.77 116.22,150.66 116.22,150.23 116.33,150.11 116.67,150.11 116.79,150.23 116.79,150.74 116.9,150.85 117.24,150.85 117.36,150.74 117.36,150.23 117.47,150.11 118.42,150.11 v2(118.83,150.52)
  ART05 w0.114: 97.05,114.73 97.32,115 97.72,115 97.95,115.24 97.95,115.24 97.98,115.29 98.14,115.45 98.22,115.48 98.34,115.5 98.58,115.5 98.81,115.73 98.85,115.8 99.2,116.15 v2(99.2,116.6)
  ART05 w0.165: v2(127.99,151) 127.17,151 127.12,150.99 127.03,150.9 126.67,150.9 126.66,150.91 124.27,150.91 124.27,150.91 119.47,150.91 119.46,150.9 119.45,150.9 118.84,150.57 v2(118.83,150.52) ; v2(73.11,150.52) 73.02,150.52 70.13,147.62 70.13,131.96 70.71,131.37 70.71,131.14 70.36,130.78 70.36,130.55 70.57,130.34 70.8,130.34 71.15,130.7 71.39,130.7 71.59,130.49 71.59,130.26 71.24,129.9 71.24,129.67 71.45,129.46 71.68,129.46 72.03,129.82 72.27,129.82 72.47,129.61 72.47,129.38 72.12,129.02 72.12,128.79 72.33,128.58 72.56,128.58 72.91,128.94 73.15,128.94 73.35,128.73 73.35,128.5 73,128.14 73,127.91 73.21,127.7 73.44,127.7 73.79,128.06 74.03,128.06 74.23,127.85 74.23,127.62 73.88,127.26 73.88,127.03 74.09,126.82 74.32,126.82 74.67,127.18 74.91,127.18 75.11,126.97 75.11,126.74 74.76,126.38 74.76,126.15 74.97,125.94 75.2,125.94 75.55,126.3 75.79,126.3 78.16,123.93 79.02,123.93 79.49,124.39 79.72,124.39 79.93,124.18 79.93,123.95 79.46,123.49 79.46,123.25 79.67,123.05 79.9,123.05 80.37,123.51 80.6,123.51 80.81,123.3 80.81,123.07 80.34,122.61 80.34,122.37 80.6,122.11 80.84,122.11 80.9,122.17 81.13,122.17 81.36,121.94 81.36,121.7 81.3,121.64 81.3,121.41 84.2,118.52 84.2,116.99 85.09,116.1 85.47,116.1 86,115.57 86.43,115.57 86.92,115.09 87.3,115.09 87.86,114.53 88.26,114.53 88.64,114.15 89.03,114.15 89.46,114.58 89.92,114.58 90.32,114.17 90.8,114.17 91.19,114.55 91.64,114.55 92.08,114.12 92.4,114.12 92.86,113.67 93.47,113.67 93.7,113.89 93.89,114.07 94.26,114.07 94.35,113.98 arc(94.38,113.94) 94.41,113.9 94.44,113.85 arc(94.87,113.6) 95.3,113.85 95.31,113.85 arc(95.49,114.03) 95.74,114.1 95.99,114.1 96.44,114.55 96.87,114.55 97.05,114.73
  ART07 w0.114: v2(73.11,150.52) 73.01,150.42 72.65,150.42 72.54,150.53 72.54,150.8 72.69,150.95 74.01,150.95 74.34,150.62 76.65,150.62 77.19,151.15 77.57,151.15 77.76,150.96 78.06,150.96 78.35,151.26 79.78,151.26 80,151.47 81.71,151.47 82.08,151.1 82.42,151.1 83.19,151.1 83.72,150.56 83.73,150.56 83.77,150.52 v2(84.54,150.52)
DDR4_COMP_CKE: length 134.3
  TOP w0.109: U4.K2 v2(102.37,148.92) ; U5.K2 v2(113.8,148.92) ; U6.K2 v2(125.23,148.92) ; U3.K2 v2(90.94,148.92) ; U7.K2 v2(79.51,148.92)
  TOP w0.175: R142.2 v2(128.06,144.65)
  ART05 w0.114: v2(125.23,148.92) 124.96,148.92 124.58,149.3 124.23,149.3 124.04,149.11 124.04,148.73 123.67,148.36 122.12,148.36 122.12,148.35 121.82,148.35 121.82,148.36 121.59,148.36 121.44,148.51 118.42,148.51 118.3,148.63 118.3,148.8 118.19,148.92 117.84,148.92 117.73,148.8 117.73,148.65 117.59,148.51 117.27,148.51 117.16,148.63 117.16,148.8 117.04,148.92 116.7,148.92 116.59,148.8 116.59,148.65 116.45,148.51 116.13,148.51 116.02,148.63 116.02,148.8 115.9,148.92 115.56,148.92 115.44,148.8 115.44,148.65 115.3,148.51 114.2,148.51 v2(113.8,148.92) 113.63,148.92 113.24,149.31 112.85,149.31 112.59,149.05 112.59,148.53 112.27,148.21 109.75,148.21 109.28,147.73 106.19,147.73 106.17,147.71 105.72,147.71 105.61,147.6 105.61,147.46 105.49,147.34 105.15,147.34 105.04,147.46 105.04,147.64 104.92,147.75 104.58,147.75 104.46,147.64 104.46,147.48 104.35,147.37 104.01,147.37 103.89,147.48 103.89,147.64 103.78,147.75 103.54,147.75 v2(102.37,148.92) 101.2,147.75 95.37,147.75 94.78,148.35 94.02,148.35 93.9,148.46 93.9,148.75 93.79,148.87 93.45,148.87 93.33,148.75 93.33,148.46 93.22,148.35 92.88,148.35 92.76,148.46 92.76,148.78 92.65,148.89 92.3,148.89 92.19,148.78 92.19,148.46 92.08,148.35 91.65,148.35 91.08,148.92 v2(90.94,148.92) 90.85,148.84 90.85,148.31 90.24,147.7 89.13,147.7 88.34,146.91 84.1,146.91 83.35,147.03 83.25,147.16 83.29,147.38 83.19,147.51 82.85,147.56 82.72,147.46 82.69,147.24 82.56,147.14 82.04,147.22 80.44,147.8 80.23,147.8 79.53,148.49 79.53,148.89 v2(79.51,148.92)
  ART05 w0.165: v2(125.23,148.92) 125.58,148.57 125.58,148.41 126.64,147.35 126.64,146.07 v2(128.06,144.65) ; v2(96.6,117.1) 96.26,117.45 96.26,117.86 95.98,118.13 arc(95.87,118.17) 95.76,118.18 95.65,118.18 arc(95.45,118.23) 95.31,118.38 95.3,118.38 arc(95.11,118.58) 94.85,118.67 arc(94.65,118.73) 94.48,118.86 arc(94.29,119) 94.05,119.04 93.8,119.04 93.39,118.64 92.89,118.64 92.4,119.13 92.15,119.13 91.59,119.69 91.24,119.69 91.23,119.7 91.15,119.74 90.81,120.08 arc(90.75,120.13) 90.67,120.14 90.22,120.14 89.85,120.51 89.51,120.51 89.16,120.17 88.54,120.17 88.36,120.34 88.36,121.28 88.11,121.54 87.73,121.54 87.35,121.92 87.35,122.43 84.6,125.17 84.6,125.65 84.6,125.65 84.6,133.4 84.38,133.62 84.12,133.62 83.61,133.11 83.37,133.11 83.17,133.31 83.17,133.55 83.69,134.08 83.69,134.31 83.5,134.5 83.24,134.5 82.66,133.92 82.43,133.92 82.22,134.13 82.22,134.36 82.81,134.96 82.81,135.19 82.62,135.39 82.38,135.39 81.82,134.82 81.58,134.82 81.38,135.03 81.38,135.26 82.6,136.49 82.6,136.75 82.4,136.95 82.17,136.95 80.99,135.77 80.76,135.77 80.55,135.98 80.55,136.21 81.89,137.56 81.89,137.79 81.69,137.99 81.46,137.99 80.09,136.62 79.86,136.62 79.65,136.83 79.65,137.06 81.01,138.42 81.01,138.65 80.8,138.86 80.57,138.86 79.17,137.46 78.94,137.46 78.73,137.67 78.73,137.9 80.74,139.91 80.74,140.14 80.53,140.35 80.3,140.35 78.28,138.33 78.05,138.33 77.84,138.54 77.84,138.77 78.42,139.35 78.42,139.58 77.19,140.82 77.19,147.37 77.8,147.98 78.48,147.98 79.42,148.92 v2(79.51,148.92)
  BOTTOM w0.175: v2(128.06,144.65) R142.2
DDR4_COMP_CLKN: length 128.4
  TOP w0.109: U3.K8 v2(86.14,148.12) ; U4.K8 v2(96.77,148.12) ; U7.K8 v2(73.91,148.12) ; U6.K8 v2(119.63,148.12) ; U5.K8 v2(108.2,148.12)
  ART03 w0.114: 94.84,122.66 94.89,122.66 95.16,122.39 arc(95.27,122.15) 95.22,121.9 arc(95.14,121.6) 95.22,121.3 arc(95.28,121.1) 95.22,120.9 arc(95.14,120.6) 95.22,120.31 95.22,120.3 arc(95.28,120.1) 95.22,119.9 arc(95.14,119.6) 95.22,119.3 arc(95.28,119.1) 95.22,118.9 arc(95.14,118.6) 95.22,118.3 arc(95.28,118.12) 95.24,117.93 arc(95.23,117.91) 95.22,117.9 arc(95.14,117.6) 95.22,117.3 arc(95.28,117.1) 95.22,116.9 95.22,116.89 arc(95.14,116.6) 95.22,116.31 95.23,116.3 arc(95.4,116.11) 95.63,116.01 arc(95.64,116.01) 95.65,116.01 95.76,115.9 95.76,115.62 v2(95.74,115.6) ; v2(86.14,148.12) 86.53,147.73 87.01,147.73 87.07,147.79 87.42,147.79 87.54,147.67 87.54,147.51 87.78,147.27 88.3,147.27 88.54,147.51 88.54,147.67 88.66,147.79 92.34,147.79 92.45,147.67 92.45,146.67 92.72,146.4 93.21,146.4 93.46,146.65 93.46,147.67 93.57,147.79 94.66,147.79 94.73,147.71 95.03,147.71 95.11,147.79 95.36,147.79 95.5,147.93 95.87,147.93 95.97,147.83 96.22,147.83 96.32,147.93 96.58,147.93 v2(96.77,148.12) 97.2,147.69 98.84,147.69 98.96,147.57 98.96,147.45 99.2,147.2 99.72,147.2 99.96,147.45 99.96,147.57 100.07,147.69 100.42,147.69 100.45,147.73 103.58,147.73 103.79,147.51 104.04,147.51 104.15,147.4 104.15,146.85 104.39,146.61 104.91,146.61 105.15,146.85 105.15,147.4 105.27,147.51 105.93,147.51 106.32,147.9 107.36,147.9 107.47,147.8 107.67,147.8 107.78,147.9 107.98,147.9 v2(108.2,148.12) 108.46,148.12 108.67,147.9 108.68,147.9 108.9,147.69 111.97,147.69 112.19,147.9 115.1,147.9 115.21,147.79 115.21,146.99 115.45,146.75 115.98,146.75 116.22,146.99 116.22,147.71 116.41,147.9 118,147.9 118.1,147.8 118.35,147.8 118.45,147.9 118.7,147.9 118.78,147.83 119.08,147.83 119.16,147.9 119.41,147.9 v2(119.63,148.12)
  ART03 w0.165: 94.84,122.66 92.71,122.66 87.37,128 87.37,128.46 88.34,129.43 88.34,129.67 88.14,129.87 87.9,129.87 86.93,128.9 86.47,128.9 86.11,129.26 86.11,129.71 87.08,130.69 87.08,130.92 86.88,131.13 86.64,131.13 85.67,130.15 85.21,130.15 84.85,130.52 84.85,130.97 85.83,131.95 85.83,132.18 85.62,132.39 85.39,132.39 84.41,131.41 83.96,131.41 83.59,131.77 83.59,132.23 84.57,133.2 84.57,133.44 84.36,133.65 84.13,133.65 83.15,132.67 82.7,132.67 82.34,133.03 82.34,133.49 83.31,134.46 83.31,134.7 83.11,134.9 82.87,134.9 81.9,133.93 81.44,133.93 81.08,134.29 81.08,134.74 82.06,135.72 82.06,135.95 81.85,136.16 81.62,136.16 80.64,135.18 80.18,135.18 79.82,135.55 79.82,136 80.9,137.08 80.9,137.31 80.69,137.52 80.46,137.52 79.38,136.44 78.93,136.44 78.56,136.8 78.56,137.26 79.54,138.23 79.54,138.47 79.33,138.67 79.1,138.67 78.12,137.7 77.67,137.7 76.87,138.5 76.87,146.74 75.88,147.73 74.3,147.73 v2(73.91,148.12)
  ART07 w0.114: v2(86.14,148.12) 85.93,147.92 84.31,147.92 83.98,147.59 82.42,147.59 82.18,147.34 82.18,147 82.06,146.89 81.72,146.89 81.61,147 81.61,147.34 81.36,147.59 81.04,147.59 80.71,147.92 75.8,147.92 75.18,148.54 74.29,148.54 73.91,148.15 v2(73.91,148.12)
DDR4_COMP_CLKP: length 128.5
  TOP w0.109: U4.K7 v2(97.57,148.12) ; U5.K7 v2(109,148.12) ; U6.K7 v2(120.43,148.12) ; U7.K7 v2(74.71,148.12) ; v2(86.89,148.12) 86.89,148.17 U3.K7
  ART03 w0.114: 94.83,122.92 94.83,122.91 94.84,122.9 94.92,122.9 95.29,122.52 arc(95.35,122.46) 95.39,122.4 95.39,122.39 arc(95.47,122.1) 95.39,121.8 arc(95.33,121.6) 95.39,121.4 95.39,121.39 arc(95.47,121.1) 95.39,120.8 arc(95.33,120.6) 95.39,120.4 arc(95.47,120.1) 95.39,119.8 arc(95.33,119.6) 95.39,119.4 arc(95.47,119.1) 95.39,118.8 arc(95.33,118.6) 95.39,118.4 arc(95.47,118.12) 95.41,117.85 arc(95.4,117.82) 95.39,117.8 arc(95.33,117.6) 95.39,117.4 arc(95.47,117.1) 95.39,116.8 95.38,116.79 arc(95.33,116.6) 95.38,116.41 95.39,116.39 arc(95.51,116.27) 95.66,116.2 95.74,116.28 v2(95.74,116.6) ; v2(120.43,148.12) 120.15,148.12 119.76,148.51 119.48,148.51 119.09,148.12 116.32,148.12 116,147.8 116,147.08 115.89,146.96 115.54,146.96 115.43,147.08 115.43,147.88 115.19,148.12 112.1,148.12 111.88,147.9 109.22,147.9 v2(109,148.12) 108.76,148.12 108.4,148.48 108.02,148.48 107.66,148.12 106.23,148.12 105.84,147.73 105.18,147.73 104.94,147.48 104.94,146.94 104.82,146.82 104.48,146.82 104.37,146.94 104.37,147.48 104.13,147.73 103.88,147.73 103.67,147.94 100.36,147.94 100.33,147.9 99.98,147.9 99.74,147.66 99.74,147.53 99.63,147.42 99.29,147.42 99.17,147.53 99.17,147.66 98.93,147.9 97.79,147.9 v2(97.57,148.12) 97.32,148.12 96.95,148.49 96.55,148.49 96.2,148.14 95.41,148.14 95.27,148 93.48,148 93.24,147.76 93.24,146.73 93.13,146.62 92.81,146.62 92.67,146.76 92.67,147.76 92.43,148 88.57,148 88.33,147.76 88.33,147.6 88.21,147.48 87.87,147.48 87.75,147.6 87.75,147.76 87.51,148 87.01,148 v2(86.89,148.12)
  ART03 w0.165: v2(74.71,148.12) 74.83,148 75.99,148 77.14,146.85 77.14,146.6 77.24,146.5 77.24,146.25 77.14,146.15 77.14,145.89 77.24,145.79 77.24,145.54 77.14,145.44 77.14,145.19 77.24,145.09 77.24,144.83 77.14,144.74 77.14,144.48 77.24,144.38 77.24,144.13 77.14,144.03 77.14,143.68 77.24,143.59 77.24,143.33 77.14,143.23 77.14,142.98 77.24,142.88 77.24,142.63 77.14,142.53 77.14,142.24 77.24,142.14 77.24,141.88 77.14,141.78 77.14,141.53 77.24,141.43 77.24,141.18 77.14,141.08 77.14,140.82 77.24,140.73 77.24,140.47 77.14,140.37 77.14,140.12 77.24,140.02 77.24,139.77 77.14,139.67 77.14,139.41 77.24,139.31 77.24,139.06 77.14,138.96 77.14,138.61 77.78,137.96 78.01,137.96 78.99,138.94 79.44,138.94 79.81,138.58 79.81,138.12 78.83,137.15 78.83,136.91 79.04,136.71 79.27,136.71 80.35,137.79 80.8,137.79 81.17,137.42 81.17,136.97 80.09,135.89 80.09,135.66 80.29,135.45 80.53,135.45 81.5,136.43 81.96,136.43 82.32,136.06 82.32,135.61 81.35,134.63 81.35,134.4 81.55,134.19 81.79,134.19 82.76,135.17 83.22,135.17 83.58,134.81 83.58,134.35 82.6,133.37 82.6,133.14 82.81,132.93 83.04,132.93 84.02,133.91 84.47,133.91 84.84,133.55 84.84,133.09 83.86,132.12 83.86,131.88 84.07,131.68 84.3,131.68 85.28,132.65 85.73,132.65 86.09,132.29 86.09,131.84 85.12,130.86 85.12,130.63 85.32,130.42 85.56,130.42 86.53,131.4 86.99,131.4 87.35,131.03 87.35,130.58 86.37,129.6 86.37,129.37 86.58,129.16 86.81,129.16 87.79,130.14 88.25,130.14 88.61,129.78 88.61,129.32 87.63,128.35 87.63,128.11 92.82,122.92 94.83,122.92
  ART07 w0.114: v2(74.71,148.12) 75.29,148.12 75.71,147.7 80.62,147.7 80.95,147.37 81.28,147.37 81.39,147.26 81.39,146.91 81.63,146.67 82.15,146.67 82.39,146.91 82.39,147.26 82.51,147.37 83.37,147.37 83.46,147.27 83.72,147.27 83.82,147.37 84.07,147.37 84.4,147.7 84.74,147.7 84.83,147.6 85.01,147.6 85.11,147.7 86.61,147.7 86.84,147.93 86.84,147.95 86.89,148 v2(86.89,148.12)
DDR4_COMP_CSN: length 138.3
  TOP w0.109: U6.L7 v2(121.23,148.92) ; U7.L7 75.54,148.89 v2(75.54,148.82) ; U5.L7 v2(109.8,148.92) ; U4.L7 v2(98.37,148.92) ; v2(87.12,148.77) 86.57,149.32 U3.L7
  TOP w0.175: R1045.1 v2(127.99,147.45)
  ART05 w0.114: v2(98.34,117.1) 98.63,116.81 98.63,116.45 arc(98.65,116.37) 98.69,116.3 arc(98.74,116.1) 98.69,115.9 98.68,115.89 arc(98.54,115.75) 98.34,115.7 98.19,115.7 arc(98.02,115.65) 97.9,115.53 97.82,115.39 arc(97.67,115.25) 97.47,115.2 97.3,115.2 97.08,115.42
  ART05 w0.165: v2(75.54,148.82) 75.54,148.35 74.9,147.71 72.93,147.71 71.23,146.01 71.23,135.27 78.34,128.15 78.86,128.15 79.69,128.99 79.92,128.99 80.13,128.78 80.13,128.55 79.3,127.71 79.3,127.48 79.5,127.27 79.74,127.27 81.38,128.92 81.62,128.92 81.82,128.71 81.82,128.48 80.18,126.83 80.18,126.6 80.38,126.39 80.62,126.39 81.78,127.56 82.01,127.56 82.22,127.35 82.22,127.12 81.22,126.12 81.22,125.89 83,124.11 83,123.87 82.49,123.36 82.49,123.12 82.69,122.92 82.93,122.92 83.44,123.43 83.67,123.43 83.88,123.23 83.88,122.99 83.37,122.48 83.37,122.24 83.57,122.04 83.81,122.04 84.32,122.55 84.55,122.55 84.83,122.27 84.83,120.45 85.14,120.14 85.57,120.14 85.78,119.94 85.78,118.93 86.04,118.67 86.31,118.67 86.59,118.39 86.69,118.39 87.04,118.03 87.32,118.03 87.77,117.59 88.1,117.59 88.52,117.17 89.08,117.17 89.51,117.6 89.89,117.6 90.42,117.07 90.73,117.07 91.13,116.66 91.51,116.66 92.07,116.1 92.48,116.1 92.94,115.65 93.35,115.65 93.83,116.13 94.16,116.13 94.69,115.6 94.96,115.6 95.42,115.14 95.96,115.14 96.34,115.52 96.97,115.52 97.08,115.42
  ART07 w0.114: v2(121.23,148.92) 120.82,148.51 119.51,148.51 119.48,148.48 119.48,148.48 119.23,148.23 118.46,148.23 118.41,148.27 117.01,148.27 116.89,148.39 116.89,148.68 116.78,148.79 116.43,148.79 116.32,148.68 116.32,148.39 116.21,148.27 115.86,148.27 115.75,148.39 115.75,148.63 115.63,148.74 115.29,148.74 115.18,148.63 115.18,148.39 115.06,148.27 113.72,148.27 113.65,148.21 112.24,148.21 111.94,147.9 110.36,147.9 110.06,148.21 110.06,148.66 v2(109.8,148.92) 109.52,148.64 109.52,147.9 109.35,147.73 105.55,147.73 105.06,148.22 100.12,148.22 100.01,148.11 100.01,147.61 99.89,147.5 99.55,147.5 99.44,147.61 99.44,148.11 99.32,148.22 99.07,148.22 v2(98.37,148.92) 98.14,148.7 98.14,148 97.89,147.75 94.82,147.75 94.48,148.09 93.58,148.09 93.47,147.98 93.47,147.64 93.35,147.52 93.01,147.52 92.9,147.64 92.9,147.98 92.78,148.09 90.35,148.09 90.02,147.75 87.62,147.75 87.33,148.05 87.33,148.56 v2(87.12,148.77) 86.8,148.77 86.73,148.7 86.54,148.7 86.41,148.56 86.21,148.56 86.19,148.54 86.05,148.54 85.99,148.48 85.84,148.48 85.69,148.33 84.28,148.33 84.08,148.14 83.76,148.14 83.63,148 83.25,148 83.13,148.12 83.13,148.42 83.02,148.54 82.67,148.54 82.56,148.42 82.56,148.12 82.45,148 82.1,148 81.99,148.12 81.99,148.5 81.87,148.61 81.53,148.61 81.42,148.5 81.42,148.12 81.3,148 81.05,148 80.83,148.22 76.06,148.22 75.54,148.74 v2(75.54,148.82)
  ART07 w0.165: v2(121.23,148.92) 121.58,148.56 121.58,148.5 121.75,148.33 121.82,148.33 122.05,148.09 126.3,148.09 126.54,147.85 127.58,147.85 v2(127.99,147.45)
