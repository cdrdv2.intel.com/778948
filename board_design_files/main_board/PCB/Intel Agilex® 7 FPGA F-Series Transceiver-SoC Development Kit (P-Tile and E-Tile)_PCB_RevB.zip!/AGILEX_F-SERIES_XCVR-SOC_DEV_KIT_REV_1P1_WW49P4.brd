# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FLASH_DC0_RSTN: length 9.1
  TOP w0.109: J10.55 v2(183.44,92.61)
  BOTTOM w0.089: 178.66,91.95 178.53,91.95 178.15,91.57 177.45,91.57 v2(177.07,91.18)
  BOTTOM w0.109: v2(183.44,92.61) 182.01,91.19 R182.1 181.26,91.76 181.07,91.95 178.66,91.95
FLASH_DC1_IO0: length 20.8
  TOP w0.109: v2(186.03,105.49) 185.62,105.49 185.6,105.51 J11.5
  ART18 w0.114: v2(186.03,105.49) 186.69,104.83 186.69,101.8 178.99,94.11 177.45,94.11 177.36,94.02 177.22,94.02 175.32,94.02 175.32,94.02 175.03,94.02 v2(174.67,94.38)
FLASH_DC1_IO1: length 25.6
  TOP w0.109: v2(192,105.33) 191.83,105.51 J11.6
  ART03 w0.114: v2(173.87,95.18) 174.28,94.77 177.86,94.77 178.49,94.14 179.46,94.14 183.64,98.32 186.92,98.32 191.54,102.94 191.54,104.87 v2(192,105.33)
FLASH_DC1_IO2: length 24.2
  TOP w0.109: J11.16 192.09,108.01 v2(192.68,107.42)
  ART03 w0.114: v2(192.68,107.42) 190.22,104.96 190.22,102.8 186.58,99.16 183.29,99.16 179.57,95.43 178.65,95.43 178.58,95.5 177.78,95.5 177.3,95.98 v2(177.07,95.98)
FLASH_DC1_IO3: length 17.9
  TOP w0.109: J11.17 183.28,108.51 v2(182.7,109.09)
  ART18 w0.114: v2(182.7,109.09) 183.23,108.55 183.23,106.37 183,106.15 183,104.45 182.51,103.95 182.51,101.07 178.61,97.18 177.47,97.18 v2(177.07,96.78)
FLASH_DC1_IO4: length 28.3
  TOP w0.109: J11.8 192.19,106.01 v2(192.84,105.36)
  ART03 w0.114: v2(173.07,94.38) 173.44,94.01 178.18,94.01 178.46,93.73 180.29,93.73 181.07,94.51 181.43,94.51 184.8,97.88 187.28,97.88 192.84,103.43 v2(192.84,105.36)
FLASH_DC1_IO5: length 21.1
  TOP w0.109: v2(183.49,105.26) 183.49,106.25 183.75,106.51 J11.9
  ART18 w0.114: v2(183.49,105.26) 183.84,104.91 183.84,104.33 183.52,104.02 183.17,104.02 182.92,103.78 182.92,100.78 178.9,96.76 178.5,96.76 178.13,96.39 174.49,96.39 174.26,96.16 174.26,95.81 174.02,95.57 173.67,95.57 173.45,95.35 173.45,95 173.23,94.77 172.66,94.77 v2(172.27,94.38)
FLASH_DC1_IO6: length 23.7
  TOP w0.109: v2(183.46,110.62) 183.57,110.51 J11.25
  ART18 w0.114: v2(183.46,110.62) 185.01,109.07 185.01,103.22 184.53,102.74 184.53,101.14 184.49,101.1 184.49,101.09 179.94,96.55 179.94,95.91 179.46,95.43 178.61,95.43 178.37,95.19 178.01,95.19 177.62,94.79 175.88,94.79 v2(175.47,94.38)
FLASH_DC1_IO7: length 21.1
  TOP w0.109: v2(183.44,109.04) 183.44,109.28 183.67,109.51 183.68,109.51 J11.21
  ART18 w0.114: v2(183.44,109.04) 184.43,108.05 184.43,104.11 184.07,103.75 184.07,101.27 179.09,96.29 178.71,96.29 178.46,96.04 178.46,95.81 178.25,95.6 175.89,95.6 v2(175.47,95.18)
FLASH_DC1_IO8: length 24.2
  TOP w0.109: J11.18 192.35,108.51 v2(192.86,109.02)
  ART03 w0.114: v2(177.87,96.78) 177.9,96.75 178.43,96.75 178.46,96.72 179.61,96.72 182.91,100.02 186.07,100.02 188.21,102.16 188.21,104.33 190.17,106.28 190.17,107.19 191.26,108.28 192.12,108.28 v2(192.86,109.02)
FLASH_DC1_IO9: length 21.9
  TOP w0.109: J11.20 191.88,109.01 v2(191.97,108.91)
  ART03 w0.114: v2(177.87,97.58) 179.28,97.58 182.65,100.95 185.63,100.95 186.84,102.16 186.84,104.49 189.1,106.76 189.1,107.58 190.44,108.91 v2(191.97,108.91)
FLASH_DC1_IO10: length 25.5
  TOP w0.109: J11.10 192.42,106.51 v2(192.53,106.4)
  ART03 w0.114: v2(192.53,106.4) 192.33,106.4 190.64,104.71 190.64,102.63 186.75,98.74 183.47,98.74 179.31,94.58 178.54,94.58 177.93,95.2 177.65,95.2 177.27,95.58 175.87,95.58 v2(175.47,95.98)
FLASH_DC1_IO11: length 16.5
  TOP w0.109: v2(182.74,106.92) 182.82,107.01 183.68,107.01 J11.11
  ART18 w0.114: v2(182.74,106.92) 182.59,106.77 182.59,104.62 182.09,104.12 182.09,101.28 178.83,98.03 178.83,98.03 178.79,97.99 176.97,97.99 176.92,97.94 176.92,97.94 176.71,97.73 176.71,97.46 176.43,97.18 175.87,97.18 v2(175.47,96.78)
FLASH_DC1_IO12: length 21
  TOP w0.109: v2(189.63,107.47) 190.1,107.01 J11.12
  ART03 w0.114: v2(176.27,96.78) 176.64,97.16 179.45,97.16 182.83,100.53 185.87,100.53 187.27,101.93 187.27,104.24 189.52,106.49 189.52,107.36 v2(189.63,107.47)
FLASH_DC1_IO13: length 17.1
  TOP w0.109: J11.13 182.41,107.51 v2(182.24,107.67)
  ART18 w0.114: v2(176.27,97.58) 176.27,97.78 176.65,98.17 176.65,98.51 176.91,98.77 177.17,98.77 177.22,98.82 177.22,98.82 177.43,99.03 177.43,99.03 177.47,99.07 177.47,99.39 177.65,99.57 179.14,99.57 181.01,101.43 181.01,104.67 180.38,105.3 180.38,106.7 181.35,107.67 v2(182.24,107.67)
FLASH_DC1_IO14: length 23.9
  TOP w0.109: v2(191.97,110.21) 191.77,110.01 J11.24
  ART03 w0.114: v2(191.97,110.21) 191.77,110.01 190.94,110.01 188.68,107.75 188.68,106.97 186.69,104.98 185.11,104.98 183.95,103.81 183.95,103.02 182.04,101.11 178.95,98.02 178.36,98.02 178.33,97.99 176.12,97.99 175.71,97.58 v2(175.47,97.58)
FLASH_DC1_IO15: length 20.9
  TOP w0.109: J11.26 190.01,110.51 v2(189.68,110.18)
  ART03 w0.114: v2(189.68,110.18) 189.68,109.95 187.88,108.15 186.53,108.15 185.97,107.59 185.22,107.59 183.06,105.43 183.06,105.41 183.05,105.4 183.05,105.13 181.2,103.28 181.2,101.45 178.55,98.81 176.94,98.81 176.51,98.38 v2(176.27,98.38)
FLASH_DC1_IO16: length 22.1
  TOP w0.109: J11.28 v2(191.97,111.01)
  ART03 w0.114: v2(177.87,98.38) 178.39,98.38 178.49,98.48 178.81,98.48 181.62,101.28 181.62,102.68 182.96,104.02 183.51,104.02 183.58,104.09 183.59,104.09 184.35,104.85 184.35,105.66 185.82,107.13 187.93,107.13 188.26,107.47 188.26,107.92 191.35,111.01 v2(191.97,111.01)
FLASH_DC1_IO17: length 18.2
  TOP w0.109: J11.29 183.45,111.51 v2(182.61,110.67)
  ART18 w0.114: v2(177.07,98.38) 177.35,98.38 177.75,98.78 178.99,98.78 181.67,101.46 181.67,104.3 182.17,104.8 182.17,106.98 182.67,107.49 182.67,107.9 182.19,108.38 182.19,110.26 v2(182.61,110.67)
FLASH_DC1_IO18: length 20.8
  TOP w0.109: v2(189.3,111) 189.33,110.97 189.51,110.97 190.05,111.51 J11.30
  ART03 w0.114: v2(177.07,99.18) 177.47,99.58 178.14,99.58 180.36,101.8 180.36,103.63 182.17,105.43 182.17,106.96 182.88,107.67 183.46,107.67 185.39,109.6 185.97,109.6 186.58,110.21 188.48,110.21 189.27,111 v2(189.3,111)
FLASH_DC1_IO19: length 18.7
  TOP w0.109: v2(182.94,112.09) 183.02,112.01 J11.31
  ART18 w0.114: v2(182.94,112.09) 182.49,112.55 181.86,112.55 181.32,112 181.32,108.99 179.54,107.22 179.54,104.95 180.17,104.32 180.17,101.94 178.85,100.62 178.22,100.62 178.02,100.42 177.71,100.42 177.27,99.98 v2(177.07,99.98)
FLASH_DC1_IO20: length 20.3
  TOP w0.109: J11.32 189.91,112.01 v2(189.61,111.71)
  ART03 w0.114: v2(177.87,99.18) 178.33,99.18 180.78,101.63 180.78,103.46 182.63,105.31 182.63,105.58 182.64,105.58 182.64,105.6 185.05,108.01 185.07,108.01 185.54,108.48 185.72,108.48 186.36,109.12 188.03,109.12 189.84,110.92 189.84,111.48 v2(189.61,111.71)
FLASH_DC1_IO21: length 17.8
  TOP w0.109: J11.33 183.68,112.51 183.53,112.65 182.7,112.65 v2(182.16,112.12)
  ART18 w0.114: v2(182.16,112.12) 181.73,111.69 181.73,108.79 179.96,107.02 179.96,105.12 180.59,104.49 180.59,101.68 178.97,100.05 178.35,100.05 178.28,99.98 v2(177.87,99.98)
FLASH_DC1_IO22: length 25.9
  TOP w0.109: v2(189.63,112.51) J11.34
  ART03 w0.114: v2(189.63,112.51) 188.27,111.15 186.97,111.15 186.43,110.62 185.94,110.62 185.92,110.6 185.68,110.6 183.36,108.28 181.61,108.28 179.68,106.35 179.68,101.85 178.2,100.38 176.88,100.38 176.68,100.18 176.68,99.03 176.43,98.78 175.98,98.78 175.87,98.67 175.87,98.2 175.64,97.97 175.06,97.97 v2(174.67,97.58)
FLASH_DC1_IO23: length 24.9
  TOP w0.109: v2(183.22,113.12) 183.61,113.51 J11.37
  ART18 w0.114: v2(183.22,113.12) 183.1,113 181.63,113 180.79,112.17 180.79,109.07 178.53,106.81 178.53,104.88 178.76,104.65 179.21,104.65 179.65,104.21 179.65,102.06 178.84,101.24 177.7,101.24 177.47,101.02 177.47,100.61 177.21,100.36 176.86,100.36 176.68,100.18 176.68,99.09 176.63,99.03 176.63,99.03 176.42,98.82 176.42,98.82 176.38,98.78 176.02,98.78 175.87,98.63 175.87,98.16 175.68,97.97 174.26,97.97 v2(173.87,97.58)
FLASH_DC1_IO24: length 24.2
  TOP w0.109: v2(189.66,113.51) J11.38
  ART03 w0.114: v2(189.66,113.51) 187.98,111.84 187.12,111.84 186.97,111.68 185.8,111.68 183.69,109.57 182.09,109.57 178.56,106.04 178.56,102.03 177.82,101.3 176.96,101.3 176.68,101.01 176.68,100.63 176.45,100.41 176.1,100.41 175.84,100.15 175.84,99.56 v2(175.47,99.18)
FLASH_DC1_IO25: length 21.3
  TOP w0.109: J11.41 182.58,114.51 v2(182.39,114.32)
  ART18 w0.114: v2(176.27,99.18) 175.87,99.58 175.87,101.32 176.09,101.54 176.09,102.44 176.6,102.96 176.6,103.75 176.5,103.86 176.5,106.55 179.41,109.46 179.41,112.86 180.87,114.32 v2(182.39,114.32)
FLASH_DC1_IO26: length 32.8
  TOP w0.109: v2(188.85,103.38) 188.85,113.31 190.05,114.51 J11.42
  ART03 w0.114: v2(173.07,95.18) 173.46,95.57 173.46,96.22 173.61,96.37 178.18,96.37 178.24,96.3 179.84,96.3 183.14,99.6 186.42,99.6 188.85,102.02 v2(188.85,103.38)
FLASH_DC1_IO27: length 27.3
  TOP w0.109: v2(183.36,115.19) 183.54,115.01 J11.43
  ART18 w0.114: v2(183.36,115.19) 182.76,115.79 180.46,115.79 177.95,113.27 177.95,109.78 175.24,107.07 175.24,103.97 174.04,102.77 174.04,101.76 173.65,101.37 173.65,100.72 173.46,100.53 173.46,96.37 v2(173.07,95.98)
FLASH_DC1_IO28: length 25
  TOP w0.109: v2(191.95,115.01) J11.44
  ART03 w0.114: v2(176.27,100.78) 176.27,101.06 177.24,102.03 177.24,105.64 181.63,110.03 183.49,110.03 185.63,112.18 186.88,112.18 187.07,112.37 187.83,112.37 189.71,114.25 191.18,114.25 v2(191.95,115.01)
FLASH_DC1_IO29: length 22.1
  TOP w0.109: J11.45 185.66,115.51 v2(185.85,115.32)
  ART18 w0.114: v2(177.07,100.78) 177.07,101.23 177.64,101.8 178.1,101.8 178.34,102.04 178.34,103.2 177.34,104.21 177.34,106.2 180.29,109.15 180.29,112.37 181.37,113.46 182.91,113.46 183.22,113.77 184.3,113.77 v2(185.85,115.32)
FLASH_DC1_IO30: length 28.9
  TOP w0.109: v2(189.58,115.14) 189.96,115.51 J11.46
  ART03 w0.114: v2(189.58,115.14) 189.2,115.52 187.47,115.52 186.43,114.48 185.44,114.48 183.59,112.62 181.94,112.62 175.51,106.2 175.51,103.54 174.47,102.49 174.47,101.63 174.68,101.41 174.68,99.3 174.17,98.78 173.47,98.78 v2(173.07,98.38)
FLASH_DC1_IO31: length 24
  TOP w0.109: v2(182.17,115.21) 182.97,116.01 J11.47
  ART18 w0.114: v2(173.87,98.38) 174.32,98.83 174.32,101.45 174.47,101.6 174.47,102.54 175.66,103.73 175.66,106.9 178.48,109.72 178.48,113.21 180.48,115.21 v2(182.17,115.21)
FLASH_DC1_IO32: length 30.6
  TOP w0.109: J11.48 189.75,116.01 v2(189.58,115.85)
  ART03 w0.114: v2(189.58,115.85) 190.01,116.28 190.01,116.74 189.74,117.02 187.17,117.02 186.37,116.22 185.15,116.22 183.59,114.65 183.44,114.65 182.55,113.77 181.66,113.77 174.27,106.37 174.27,104.04 173.17,102.95 173.17,101.57 173.46,101.29 173.46,99.57 v2(173.07,99.18)
FLASH_DC1_IO33: length 27.9
  TOP w0.109: v2(189.56,116.59) 189.63,116.51 J11.50
  ART03 w0.114: v2(189.56,116.59) 187.5,116.59 186.71,115.8 185.52,115.8 183.36,113.64 183.08,113.64 182.56,113.12 181.84,113.12 174.89,106.16 174.89,103.63 174.05,102.79 174.05,101.32 174.34,101.02 174.34,99.65 v2(173.87,99.18)
FLASH_DC1_IO34: length 25.3
  TOP w0.109: v2(183.44,116.69) 183.44,116.76 183.69,117.01 J11.51
  ART18 w0.114: v2(174.67,98.38) 174.67,101.1 175.67,102.1 175.67,102.62 176.08,103.02 176.08,106.72 178.99,109.63 178.99,113.13 180.62,114.76 183.54,114.76 183.77,114.99 183.77,115.01 183.78,115.02 183.78,116.35 v2(183.44,116.69)
FLASH_DC1_IO35: length 28.4
  TOP w0.109: 188.87,116.53 189.35,117.01 J11.52
  TOP w0.127: 188.87,116.53 188.87,115.09 v2(188.85,115.06)
  ART03 w0.114: v2(175.47,98.38) 175.08,98.77 175.08,101.3 175.6,101.81 175.6,102.92 176.13,103.46 176.13,106.18 181.61,111.66 183.54,111.66 185.37,113.49 186.64,113.49 187.55,114.4 188.19,114.4 v2(188.85,115.06)
FLASH_DC1_IO36: length 29.3
  TOP w0.109: J11.53 183.44,117.51 v2(183.43,117.52)
  ART18 w0.114: v2(172.27,95.18) 172.29,95.18 172.67,95.55 172.67,100.81 173.11,101.26 173.11,102.44 174.82,104.14 174.82,107.24 177.53,109.95 177.53,113.5 180.44,116.41 182.32,116.41 v2(183.43,117.52)
FLASH_DC1_IO37: length 32.8
  TOP w0.109: v2(189.58,117.51) J11.54
  ART03 w0.114: v2(189.58,117.51) 185.54,117.51 183.88,115.85 183.39,115.85 182.29,114.76 181.91,114.76 172.67,105.51 172.67,96.38 v2(172.27,95.98)
FLASH_DC1_IO38: length 30.1
  TOP w0.109: J11.56 191.87,118.01 192.46,117.42 192.46,117.35 192.58,117.22 v2(192.62,117.22)
  ART03 w0.114: v2(192.62,117.22) 192.58,117.22 192.38,117.42 191.38,117.42 190.97,117.01 190.97,115.81 189.86,114.71 189.28,114.71 188.01,113.43 187.54,113.43 186.7,112.6 185.22,112.6 183.77,111.15 182.01,111.15 176.71,105.84 176.71,103.28 176.09,102.67 176.09,101.65 175.47,101.02 v2(175.47,99.98)
FLASH_DC1_IO39: length 25.1
  TOP w0.109: v2(183.24,118.46) 183.3,118.52 J11.57
  ART18 w0.114: v2(183.24,118.46) 184.27,117.42 184.27,114.92 184.19,114.84 184.19,114.81 183.67,114.3 183.16,114.3 182.73,113.87 181.06,113.87 179.83,112.65 179.83,109.29 176.92,106.37 176.92,104.03 177.22,103.73 177.22,101.98 176.65,101.41 176.65,100.58 176.27,100.2 v2(176.27,99.98)
FLASH_DC1_PRSNTN: length 293.6
  TOP w0.109: U23.M18 v2(41.14,179.92) 41.14,180.83 40.1,181.86 40.1,182.92 R355.1 39.68,183.07 39.68,183.07 R181.1
  ART07 w0.114: v2(41.14,179.92) 41.53,179.53 42.06,179.53 43.1,178.48 43.1,177.37 43.35,177.11 46.24,177.11 46.35,177 46.35,174.5 46.48,174.37 53.47,174.37 56.77,171.07 60.71,171.07 61.85,169.93 61.85,168.66 63.31,167.2 64.2,167.2 65.41,165.99 67.18,165.99 67.94,165.23 73.53,165.23 78.74,170.43 78.74,170.94 79.5,171.7 127.89,171.7 128.65,170.94 128.65,167.89 132.46,164.08 136.14,164.08 136.47,163.75 138.76,163.75 139.45,163.07 139.45,161.8 140.59,160.66 147.19,160.66 148.34,159.51 159.39,159.51 164.97,153.92 171.83,153.92 172.59,154.69 174.75,154.69 175.52,153.92 185.8,153.92 187.32,152.4 188.09,152.4 190.09,150.4 190.09,141.31 191.08,140.32 191.08,137.83 188.32,135.06 188.32,129.78 189.97,128.13 189.97,128.11 189.99,128.09 189.99,127.28 190.4,126.87 190.4,124.38 189.79,123.77 189.79,118.03 196.01,111.81 196.01,110.69 v2(197.53,109.17)
  ART18 w0.114: v2(165.07,87.98) 164.89,87.98 164.49,87.58 164.11,87.58 163.85,87.32 163.85,82.24 164.16,81.94 172.77,81.94 173.84,80.87 180.88,80.87 181.23,81.23 183.64,81.23 185.09,82.68 185.09,82.72 185.1,82.73 185.1,83.04 186.94,84.89 186.94,85.24 187.4,85.7 188.87,85.7 189.3,85.27 190.14,85.27 191.27,86.4 193.13,86.4 193.57,86.84 193.57,89.18 195.04,90.65 195.04,95.98 197.46,98.39 197.46,109.09 v2(197.53,109.17)
  BOTTOM w0.109: R179.2 163.93,85.63 163.58,85.98 163.58,87.12 164.03,87.58 164.67,87.58 v2(165.07,87.98)
FLASH_DC1_RSTN: length 32.1
  TOP w0.109: J11.55 182.96,118.01 v2(182.58,117.63)
  ART16 w0.114: v2(177.87,91.18) 177.87,91.44 177.48,91.83 177.48,100.17 177.7,100.38 178.14,100.38 178.53,100.77 178.53,113.59 v2(182.58,117.63)
  BOTTOM w0.127: v2(182.58,117.63) 182.49,117.72 R183.1
FMC_JTAG_BYPASSN: length 187.3
  TOP w0.109: U23.L12 v2(40.34,175.12)
  ART03 w0.114: v2(40.34,175.12) 40.74,175.52 40.74,176.21 40.85,176.33 42.18,176.33 42.34,176.49 42.34,177.72 42.52,177.9 48.74,177.9 53.72,182.88 63.12,182.88 65.02,184.78 72.9,184.78 75.08,182.6 75.08,176.38 77.98,173.48 77.98,172.85 79.63,171.2 134.24,171.2 136.47,173.43 136.47,187.4 141.86,192.79 142.88,192.79 144.02,193.93 144.02,194.82 145.11,195.91 164.59,195.91 165.52,194.98 170.22,194.98 171.17,194.03 174.14,194.03 176.56,191.62 176.56,189.92 183.01,183.46 186.01,183.46 v2(186.87,182.6)
FPGA_DNU_CORE0:
  vias: v2(137.31,89.6)
FPGA_DNU_CORE1:
  vias: v2(137.31,88.6)
FPGA_DNU_CORE2:
  vias: v2(132.11,92.6)
FPGA_DNU_CORNER0:
  vias: v2(137.31,91.6)
FPGA_DNU_CORNER1:
  vias: v2(123.45,110.6)
FPGA_DNU_CORNER2:
  vias: v2(100.07,93.1)
FPGA_DNU_CORNER3:
  vias: v2(100.94,110.6)
FPGA_DNU_CORNER4:
  vias: v2(137.31,92.6)
FPGA_DNU_CORNER5:
  vias: v2(122.58,110.1)
FPGA_DNU_CORNER6:
  vias: v2(100.94,92.6)
FPGA_DNU_CORNER7:
  vias: v2(100.94,109.6)
FPGA_DNU_SDM0:
  vias: v2(130.38,91.6)
FPGA_DNU_SDM1:
  vias: v2(130.38,92.6)
FPGA_GPIO0: length 53.4
  ART03 w0.114: v2(123.45,113.6) 123.45,113.15 124.22,112.38 124.22,111.84 124.94,111.11 125.43,111.11 126,110.54 126.3,110.54 126.68,110.16 127.05,110.16 127.55,109.66 127.86,109.66 128.44,109.09 128.8,109.09 129.2,108.7 129.74,108.7 130.18,109.13 130.67,109.13 131.16,108.64 131.43,108.64 131.91,108.15 132.41,108.15 132.78,108.52 133.22,108.52 133.62,108.13 133.97,108.13 134.45,107.65 134.95,107.65 135.42,107.18 135.76,107.18 136.33,106.6 136.72,106.6 137.12,106.2 137.52,106.2 138.06,105.65 139.25,105.65 140.53,104.37 145.75,104.37 146.15,104.78 149.69,104.78 151.05,103.42 153.98,103.42 154.59,102.81 154.59,101.66 155.24,101.01 159.93,101.01 161.35,99.59 165.2,99.59 165.48,99.31 165.48,99.03 165.71,98.81 165.99,98.81 166.26,98.54 166.26,97.19 v2(166.67,96.78)
FPGA_GPIO1: length 56.9
  ART03 w0.114: v2(166.67,95.98) 167.08,96.39 167.08,98.55 166.83,98.81 166.5,98.81 166.29,99.02 166.29,100.15 166.04,100.41 165.68,100.41 165.48,100.61 165.48,101.55 165,102.02 165,102.28 161.72,105.56 144.58,105.56 143.56,106.58 140.09,106.58 138.84,107.84 138.84,109.5 138.62,109.71 138.01,109.71 137.53,110.2 136.94,110.2 136.46,110.68 136.28,110.68 135.79,111.18 135.37,111.18 134.89,111.66 134.62,111.66 134.14,111.18 133.53,111.18 133.12,111.58 131.05,111.58 130.67,111.2 130.19,111.2 129.31,112.08 128.45,112.08 127.98,112.55 127.62,112.55 127.29,112.21 125.02,112.21 124.7,112.53 124.7,113.26 124.25,113.71 124.16,113.71 123.74,114.13 123.74,114.31 v2(123.45,114.6)
FPGA_GPIO2: length 50.7
  ART03 w0.114: v2(165.87,98.38) 165.62,98.38 165.2,98.81 163.58,98.81 163.45,98.93 161.57,98.93 161.01,99.49 159.89,99.49 159.89,99.49 158.63,99.49 158.29,99.83 155.59,99.83 152.32,103.1 150.92,103.1 149.55,104.46 146.28,104.46 145.88,104.06 140.2,104.06 139.64,104.61 137.86,104.61 137.44,105.03 137.1,105.03 136.73,104.66 136.27,104.66 135.74,105.19 135.37,105.19 134.92,105.64 134.37,105.64 133.9,106.11 133.63,106.11 133.2,106.54 132.78,106.54 132.44,106.2 131.9,106.2 131.57,106.53 131.18,106.53 130.57,107.15 130.07,107.15 129.64,107.58 129.22,107.58 128.7,108.1 128.44,108.1 127.98,108.56 127.72,108.56 127.14,109.14 126.67,109.14 126.23,109.59 125.79,109.59 125.29,110.1 124.96,110.1 122.94,112.11 122.94,112.74 v2(122.58,113.1)
FPGA_GPIO3: length 51.9
  ART03 w0.114: v2(122.58,114.1) 123.5,114.1 123.84,113.76 123.84,113.03 125.22,111.65 126.24,111.65 126.68,111.2 127.04,111.2 127.62,110.62 127.84,110.62 128.36,110.1 128.71,110.1 129.3,109.51 129.71,109.51 130.35,110.16 130.68,110.16 131.04,110.52 131.57,110.52 131.9,110.19 132.26,110.19 132.8,109.64 133.2,109.64 133.71,109.13 134.16,109.13 134.58,109.55 134.94,109.55 135.39,109.09 135.75,109.09 136.23,108.61 136.64,108.61 137.06,108.19 137.43,108.19 137.98,107.64 138.37,107.64 138.87,107.14 138.87,106.73 140.72,104.89 145.72,104.89 146.08,105.24 153.39,105.24 154.83,103.8 160.15,103.8 163.6,100.36 165.25,100.36 165.46,100.15 165.46,99.8 165.87,99.38 v2(165.87,99.18)
FPGA_GPIO4: length 55.6
  ART03 w0.114: v2(164.27,97.58) 163.86,97.58 163.8,97.64 163.62,97.64 163.58,97.6 161.33,97.6 161.03,97.9 156.01,97.9 155.35,98.55 146.53,98.55 144.57,100.51 137.96,100.51 137.62,100.16 137.07,100.16 136.59,99.68 136.09,99.68 135.72,100.05 135.46,100.05 134.95,99.54 134.45,99.54 133.88,100.11 133.64,100.11 133.17,100.58 132.69,100.58 132.16,101.12 131.84,101.12 131.42,101.54 131.11,101.54 130.66,101.99 130.05,101.99 129.64,101.59 129.21,101.59 128.92,101.88 128.92,102.32 129.03,102.44 129.03,102.89 128.8,103.12 128.45,103.12 127.93,103.64 127.61,103.64 127.19,104.06 126.8,104.06 126.5,104.36 126.5,106.35 126.21,106.64 125.74,106.64 125.25,107.14 124.98,107.14 124.5,107.62 124.04,107.62 123.58,108.08 123.22,108.08 122.64,108.65 122.43,108.65 121.92,109.16 121.51,109.16 121.33,109.34 121.33,112.76 121.72,113.15 v2(121.72,113.6)
FPGA_GPIO5: length 53.2
  ART03 w0.114: v2(164.27,98.38) 161.52,98.38 160.74,99.16 158.37,99.16 158.09,99.44 155.5,99.44 152.16,102.78 150.78,102.78 149.45,104.11 146.56,104.11 146.12,103.68 138.04,103.68 137.54,104.18 137.08,104.18 136.51,103.61 136.26,103.61 135.85,103.2 135.37,103.2 134.96,103.61 134.43,103.61 133.97,104.06 133.6,104.06 133.15,104.52 132.84,104.52 132.45,104.13 131.97,104.13 131.39,104.7 131,104.7 130.51,105.19 130.12,105.19 129.78,105.54 129.34,105.54 128.83,106.05 128.5,106.05 128.22,106.32 128.22,107.23 127.76,107.68 127.53,107.68 127.14,108.08 126.78,108.08 126.16,108.7 125.73,108.7 125.27,109.16 125.04,109.16 124.6,109.6 124.1,109.6 123.56,110.15 123.19,110.15 122.52,110.82 122.52,112.62 122.2,112.94 122.2,113.26 122.21,113.27 122.21,113.28 122.3,113.36 122.3,113.37 122.35,113.42 122.35,113.78 122.3,113.83 122.3,113.84 122.01,114.13 122.01,114.31 v2(121.72,114.6)
FPGA_GPIO6: length 61.5
  ART03 w0.114: v2(165.87,96.78) 165.47,97.18 164.88,97.18 164.67,96.96 164.67,96.6 164.44,96.37 164.06,96.37 163.72,96.71 160.49,96.71 160.41,96.63 159.76,96.63 159.68,96.71 151.62,96.71 150.75,95.83 146.67,95.83 144.51,97.99 138.86,97.99 138.53,97.66 137.95,97.66 137.48,98.13 137.13,98.13 136.66,97.66 136.23,97.66 135.84,98.06 135.41,98.06 134.98,97.62 134.4,97.62 133.92,98.11 133.59,98.11 133.1,98.6 132.73,98.6 132.21,99.12 131.83,99.12 131.41,99.54 131,99.54 130.61,99.15 130.15,99.15 129.64,99.66 129.2,99.66 128.64,100.21 128.27,100.21 127.84,100.65 127.56,100.65 127.05,101.16 126.63,101.16 126.11,101.68 125.69,101.68 125.26,102.11 124.86,102.11 124.48,102.49 124.16,102.49 123.63,103.01 123.36,103.01 123.05,103.31 123.05,105.45 122.83,105.66 122.31,105.66 122.15,105.83 122.15,106.76 121.77,107.14 121.45,107.14 120.93,107.66 120.69,107.66 120.17,108.18 119.74,108.18 119.51,108.41 119.51,110.86 119.74,111.09 120.1,111.09 120.43,111.42 120.43,112.68 v2(120.85,113.1)
FPGA_GPIO7: length 56.7
  ART03 w0.114: v2(120.85,114.1) 121.77,114.1 122.11,113.76 122.11,113.44 122.02,113.35 121.96,113.29 121.96,112.91 122.11,112.76 122.11,109.88 122.36,109.63 122.83,109.63 123.28,109.18 123.58,109.18 124.14,108.62 124.5,108.62 125.01,108.12 125.29,108.12 125.7,107.7 126.03,107.7 126.56,107.18 127.15,107.18 127.38,106.95 127.38,105.92 127.7,105.6 127.98,105.6 128.21,105.37 128.21,104.49 128.49,104.21 128.76,104.21 129.03,103.93 129.03,103.69 129.16,103.57 129.83,103.57 130.2,103.2 130.76,103.2 131.05,103.49 131.44,103.49 131.85,103.09 132.25,103.09 132.77,102.57 133.13,102.57 133.59,102.11 133.93,102.11 134.4,101.64 134.8,101.64 135.24,101.19 135.83,101.19 136.23,101.6 136.47,101.6 136.59,101.71 136.6,101.71 136.92,102.03 137.69,102.03 138.01,101.71 138.33,101.71 138.55,101.93 139.36,101.93 140,101.28 144.82,101.28 147.17,98.93 155.42,98.93 156.14,98.22 161.17,98.22 161.47,97.92 163.45,97.92 163.53,97.99 165.46,97.99 v2(165.87,97.58)
FPGA_GPIO8: length 64
  ART03 w0.114: v2(165.07,96.78) 165.07,96.53 164.67,96.13 164.67,95.78 164.46,95.58 163.6,95.58 163.36,95.82 161.96,95.82 160.96,94.82 158.8,94.82 157.35,96.27 151.79,96.27 150.98,95.45 146.52,95.45 146.02,95.95 140.22,95.95 139.67,96.49 137.86,96.49 137.54,96.18 137.12,96.18 136.66,96.63 136.31,96.63 135.78,97.17 135.39,97.17 134.94,96.71 134.4,96.71 134.11,97 133.58,97 133.16,96.58 132.72,96.58 132.33,96.2 131.95,96.2 131.5,96.65 131.1,96.65 130.63,97.12 130.12,97.12 129.63,97.61 129.18,97.61 128.7,98.09 128.42,98.09 127.91,98.6 127.71,98.6 127.14,99.17 126.68,99.17 126.25,99.61 125.96,99.61 125.43,100.14 125.08,100.14 124.57,100.65 124.03,100.65 123.67,101 123.44,101 122.81,101.64 122.24,101.64 121.79,102.08 121.39,102.08 121.25,102.22 121.25,106.38 121.06,106.57 120.73,106.57 120.14,107.15 119.8,107.15 119.39,107.56 118.99,107.56 118.73,107.81 118.73,111.38 118.95,111.59 119.32,111.59 119.57,111.85 119.57,113.18 v2(119.99,113.6)
FPGA_GPIO9: length 59.3
  ART03 w0.114: v2(165.07,97.58) 164.84,97.58 164.44,97.18 164.01,97.18 163.85,97.03 160.36,97.03 160.28,96.95 159.89,96.95 159.81,97.03 155.8,97.03 154.59,98.23 146.26,98.23 145.97,98.53 137.93,98.53 137.46,99 137.03,99 136.7,98.67 136.31,98.67 135.84,99.14 135.42,99.14 134.91,98.63 134.49,98.63 134.07,99.05 133.77,99.05 133.2,99.62 132.88,99.62 132.3,100.2 131.9,100.2 131.48,100.62 131.14,100.62 130.67,101.09 130.09,101.09 129.71,100.71 129.2,100.71 128.88,101.03 128.52,101.03 128.04,101.52 127.69,101.52 127.39,101.82 127.39,102.83 127.09,103.14 126.56,103.14 126,103.7 125.76,103.7 125.35,104.1 125.02,104.1 124.42,104.7 124.13,104.7 123.86,104.97 123.86,106.79 123.51,107.15 123.16,107.15 122.61,107.71 122.17,107.71 121.7,108.18 121.39,108.18 120.99,108.57 120.75,108.57 120.42,108.9 120.42,110.78 120.93,111.29 120.93,112.63 121.28,112.98 121.28,113.3 120.94,113.65 120.59,113.65 119.99,114.25 v2(119.99,114.6)
FPGA_GPIO10: length 64.1
  ART03 w0.114: v2(119.12,113.1) 119.6,113.58 119.6,114.76 119.83,114.99 120.32,114.99 120.59,114.71 121.28,114.71 121.56,114.99 121.89,114.99 122.16,114.71 122.87,114.71 123.2,115.04 123.62,115.04 123.74,114.93 123.74,114.86 124.08,114.52 124.44,114.52 124.8,114.17 124.8,113.44 125.02,113.21 125.39,113.21 126.01,112.59 126.3,112.59 126.75,113.03 129.2,113.03 130.04,112.19 130.7,112.19 131.08,112.57 131.47,112.57 131.85,112.19 134.24,112.19 134.62,112.57 134.9,112.57 135.37,112.1 135.74,112.1 136.17,111.67 137.54,111.67 139.28,109.93 139.28,108.01 140.31,106.98 143.91,106.98 144.88,106.02 161.9,106.02 165.32,102.59 165.32,102.15 166.27,101.21 166.27,100.61 166.5,100.38 166.83,100.38 167.08,100.13 167.08,99.01 167.28,98.81 167.59,98.81 167.87,98.53 167.87,96.38 v2(168.27,95.98)
FPGA_GPIO11: length 68.1
  ART03 w0.114: v2(168.27,95.18) 168.48,95.18 168.91,95.61 169.27,95.61 169.47,95.81 169.47,98.54 169.21,98.81 168.86,98.81 168.66,99.01 168.66,100.15 168.42,100.38 168.1,100.38 167.83,100.65 167.83,100.98 166.98,101.83 166.98,102.95 165.62,104.31 165.62,105.9 164.69,106.83 145.13,106.83 144.24,107.72 140.93,107.72 140.16,108.5 140.16,110.77 137.21,113.71 136.28,113.71 135.86,114.13 135.36,114.13 134.92,114.57 134.45,114.57 134.1,114.21 133.56,114.21 133.26,114.52 132.68,114.52 132.33,114.17 131.81,114.17 131.46,114.53 131,114.53 130.64,114.17 130.17,114.17 129.73,114.62 128.94,114.62 128.5,114.17 126.64,114.17 126.1,114.71 125.89,114.71 125.88,114.72 125.83,114.72 125.52,115.04 125.02,115.04 124.36,115.7 123.9,115.7 123.57,116.03 123.16,116.03 122.74,115.61 122.35,115.61 121.96,115.21 121.88,115.21 121.88,115.21 121.56,115.21 121.56,115.21 121.44,115.21 121.16,115.49 120.06,115.49 119.12,114.55 v2(119.12,114.1)
FPGA_GPIO12: length 64.7
  ART03 w0.114: v2(165.07,95.98) 165.29,95.98 165.71,96.39 166.07,96.39 166.27,96.19 166.27,95.8 166.49,95.58 168.43,95.58 168.66,95.81 168.66,98.55 168.44,98.77 168.11,98.77 167.87,99.01 167.87,100.13 167.59,100.41 167.29,100.41 167.06,100.64 167.06,101.3 166.66,101.7 166.66,102.82 165.3,104.18 165.3,105.77 164.67,106.4 144.98,106.4 144.08,107.3 arc(144.04,107.33) 143.98,107.34 140.67,107.34 139.74,108.27 139.74,110.32 138,112.06 137.15,112.06 136.66,112.55 136.21,112.55 135.65,113.11 135.43,113.11 134.94,113.6 134.51,113.6 133.93,113.03 133.77,113.03 133.18,113.61 132.8,113.61 132.32,113.13 131.86,113.13 131.36,113.64 130.98,113.64 130.42,113.08 130.1,113.08 129.59,113.59 125.93,113.59 125.31,114.21 125.02,114.21 124.52,114.71 124.16,114.71 123.93,114.94 123.93,115.12 v2(123.45,115.6)
FPGA_GPIO13: length 67.2
  ART03 w0.114: v2(123.45,116.6) 124.52,116.6 125.06,116.07 125.4,116.07 125.91,115.56 126.21,115.56 126.64,115.13 127.24,115.13 127.65,115.54 127.94,115.54 128.38,115.09 128.94,115.09 129.39,115.54 129.9,115.54 130.22,115.21 130.54,115.21 130.77,115.44 130.77,115.54 130.89,115.66 134.79,115.66 135.32,115.13 135.79,115.13 136.36,114.55 137.17,114.55 140.69,111.04 140.69,110.32 142.13,108.89 142.13,108.41 142.43,108.1 144.32,108.1 145.21,107.21 164.82,107.21 165.94,106.09 165.94,104.44 168.08,102.3 168.08,101.52 168.66,100.94 168.66,100.61 168.88,100.38 169.21,100.38 169.47,100.12 169.47,99.01 169.67,98.81 170.05,98.81 170.25,98.6 170.25,95.02 170.03,94.79 166.5,94.79 166.27,95.02 166.27,95.32 165.87,95.72 v2(165.87,95.98)
FPGA_GPIO14: length 78.4
  ART03 w0.114: v2(122.58,116.1) 122.16,116.52 122.16,117.4 122.3,117.54 122.76,117.54 123.23,118.01 123.53,118.01 124.08,118.55 124.49,118.55 124.97,118.07 124.97,118.03 125.3,118.03 125.81,118.54 126.26,118.54 126.72,118.08 127.46,118.08 128.32,117.22 arc(128.73,117.11) 129.08,117.35 arc(129.51,117.6) 129.95,117.35 arc(130.38,117.1) 130.81,117.35 arc(131.24,117.6) 131.68,117.35 131.68,117.34 arc(132.12,117.1) 132.54,117.35 arc(132.97,117.6) 133.4,117.36 133.42,117.34 arc(133.85,117.1) 134.28,117.35 arc(134.7,117.6) 135.14,117.36 135.19,117.26 135.31,117.14 135.83,117.14 136.17,117.49 136.68,117.49 141.85,112.32 141.85,110.54 142.33,110.06 143.71,110.06 145.34,108.43 147.5,108.43 147.72,108.66 150.98,108.66 151.71,107.92 166.11,107.92 169.57,104.47 169.57,101.68 170.26,100.99 170.26,100.63 170.55,100.34 170.82,100.34 170.82,100.34 170.91,100.34 171.03,100.22 171.03,99.45 171.86,98.63 171.86,94.97 171.68,94.79 171.35,94.79 171.03,94.48 171.03,94.23 170.82,94.02 170.57,94.02 170.26,93.7 170.26,93.4 170.05,93.19 166.47,93.19 166.27,93.4 166.27,93.7 165.96,94.01 165.71,94.01 165.46,94.26 165.46,94.79 v2(165.07,95.18)
FPGA_GPIO15: length 72.6
  ART03 w0.114: v2(122.58,117.1) 123.67,117.1 124.13,117.56 124.61,117.56 124.98,117.2 125.39,117.2 125.98,116.6 126.05,116.6 arc(126.3,116.53) 126.48,116.35 126.48,116.35 arc(126.91,116.1) 127.35,116.35 127.35,116.35 arc(127.78,116.6) 128.21,116.35 arc(128.65,116.1) 129.08,116.35 arc(129.51,116.6) 129.95,116.35 129.95,116.35 arc(130.38,116.1) 130.81,116.35 130.81,116.35 arc(130.99,116.53) 131.24,116.6 arc(131.49,116.53) 131.68,116.35 131.68,116.35 arc(132.11,116.1) 132.54,116.35 arc(132.98,116.6) 133.41,116.35 133.41,116.35 arc(133.85,116.1) 134.28,116.35 arc(134.71,116.6) 135.14,116.35 135.14,116.35 arc(135.58,116.1) 136.01,116.35 arc(136.44,116.6) 136.87,116.36 137.6,115.09 141.4,111.29 141.4,110.35 142.63,109.12 143.81,109.12 145.39,107.54 147.29,107.54 148.09,108.34 150.81,108.34 151.61,107.54 165.02,107.54 166.37,106.2 166.37,104.57 168.45,102.49 168.45,102.01 169.47,100.99 169.47,100.59 169.67,100.38 170.05,100.38 170.25,100.18 170.25,99.06 170.54,98.77 170.95,98.77 171.07,98.65 171.07,95 170.84,94.77 170.48,94.77 170.28,94.56 170.28,94.23 170.03,93.98 166.44,93.98 166.27,94.16 166.27,94.51 165.87,94.91 v2(165.87,95.18)
FPGA_GPIO_OUTCLKN: length 135.2
  ART16 w0.094: v2(101.8,87.1) 101.8,86.8 101.71,86.7 101.38,86.7 101.09,86.42 101.09,85.98 102.39,84.68 102.39,82.89 100.94,81.44 100.94,80.59 99.87,79.53 99.87,78.68 98.26,77.07 96.8,77.07 91.3,71.56 88.78,71.56 82.01,64.8 67.68,64.8 63.42,60.54 63.42,45.78 61.3,43.66 61.3,32.06 65.32,28.04 90.27,28.04 93.12,25.2 93.12,8.98 v3(92.77,8.64)
FPGA_GPIO_OUTCLKP: length 135
  ART16 w0.094: v2(101.8,86.1) 101.8,86.4 101.71,86.5 101.46,86.5 101.3,86.33 101.3,86.06 102.59,84.77 102.59,82.8 101.14,81.35 101.14,80.51 100.08,79.44 100.08,78.6 98.34,76.86 96.89,76.86 91.38,71.36 88.86,71.36 82.09,64.59 67.77,64.59 63.63,60.45 63.63,45.69 61.51,43.57 61.51,32.14 65.41,28.24 65.69,28.24 65.79,28.35 65.99,28.35 66.09,28.24 90.36,28.24 93.32,25.28 93.32,25.1 93.42,25 93.42,24.8 93.32,24.7 93.32,8.98 v3(93.66,8.64)
FPGA_GPIO_REFCLK: length 94.3
  ART16 w0.114: v2(65.22,124.87) 65.22,118.06 61.24,114.07 57.4,114.07 55.41,112.07 v2(55.41,111.25)
  BOTTOM w0.109: v2(65.22,124.87) 65.38,125.02 65.38,128.67 74.63,137.92 78.46,137.92 80.36,136.02 106.02,136.02 111.1,130.94 111.1,122.3 111.86,121.54 112.62,121.54 113.38,120.78 113.38,119.89 114.4,118.87 114.4,115.25 R1027.1
FPGA_GPIO_REFCLKN0: length 95.8
  ART16 w0.094: v2(103.53,82.1) 103.13,81.7 102.92,81.7 102.48,81.26 102.48,77.09 101.56,76.17 101.56,73.95 92.85,65.24 86.02,65.24 83.06,62.28 80.63,62.28 79.4,63.51 67.91,63.51 64.59,60.2 64.59,54.22 65.77,53.04 65.77,38.19 67.5,36.46 78.02,36.46 78.82,35.67 78.82,34.76 79.06,34.52 79.73,34.52 79.82,34.42 v2(79.82,34.16)
  BOTTOM w0.089: R28.1 79.82,34.16 v2(79.82,34.16) ; R24.1 103.23,81.74 102.8,81.74 102.46,81.41 102.46,80.07 R27.1
FPGA_GPIO_REFCLKN1: length 97.1
  TOP w0.089: R32.1 v2(162.34,34.29)
  ART20 w0.094: v2(103.53,87.1) 103.53,86.77 103.61,86.7 arc(103.62,86.69) 103.63,86.69 arc(103.88,86.59) 104.05,86.4 104.06,86.4 arc(104.2,86.25) 104.4,86.2 104.4,86.2 arc(104.7,86.12) 104.92,85.9 104.92,85.9 arc(105.07,85.75) 105.26,85.7 105.27,85.7 arc(105.57,85.62) 105.79,85.4 arc(105.85,85.26) 105.87,85.1 105.87,82.89 121.33,67.42 121.33,62.53 121.13,62.32 121.13,59.14 123.26,57 123.26,54.03 123.92,53.37 123.92,51.54 124.69,50.78 124.69,45.16 124.76,45.09 124.76,44.96 124.69,44.88 124.69,44.7 130,39.39 130.13,39.39 130.26,39.27 130.26,39.13 130.38,39 130.52,39 130.65,38.88 130.65,38.74 130.78,38.61 155.29,38.61 160.17,33.73 161.78,33.73 v2(162.34,34.29)
  BOTTOM w0.089: R25.2 104.73,87.04 R31.1
FPGA_GPIO_REFCLKN2: length 118.2
  TOP w0.089: R43.2 131.94,7.92 131.94,8.27 v3(131.64,8.56) 131.94,8.86 131.94,8.97 R50.1
  ART20 w0.094: v3(131.64,8.56) 131.98,8.9 131.98,10.54 132.49,11.05 140.12,11.05 142.19,13.11 142.19,27.6 140.96,28.83 134,28.83 120.47,42.36 120.47,49.9 119.83,50.54 119.83,62.32 119.08,63.08 119.08,67.23 106.4,79.91 103.73,79.91 102.93,80.71 102.93,85.09 arc(102.95,85.25) 103.01,85.4 arc(103.07,85.6) 103.01,85.8 arc(102.93,86.1) 103.01,86.4 arc(103.07,86.6) 103.01,86.8 arc(102.93,87.1) 103.01,87.4 arc(103.07,87.6) 103.01,87.8 arc(102.93,88.1) 103.01,88.4 arc(103.23,88.62) 103.53,88.7 103.53,88.7 arc(103.73,88.75) 103.88,88.9 103.88,88.9 arc(104.1,89.12) 104.4,89.2 104.4,89.2 arc(104.6,89.25) 104.74,89.4 104.74,89.4 arc(104.92,89.59) 105.16,89.69 arc(105.18,89.69) 105.19,89.7 105.26,89.77 v2(105.26,90.1)
  BOTTOM w0.089: R43.2 131.94,7.92 131.94,8.27 v3(131.64,8.56) ; R49.1 105.4,89.92 R26.2
FPGA_GPIO_REFCLKP0: length 95
  ART16 w0.094: v2(79.82,35.18) 79.82,34.87 79.67,34.72 79.15,34.72 79.02,34.85 79.02,35.75 78.11,36.66 67.58,36.66 65.98,38.27 65.98,53.12 64.8,54.31 64.8,59.31 64.9,59.42 64.9,59.61 64.8,59.71 64.8,60.11 67.99,63.31 68.66,63.31 68.77,63.2 68.95,63.2 69.06,63.31 69.25,63.31 69.35,63.2 69.54,63.2 69.65,63.31 79.32,63.31 80.55,62.08 83.14,62.08 86.1,65.04 92.94,65.04 101.77,73.86 101.77,76.09 102.68,77 102.68,81.18 103,81.5 103.13,81.5 v2(103.53,81.1)
  BOTTOM w0.089: R30.1 79.82,35.18 v2(79.82,35.18) ; R29.1 102.75,80.04 102.75,81.29 102.92,81.46 103.23,81.46 R24.2
FPGA_GPIO_REFCLKP1: length 96.9
  TOP w0.089: R36.1 v2(162.34,33.02)
  ART20 w0.094: v2(162.34,33.02) 161.83,33.53 160.09,33.53 155.21,38.4 130.7,38.4 124.48,44.62 124.48,50.7 123.72,51.46 123.72,53.29 123.06,53.95 123.06,56.92 120.93,59.05 120.93,62.41 121.13,62.61 121.13,67.34 105.66,82.8 105.66,85.1 arc(105.59,85.33) 105.4,85.48 arc(105.33,85.49) 105.26,85.5 105.26,85.5 arc(104.96,85.58) 104.74,85.8 104.74,85.8 arc(104.6,85.95) 104.4,86 104.4,86 arc(104.1,86.08) 103.88,86.3 103.88,86.3 arc(103.76,86.43) 103.6,86.49 103.53,86.43 v2(103.53,86.1)
  BOTTOM w0.089: R34.1 104.73,86.16 R25.1
FPGA_GPIO_REFCLKP2: length 118
  TOP w0.089: R52.1 132.22,8.97 132.22,8.86 v3(132.52,8.56) 132.22,8.27 132.22,7.92 R33.2
  ART20 w0.094: v3(132.52,8.56) 132.18,8.9 132.18,10.46 132.57,10.85 132.99,10.85 133.06,10.77 133.22,10.77 133.3,10.85 140.21,10.85 142.39,13.03 142.39,27.69 141.05,29.03 134.09,29.03 120.67,42.45 120.67,49.99 120.04,50.62 120.04,62.41 119.28,63.17 119.28,67.32 106.48,80.11 103.82,80.11 103.13,80.79 103.13,85.09 arc(103.15,85.2) 103.19,85.3 arc(103.27,85.6) 103.19,85.9 arc(103.13,86.1) 103.19,86.3 arc(103.27,86.6) 103.19,86.9 arc(103.13,87.1) 103.19,87.3 arc(103.27,87.6) 103.19,87.9 arc(103.13,88.1) 103.19,88.3 103.19,88.3 arc(103.34,88.45) 103.53,88.5 103.54,88.5 arc(103.84,88.58) 104.05,88.8 104.06,88.8 arc(104.2,88.95) 104.4,89 104.4,89 arc(104.7,89.08) 104.92,89.3 104.92,89.3 arc(105.04,89.43) 105.2,89.49 105.26,89.43 v2(105.26,89.1)
  BOTTOM w0.089: v3(132.52,8.56) 132.22,8.27 132.22,7.92 R33.2 ; R26.1 105.4,89.03 R51.1
FPGA_JTAG_BYPASSN: length 192.2
  TOP w0.109: U23.L11 v2(40.34,174.32)
  ART03 w0.114: v2(40.34,174.32) 40.77,174.75 41.42,174.75 41.53,174.85 41.53,175.36 41.68,175.51 46.25,175.51 46.56,175.82 48.18,175.82 54.23,181.86 63.75,181.86 65.66,183.77 72.14,183.77 74.19,181.71 74.19,177.44 71.37,174.62 71.37,170.56 73.91,168.02 134.49,168.02 135.64,169.16 135.64,171.32 137.41,173.1 137.41,186.9 142.43,191.92 143.41,191.92 145.54,194.06 157.04,194.06 157.42,193.68 158.5,193.68 158.88,194.06 159.64,194.06 160.15,193.55 162.05,193.55 162.43,193.93 169.67,193.93 170.92,192.68 174.15,192.68 175.51,191.31 175.51,189.78 182.66,182.63 184.31,182.63 v2(184.33,182.6)
FPGA_JTAG_TCK: length 186
  TOP w0.109: U23.E14 v2(34.73,176.72)
  ART05 w0.114: v2(138.17,84.1) 138.45,84.1 138.57,83.99 138.57,79.97 140.5,78.04 v2(140.5,77.47)
  ART16 w0.114: v2(34.73,176.72) 34.31,177.14 34.31,179.32 34.52,179.53 44.88,179.53 45.75,178.66 49.92,178.66 54.02,174.56 54.02,163.22 71.12,146.13 71.12,138.76 72.42,137.46 79.35,137.46 86.92,129.89 95.23,129.89 97.67,127.46 107.14,127.46 108.61,125.99 108.61,122.41 109.35,121.67 109.35,117.98 109.17,117.81 109.17,113.33 109.47,113.03 109.86,113.03 110.06,112.82 110.06,111.94 110.36,111.63 110.62,111.63 111.12,111.12 111.51,111.12 112.01,110.62 112.27,110.62 112.78,110.11 113.28,110.11 113.79,109.6 114.05,109.6 114.55,110.11 115.06,110.11 115.57,109.6 115.82,109.6 116.33,109.09 116.71,109.09 116.97,108.84 116.97,106.93 117.47,106.43 117.47,96.77 116.97,96.27 116.97,95.88 117.22,95.63 117.42,95.63 117.93,95.12 118.34,95.12 118.77,94.69 119.1,94.69 119.66,94.13 120.24,94.13 120.72,93.65 121.05,93.65 121.52,94.12 121.98,94.12 122.53,93.58 128.34,93.58 129.27,92.65 129.7,92.65 129.95,92.4 129.95,91.41 130.35,91.01 130.52,91.01 130.77,90.76 130.77,89.88 131.09,89.56 131.57,89.56 132.01,89.12 132.34,89.12 132.57,88.89 132.57,87.94 132.85,87.66 133.07,87.66 133.55,87.17 134.02,87.17 134.56,86.64 134.86,86.64 135.12,86.39 135.12,84.29 135.31,84.1 135.81,84.1 136.37,83.54 136.59,83.54 137,83.13 137.64,83.13 138.17,83.67 v2(138.17,84.1)
FPGA_JTAG_TDI: length 186.9
  TOP w0.109: U23.B16 v2(32.33,178.32)
  ART05 w0.114: v2(140.5,76.2) 140.5,76.49 140.03,76.96 140.03,77.82 137.73,80.12 137.73,83.42 137.55,83.6 v2(137.31,83.6)
  ART16 w0.114: v2(137.31,83.6) 137.31,83.92 136.7,84.53 136.34,84.53 135.97,84.9 135.97,86.93 135.76,87.13 135.32,87.13 134.86,87.59 134.54,87.59 134.04,88.1 133.65,88.1 133.43,88.32 133.43,89.36 133.12,89.67 132.75,89.67 132.33,90.09 131.9,90.09 131.65,90.35 131.65,91.31 131.26,91.69 131.06,91.69 130.83,91.92 130.83,92.98 130.22,93.58 128.9,93.58 128.55,93.93 123.02,93.93 121.88,95.07 121.54,95.07 121.16,94.69 120.57,94.69 120.16,95.1 119.73,95.1 119.2,95.63 118.82,95.63 118.29,96.16 118.11,96.16 117.86,96.42 117.86,110.36 117.6,110.62 117.22,110.62 116.71,110.11 116.2,110.11 115.82,110.49 115.57,110.49 114.94,111.12 114.68,111.12 114.15,110.59 113.79,110.59 113.26,111.12 112.8,111.12 112.29,111.63 111.86,111.63 111.33,112.17 111.1,112.17 110.87,112.39 110.87,113.28 110.62,113.54 110.24,113.54 110.03,113.74 110.03,121.74 109.12,122.66 109.12,126.2 107.35,127.96 97.88,127.96 95.44,130.4 87.13,130.4 79.56,137.97 72.63,137.97 71.63,138.98 71.63,146.34 54.53,163.44 54.53,174.71 49.28,179.96 46.48,179.96 45.97,180.47 33.7,180.47 33.53,180.29 33.53,178.94 33.31,178.73 32.98,178.73 32.57,178.32 v2(32.33,178.32)
FPGA_JTAG_TDO: length 184
  TOP w0.109: U23.B17 v2(32.33,179.12)
  ART05 w0.114: v2(140.5,80.01) 140.24,80.26 139.93,80.26 139.42,80.77 139.42,84.15 138.47,85.1 v2(138.17,85.1)
  ART16 w0.114: v2(32.33,179.12) 31.95,179.5 31.95,180.49 32.81,181.36 46.36,181.36 46.74,180.97 49.92,180.97 55.42,175.47 55.42,163.8 72.51,146.71 72.51,140.59 74.11,138.99 79.8,138.99 87.5,131.29 95.81,131.29 98.24,128.85 107.72,128.85 110,126.57 110,123.06 111.76,121.31 111.76,114.94 112.01,114.68 112.39,114.68 112.65,114.43 112.65,113.26 112.88,113.03 113.28,113.03 113.67,112.65 114.17,112.65 114.68,113.16 115.32,113.16 116.31,112.17 116.74,112.17 117.22,112.65 117.6,112.65 118.11,112.14 118.49,112.14 119,111.63 119.25,111.63 119.56,111.33 119.56,97.28 119.78,97.05 120.22,97.05 120.6,96.67 121.05,96.67 121.43,97.05 123.42,97.05 125.81,94.67 129.2,94.67 129.25,94.61 131.55,94.61 132.56,93.6 132.56,92.38 133.42,91.52 133.42,91.29 133.6,91.11 133.91,91.11 134.4,90.61 134.74,90.61 135.1,90.26 135.1,89.27 135.33,89.04 135.84,89.04 136.33,88.54 136.65,88.54 137.1,88.1 137.5,88.1 137.77,87.83 137.77,85.5 v2(138.17,85.1)
FPGA_JTAG_TMS: length 188.2
  TOP w0.109: U23.D14 v2(33.94,176.72)
  ART05 w0.114: v2(137.31,84.6) 138.36,84.6 138.91,84.05 138.91,80.33 v2(140.5,78.74)
  ART16 w0.114: v2(137.31,84.6) 136.92,84.99 136.92,87.33 136.56,87.68 136.26,87.68 135.81,88.13 135.29,88.13 134.85,88.57 134.56,88.57 134.28,88.84 134.28,89.82 134.03,90.07 133.63,90.07 133.18,90.51 132.85,90.51 132.51,90.85 132.51,91.77 132.18,92.1 131.93,92.1 131.64,92.39 131.64,93.28 131.32,93.6 130.81,93.6 130.39,94.02 129.2,94.02 128.94,94.27 124.17,94.27 122.43,96.01 121.43,96.01 121.13,95.71 120.55,95.71 120.11,96.14 119.83,96.14 119.35,96.62 118.87,96.62 118.73,96.76 118.73,110.89 118.49,111.12 117.98,111.12 117.6,111.51 117.09,111.51 116.71,111.12 116.33,111.12 115.95,111.51 115.57,111.51 114.94,112.14 114.55,112.14 114.05,111.63 113.67,111.63 113.16,112.14 112.9,112.14 112.39,112.65 112.01,112.65 111.76,112.9 111.76,113.79 111.51,114.05 111.12,114.05 110.87,114.3 110.87,121.69 109.57,122.99 109.57,126.39 107.54,128.42 98.07,128.42 95.63,130.86 87.32,130.86 79.75,138.43 74.06,138.43 72.08,140.41 72.08,146.53 54.99,163.62 54.99,174.97 49.49,180.47 46.61,180.47 46.18,180.9 33.47,180.9 32.74,180.16 32.74,178.97 32.51,178.74 32.13,178.74 31.93,178.54 31.93,177.21 32.42,176.72 v2(33.94,176.72)
FPGA_LED_G0: length 123.3
  TOP w0.109: v2(168.94,207.42) 168.39,207.97 U18.C7
  ART18 w0.114: v2(121.72,120.6) 121.26,121.06 121.26,121.89 121.61,122.25 121.61,123.16 122.53,124.08 122.53,127.89 124.39,129.75 130.49,129.75 132.81,132.08 132.81,135.13 135.41,137.72 135.41,150.9 141.1,156.59 141.1,162.41 141.83,163.14 141.83,166.83 140.72,167.94 137.92,167.94 137.08,168.78 137.08,186.36 137.15,186.42 137.15,186.69 145.02,194.56 148.21,194.56 150.5,196.85 156.72,196.85 165.86,205.99 167.51,205.99 v2(168.94,207.42)
FPGA_LED_G1: length 125.8
  TOP w0.109: v2(168.91,206.63) 167.76,207.78 U18.C5
  ART18 w0.114: v2(121.72,121.6) 121.72,121.85 121.84,121.97 121.84,122.88 122.89,123.93 122.89,127.36 124.94,129.41 130.78,129.41 133.2,131.83 133.2,135 135.79,137.59 135.79,150.77 142.39,157.38 142.39,160.43 145.03,163.07 145.03,167 143.59,168.45 138.33,168.45 137.46,169.32 137.46,186.56 145.15,194.25 148.84,194.25 151,196.41 156.78,196.41 165.99,205.61 167.89,205.61 v2(168.91,206.63)
FPGA_LED_G2: length 122.8
  TOP w0.109: U18.C3 167.26,207.13 v2(167.64,206.76)
  ART18 w0.114: v2(120.85,121.1) 120.45,121.51 120.45,123.27 121.21,124.03 121.21,127.88 123.72,130.39 129.79,130.39 132.12,132.71 132.12,135.57 133.53,136.98 133.53,151.94 133.99,152.4 135.64,152.4 140.34,157.1 140.34,163.83 139.32,164.85 138.05,164.85 136.32,166.57 136.32,186.94 142.16,192.78 142.16,193.61 144.7,196.15 148.53,196.15 150.11,197.74 154.31,197.74 155.7,199.14 157.86,199.14 165.74,207.01 167.39,207.01 v2(167.64,206.76)
FPGA_LED_G3: length 119.8
  TOP w0.109: U18.C1 v2(166.76,206.47)
  ART18 w0.114: v2(166.76,206.47) 165.7,206.47 157.99,198.75 156.19,198.75 154.67,197.23 150.24,197.23 148.84,195.83 145.84,195.83 136.83,186.83 136.83,186.79 136.7,186.66 136.7,168 137.36,167.34 139.93,167.34 140.39,166.88 140.39,164.49 140.69,164.19 140.69,156.69 135.13,151.13 134.24,151.13 133.88,150.77 133.88,136.83 132.43,135.38 132.43,132.84 132.43,132.33 130.17,130.07 124.07,130.07 122.19,128.18 122.19,124.07 121.38,123.27 121.38,122.63 v2(120.85,122.1)
FPGA_LED_G4: length 120.7
  TOP w0.109: v2(161.93,207.26) 161.93,207.71 U19.C7
  ART18 w0.114: v2(161.93,207.26) 160.78,206.12 160.78,205.1 155.57,199.9 150.62,199.9 149.86,200.66 146.15,200.66 140.47,194.98 140.47,192.21 135.56,187.3 135.56,166.32 137.79,164.08 138.94,164.08 139.57,163.45 139.57,161.8 135.81,158.04 134.24,158.04 132.71,156.51 132.71,137.19 131.14,135.61 131.14,133.07 129.09,131.02 122.56,131.02 119.85,128.31 119.85,126.98 119.86,126.97 119.86,123.73 119.6,123.46 119.6,120.99 v2(119.99,120.6)
FPGA_LED_G5: length 120.1
  TOP w0.109: U19.C5 161.03,207.78 161.42,207.39 161.42,207.01 v2(161.93,206.5)
  ART18 w0.114: v2(161.93,206.5) 161.93,204.98 156.46,199.52 150.5,199.52 149.73,200.28 146.23,200.28 140.79,194.84 140.79,191.97 135.94,187.12 135.94,166.45 137.92,164.47 139.06,164.47 139.95,163.58 139.95,161.67 136.91,158.62 136.91,156.59 135.25,154.94 133.86,154.94 133.12,154.2 133.12,137.08 131.54,135.51 131.54,132.59 129.66,130.7 122.81,130.7 120.25,128.14 120.25,126.98 120.24,126.97 120.24,123.57 119.99,123.32 v2(119.99,121.6)
FPGA_LED_G6: length 121.9
  TOP w0.109: v2(160.91,207.14) 160.53,207.51 U19.C3
  ART18 w0.114: v2(119.12,121.1) 119.12,121.39 118.59,121.92 118.59,123.32 117.83,124.08 117.83,128.14 118.21,128.52 118.72,128.52 121.85,131.66 128.82,131.66 130.19,133.02 130.19,135.68 131.78,137.26 131.78,156.95 133.78,158.95 135.33,158.95 138.81,162.43 138.81,163.07 138.56,163.32 137.54,163.32 134.85,166.01 134.85,187.68 139.84,192.67 139.84,196.99 146.71,203.86 152.37,203.86 153.29,202.95 155.7,202.95 159.89,207.14 v2(160.91,207.14)
FPGA_LED_G7: length 118.7
  TOP w0.109: U19.C1 v2(160.03,206.59)
  ART18 w0.114: v2(160.03,206.59) 160.03,205.12 157.16,202.25 153.48,202.25 152.22,203.5 149.07,203.5 146.55,200.98 146.02,200.98 140.16,195.11 140.16,192.38 135.18,187.4 135.18,166.19 137.67,163.7 138.81,163.7 139.19,163.32 139.19,162.31 135.36,158.47 133.93,158.47 132.27,156.81 132.27,137.25 130.73,135.71 130.73,133.11 128.96,131.34 122.29,131.34 118.94,127.98 118.94,122.28 v2(119.12,122.1)
FPGA_MSEL0: length 99.8
  TOP w0.109: SW1.1 149.22,153.03 v2(150.06,152.2)
  ART03 w0.114: v2(151.36,90.99) 151.44,90.91 159.23,90.91 160.07,91.74 163.71,91.74 v2(164.27,91.18)
  ART20 w0.114: v2(151.36,90.99) 150.7,91.65 150.7,97.75 151.44,98.49 151.44,102.55 153.69,104.8 159.79,104.8 162.84,107.85 164.44,107.85 165.3,108.71 165.3,116.48 167.13,118.31 167.13,121.67 164.9,123.9 158.42,123.9 152.15,130.18 152.15,133.22 152.53,133.6 152.53,147.7 150.75,149.48 150.75,151.51 v2(150.06,152.2)
  BOTTOM w0.109: v2(151.36,90.99) 150.75,90.99 R5.2
FPGA_MSEL1: length 114.8
  TOP w0.109: SW1.2 150.5,153.18 v2(151.48,152.2)
  ART03 w0.114: v2(165.07,90.38) 164.68,89.99 164.01,89.99 163.7,89.69 163.7,89.36 163.45,89.1 163.45,84.5 162.25,83.31 152.7,83.31 v2(150.92,85.09)
  ART20 w0.114: v2(150.92,85.09) 150.5,85.52 150.5,88.27 151.89,89.66 151.89,91.11 151.03,91.97 151.03,97.64 151.75,98.36 151.75,102.42 153.72,104.39 159.94,104.39 162.92,107.37 164.8,107.37 165.76,108.33 165.76,116.31 167.51,118.06 167.51,121.82 164.92,124.41 158.52,124.41 152.5,130.43 152.5,133.07 152.91,133.48 152.91,148.08 152.15,148.84 152.15,151.53 v2(151.48,152.2)
  BOTTOM w0.109: R6.2 150.66,84.82 v2(150.92,85.09)
FPGA_MSEL2: length 107.2
  TOP w0.109: v2(152.88,152.2) 151.76,153.31 SW1.3
  ART03 w0.114: v2(165.87,91.18) 165.47,90.78 163.9,90.78 163.47,90.35 155.8,90.35 152.64,87.18 v2(150.95,87.18)
  ART20 w0.114: v2(152.88,152.2) 153.34,151.74 153.34,132.71 153.57,132.49 153.57,130.03 158.83,124.76 161.54,124.76 162.41,125.63 163.88,125.63 164.54,124.97 164.85,124.97 165.84,123.98 165.94,123.98 167,122.91 167,122.86 167.89,121.97 167.89,117.81 166.98,116.89 166.98,108.61 165.3,106.93 163.02,106.93 160.12,104.04 153.8,104.04 152.05,102.3 152.05,98.23 151.38,97.56 151.38,92.2 152.35,91.24 152.35,88.58 v2(150.95,87.18)
  BOTTOM w0.109: R13.2 v2(150.95,87.18)
FPGA_MSEL_EN: length 91.7
  TOP w0.109: v2(154.26,152.21) 153.03,153.44 SW1.4
  ART20 w0.114: v2(165.07,91.98) 164.86,91.98 164.42,92.42 162.95,92.42 162.63,92.73 161.97,92.73 160.47,94.23 154.78,94.23 153.95,95.07 153.95,101.78 155.85,103.68 160.53,103.68 163.37,106.53 165.58,106.53 167.41,108.36 167.41,116.61 168.28,117.47 168.28,122.17 166.85,123.6 166.85,124.28 165.48,125.65 164.36,125.65 163.88,126.14 158.09,126.14 153.95,130.28 153.95,132.76 153.64,133.07 153.64,151.59 v2(154.26,152.21)
FPGA_NCONFIG: length 76
  ART16 w0.114: v2(133.84,91.6) 134.24,92 134.24,94.34 134.43,94.53 135.43,94.53 135.94,94.02 137.59,94.02 138.02,93.59 139.43,93.59 141.65,91.37 141.65,81.08 142.34,80.39 v2(142.34,79.88) 142.92,79.88 143.46,80.42 147.27,80.42 147.55,80.14 149.15,80.14 149.96,79.32 160.15,79.32 161.8,80.98 177.22,80.98 178.8,82.56 178.8,87.13 178.36,87.58 178.36,88.06 178.03,88.39 176.91,88.39 176.67,88.63 176.67,89.77 176.48,89.97 175.21,89.97 175.07,90.1 175.07,92.38 v2(175.47,92.78)
  BOTTOM w0.114: R22.2 v2(142.34,79.88)
FPGA_NSTATUS: length 68.7
  ART05 w0.114: v2(143.04,77.34) 143.04,79.87 142.24,80.67 140.5,80.67 140.05,81.12 140.05,84.2 138.61,85.65 138.02,85.65 137.69,85.98 137.69,86.87 137.44,87.12 137.08,87.12 136.55,87.65 136.27,87.65 135.57,88.35 v2(135.57,88.6)
  ART16 w0.114: v2(143.04,77.34) 143.61,77.91 144.18,77.91 145.32,79.06 147.58,79.06 147.9,79.37 148.44,79.37 148.94,78.87 160.61,78.87 162.39,80.64 177.39,80.64 179.3,82.55 179.3,88.65 178.79,89.15 177.54,89.15 177.43,89.27 177.43,89.43 177.43,89.43 177.43,89.73 177.22,89.94 176.95,89.94 176.67,90.22 176.67,90.55 176.42,90.8 175.99,90.8 175.84,90.96 175.84,93.21 v2(175.47,93.58)
FPGA_OSC_CLK_1: length 98
  ART20 w0.086: 136.04,79.76 136.04,90.7 v2(136.44,91.1)
  ART20 w0.114: v2(155.57,27.06) 156.86,25.78 164.18,25.78 164.95,26.54 164.95,34.67 155.3,44.32 138.02,44.32 135.53,46.81 135.53,53.59 136.07,54.13 136.07,59.71 136.34,59.99 136.34,61.47 136.73,61.85 136.73,69.75 136.04,70.43 136.04,79.76
FPGA_PB0: length 172.6
  TOP w0.109: v2(137.6,196.08) 137.54,196.02 S1.2
  ART18 w0.114: v2(158.37,194.18) 158.81,194.63 158.81,195.14 161.67,197.99 168.78,197.99 172.47,194.31 175.9,194.31 178.05,192.15 178.05,185.67 177.55,185.17 177.55,172.59 178.16,171.98 178.16,168.11 172.69,162.65 171.79,162.65 169.92,160.78 165.48,160.78 160.14,155.45 145.48,155.45 144.21,154.18 142.11,154.18 138.43,150.5 138.43,145.59 139.74,144.28 139.74,136.49 140.88,135.35 140.88,130.43 139.16,128.71 133,128.71 132.05,127.76 126.72,127.76 126.34,127.38 126.34,124.13 125.91,123.7 125.43,123.7 124.49,122.76 124.29,122.76 123.91,122.38 123.91,120.31 123.72,120.12 123.14,120.12 122.72,120.54 122.47,120.54 122.01,120.08 121.45,120.08 120.98,120.55 120.73,120.55 120.3,120.12 119.77,120.12 119.42,119.77 119.42,119.45 119.64,119.23 119.64,118.95 v2(119.99,118.6)
  ART20 w0.114: v2(137.6,196.08) 140.34,196.08 142.24,194.18 v2(158.37,194.18)
  BOTTOM w0.109: C1398.2 R275.1 v2(137.6,196.08)
