# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Nets (continued)
GND: BT1.2(-) C1.2 C2.1 C3.1 C4.2 C5.1 C6.2 C7.1 C8.2 C12.2 C13.2 C14.2 C15.2 C16.1 C17.1 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.1 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C71.2 C73.2 C74.2 C75.2 C76.1 C77.1 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C120.2 C121.2 C122.2 C124.2 C125.2 C126.2 C127.2 C130.2 C132.2 C133.2 C134.2 C135.2 C136.2 C139.2 C140.1 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.1 C148.1 C149.1 C150.1 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.1 C164.1 C165.1 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.1 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C194.1 C195.2 C196.2 C197.2 C198.2 C199.1 C201.2 C202.2 C203.1 C204.1 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C222.2 C223.2 C224.2 C225.2 C226.2 C227.2 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C245.1 C246.1 C247.1 C248.1 C249.1 C250.1 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.2 C292.2 C293.1 C294.1 C312.2 C313.2 C314.2 C315.2 C316.2 C317.2 C318.2 C328.2 C337.1 C338.1 C339.2 C344.2 C345.2 C346.2 C347.2 C348.1 C349.1 C350.2 C351.2 C352.2 C371.2 C372.2 C373.2 C374.2 C375.2 C377.2 C387.2 C395.2 C399.1 C400.2 C406.2 C407.2 C452.2 C453.2 C486.2 C487.2 C491.1 C492.1 C498.2 C519.1 C520.2 C521.2 C522.2 C523.2 C524.2 C525.2 C526.2 C527.2 C528.2 C529.2 C530.2 C531.2 C532.2 C533.2 C534.2 C535.2 C536.2 C537.2 C544.2 C545.2 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.2 C555.2 C556.2 C557.2 C558.2 C559.2 C560.1 C561.2 C562.1 C563.1 C564.1 C565.2 C566.1 C567.1 C568.1 C569.2 C570.1 C571.1 C572.1 C573.2 C574.2 C575.2 C576.2 C577.2 C578.2 C579.2 C580.1 C582.1 C583.1 C584.1 C585.1 C608.1 C609.1 C610.1 C611.1 C612.1 C613.1 C614.1 C624.2 C625.2 C626.2 C627.2 C632.2 C633.1 C634.1 C635.1 C636.1 C637.2 C638.2 C639.2 C640.2 C641.2 C642.2 C643.2 C644.2 C645.2 C646.2 C647.2 C648.2 C649.2 C650.2 C651.2 C652.2 C653.2 C654.2 C655.2 C656.2 C657.2 C658.2 C659.2 C660.2 C661.2 C662.2 C663.2 C664.1 C665.2 C666.2 C667.2 C668.2 C669.2 C670.2 C671.2 C672.2 C673.2 C674.2 C675.2 C676.2 C677.2 C678.2 C679.2 C680.2 C681.2 C682.2 C683.2 C684.2 C685.1 C686.2 C687.2 C688.2 C689.2 C690.2 C691.2 C692.2 C693.2 C694.2 C695.2 C696.2 C697.2 C698.2 C699.2 C700.2 C701.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.1 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C733.2 C734.2 C735.2 C736.2 C737.2 C738.2 C740.2 C741.2 C742.2 C743.2 C744.2 C745.2 C746.2 C747.2 C748.2 C749.2 C750.2 C751.2 C752.2 C753.2 C754.2 C755.1 C756.2 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C763.2 C764.2 C765.2 C766.2 C767.2 C768.2 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C788.2 C789.2 C790.2 C794.1 C796.2 C797.2 C798.1 C799.2 C800.1 C801.2 C802.1 C803.1 C804.1 C805.2 C806.1 C807.1 C808.1 C819.2 C820.1 C821.2 C822.2 C823.2 C824.2 C825.2 C826.2 C827.2 C828.2 C829.2 C830.2 C831.2 C832.2 C833.2 C834.2 C835.2 C836.2 C837.2 C841.2 C843.2 C844.2 C845.2 C846.2 C847.2 C848.2 C849.2 C850.2 C851.2 C854.2 C855.2 C856.2 C857.1 C858.1 C882.1 C883.2 C884.2 C885.1 C886.1 C887.2 C888.1 C889.1 C890.2 C891.1 C892.1 C893.2 C894.1 C897.1 C898.2 C899.1 C900.1 C901.2 C902.1 C903.1 C904.2 C905.1 C906.1 C907.2 C908.1 C909.1 C910.2 C911.1 C912.2 C913.1 C914.1 C915.1 C916.2 C917.1 C918.1 C919.1 C920.2 C921.1 C922.2 C923.1 C924.1 C925.2 C926.1 C927.1 C928.2 C929.1 C930.1 C931.2 C932.1 C933.2 C934.2 C935.2 C936.2 C937.2 C938.2 C939.2 C940.2 C941.2 C942.1 C943.1 C944.1 C945.1 C946.1 C947.1 C948.2 C949.1 C950.2 C951.2 C952.2 C953.2 C954.2 C955.2 C956.1 C957.1 C958.1 C965.1 C966.2 C967.2 C968.2 C969.2 C970.2 C976.2 C977.2 C978.2 C979.2 C980.2 C981.2 C982.2 C983.2 C984.2 C985.2 C986.1 C988.2 C989.1 C990.1 C991.1 C992.1 C993.1 C994.1 C995.1 C1094.2 C1095.2 C1096.2 C1097.2 C1098.2 C1099.2 C1100.2 C1101.2 C1102.2 C1103.2 C1104.2 C1107.1 C1108.1 C1109.1 C1110.1 C1111.1 C1112.1 C1113.1 C1116.2 C1117.2 C1118.2 C1119.2 C1120.2 C1121.2 C1122.2 C1123.2 C1124.2 C1129.2 C1130.1 C1131.1 C1132.1 C1133.1 C1136.2 C1137.1 C1138.2 C1140.2 C1141.2 C1145.2 C1146.1 C1148.2 C1149.2 C1150.2 C1154.2 C1155.1 C1156.2 C1157.2 C1158.2 C1169.2 C1170.1 C1171.2 C1172.2 C1173.2 C1178.1 C1179.1 C1181.2 C1182.2 C1184.2 C1185.1 C1186.2 C1187.1 C1199.2 C1200.1 C1201.2 C1202.2 C1203.2 C1217.2 C1218.1 C1219.2 C1220.2 C1221.2 C1226.2 C1227.1 C1228.2 C1229.2 C1230.2 C1237.2 C1238.2 C1290.2 C1291.2 C1292.2 C1293.2 C1294.2 C1295.2 C1296.1 C1297.1 C1298.1 C1299.1 C1300.1 C1301.1 C1302.1 C1303.1 C1304.1 C1305.1 C1306.1 C1307.1 C1308.1 C1309.1 C1310.1 C1316.2 C1317.2 C1318.2 C1319.2 C1327.2 C1328.2 C1329.2 C1330.2 C1331.2 C1332.1 C1333.2 C1334.2 C1335.1 C1337.2 C1338.2 C1339.2 C1340.2 C1341.2 C1342.2 C1343.2 C1344.2 C1345.2 C1346.2 C1347.2 C1348.2 C1349.2 C1350.2 C1351.2 C1352.2 C1353.2 C1354.2 C1355.2 C1356.2 C1357.2 C1358.2 C1359.2 C1360.2 C1361.2 C1362.2 C1363.2 C1364.2 C1365.2 C1366.2 C1367.2 C1368.2 C1369.2 C1370.2 C1371.2 C1372.2 C1373.2 C1374.2 C1375.2 C1376.2 C1377.2 C1378.1 C1379.1 C1380.1 C1381.2 C1382.2 C1383.2 C1384.2 C1385.2 C1386.2 C1387.2 C1388.2 C1389.1 C1390.1 C1391.1 C1392.1 C1393.1 C1394.1 C1395.1 C1396.1 C1397.1 C1398.1 C1399.1 C1400.1 C1401.1 C1402.1 C1403.1 C1404.1 C1405.1 C1408.2 C1409.1 C1410.1 C1411.1 C1412.2 C1413.2 C1414.2 C1415.2 C1416.2 C1417.2 C1424.2 C1425.2 C1426.2 C1427.2 C1428.2 C1429.2 C1430.2 C1431.2 C1432.2 C1433.2 C1434.2 C1435.2 C1436.2 C1437.2 C1438.2 C1439.2 C1440.2 C1441.2 C1442.2 C1443.2 C1444.2 C1445.2 C1446.2 C1447.2 C1448.2 C1457.2 C1458.2 C1461.2 C1463.2 C1466.2 C1468.2 C1469.2 C1470.2 C1471.2 C1472.2 C1473.2 C1474.2 C1475.2 C1476.2 C1477.2 C1478.2 C1479.2 C1480.2 C1481.2 C1482.2 C1483.2 C1484.1 C1485.1 C1486.1 C1487.1 C1488.1 C1489.2 C1490.2 C1491.2 C1492.2 C1493.2 C1494.2 C1495.2 C1496.2 C1497.1 C1498.1 C1499.2 C1500.2 C1501.2 C1502.2 C1503.2 C1504.2 C1505.2 C1506.2 C1507.2 C1508.2 C1509.2 C1510.2 C1511.2 C1512.2 C1513.2 C1514.2 C1515.1 C1516.1 C1517.1 C1518.1 C1519.1 C1520.2 C1521.2 C1522.2 C1523.2 C1524.2 C1525.2 C1526.2 C1527.2 C1528.1 C1529.1 C1530.2 C1531.2 C1532.2 C1533.2 C1534.2 C1535.2 C1536.2 C1537.2 C1546.1 C1547.1 C1551.2 C1552.2 C1553.2 C1554.2 C1559.1 C1560.1 C1561.2 C1562.2 C1563.2 C1564.2 C1565.2 C1566.2 C1567.2 C1568.2 C1569.2 C1570.2 C1571.2 C1572.2 C1573.2 C1574.2 C1575.2 C1576.2 C1577.2 C1578.2 C1579.2 C1580.2 C1581.1 C1582.1 C1583.1 C1584.1 C1585.1 C1586.2 C1587.2 C1588.1 C1590.2 C1591.2 C1592.2 C1593.2 C1594.2 C1595.2 C1596.1 C1597.2 C1598.2 C1599.2 C1600.2 C1609.2 C1610.2 C1611.2 C1612.2 C1613.1 C1614.2 C1615.2 C1616.2 C1622.2 C1623.2 C1624.2 C1625.2 C1626.2 C1627.2 C1628.2 C1629.2 C1637.1 C1650.2 C1652.2 C1660.1 C1661.1 C1664.2 C1665.1 C1666.1 C1667.1 C1668.1 C1669.2 C1670.2 C1682.1 C1683.1 C1687.2 C1688.2 C1689.2 C1690.1 C1691.1 C1692.1 C1693.1 C1703.1 C1704.1 C1709.2 C1711.2 C1712.2 C1713.1 C1714.1 C1715.1 C1716.1 C1718.1 C1719.2 C1720.1 C1721.2 C1726.1 C1727.1 C1733.2 C1734.2 C1735.2 C1736.1 C1737.1 C1738.1 C1739.1 C1743.2 C1774.2 C1775.2 C1776.2 C1777.2 C1779.2 C1780.2 C1781.2 C1782.2 C1783.2 C1784.2 C1786.2 C1788.1 C1789.1 C1790.1 C1791.1 C1792.1 C1793.1 C1794.1 C1795.1 C1796.2 C1798.2 C1799.2 C1801.2 C1802.2 C1803.2 C1804.2 C1805.2 C1807.2 C1808.2 C1809.2 C1810.2 C1811.2 C1812.2 C1813.2 C1814.2 C1815.2 C1817.2 C1840.2 C1842.2 C1843.2 C1844.2 C1845.1 C1846.1 C1847.1 C1848.2 C1858.1 C1859.1 C1860.1 C1861.1 C1862.1 C1863.1 C1864.1 C1865.1 C1866.1 C1867.1 C1868.1 C1869.1 C1870.1 C1871.1 C1872.1 C1873.1 C1874.1 C1879.2 C1880.2 C1881.2 C1895.1 C1896.2 C1901.2 C1921.2 C1931.2 C1934.2 C1970.1 C1978.2 C1979.2 C1997.2 C1998.2 C2000.2 C2001.2 C2002.2 C2016.2 C2017.2 C2044.1 C2045.1 C2048.2 C2062.1 C2063.2 C2064.2 C2065.2 C2066.2 C2067.2 C2068.2 C2069.2 C2070.2 C2086.1 C2095.1 C2096.1 C2110.1 C2113.1 C2114.2 C2115.2 C2116.2 C2117.2 C2119.2 C2120.1 C2121.1 C2122.2 C2123.1 C2124.1 C2125.2 C2126.1 C2127.1 C2128.2 C2129.1 C2130.1 C2131.2 C2132.2 C2133.2 C2134.2 C2135.2 C2136.2 C2137.2 C2138.2 CN1.4 CON1.1 CON1.2 CON1.5 CON1.6 CON1.9 CON1.10 CON1.14 CON1.15 CON1.18 CON1.19 CON1.22 CON1.23 CON1.26 CON1.27 CON1.30 CON1.31 CON1.35 CON1.36 CON1.39 CON1.40 CON1.43 CON1.44 CON1.47 CON1.48 CON1.51 CON1.52 CON1.56 CON1.57 CON1.60 CON1.61 CON1.64 CON1.65 CON1.68 CON1.69 CON1.72 CON1.73 CON1.77 CON1.78 CON1.81 CON1.82 CON1.85 CON1.86 CON1.89 CON1.90 CON1.93 CON1.94 CON1.98 CON1.99 CON1.102 CON1.103 CON1.106 CON1.107 CON1.167 CON1.168 CON1.171 CON1.172 CON1.175 CON1.176 CON1.180 CON1.181 CON1.184 CON1.185 CON1.188 CON1.189 CON1.192 CON1.193 CON1.196 CON1.197 CON1.201 CON1.202 CON1.205 CON1.206 CON1.209 CON1.210 CON1.213 CON1.214 CON1.217 CON1.218 CON1.222 CON1.223 CON1.226 CON1.227 CON1.230 CON1.231 CON1.234 CON1.235 CON1.238 CON1.239 CON1.243 CON1.244 CON1.247 CON1.248 CON1.251 CON1.252 D1.4 D1.5 D35.2 D36.1(CATHODE) D37.1(CATHODE) D38.1(CATHODE) D39.1(CATHODE) D41.4 D41.5 FB1.2 J1.2 J1.3 J1.4 J1.5 J2.2 J2.3 J2.4 J2.5 J3.2 J3.3 J3.4 J3.5 J4.2 J4.3 J4.4 J4.5 J5.61 J5.62 J5.63 J5.64(GND4) J6.2 J6.3 J6.4 J6.5 J7.2 J7.3 J7.4 J7.5 J10.3 J10.4 J10.7 J10.14 J10.15 J10.19 J10.22 J10.23 J10.27 J10.35 J10.36 J10.39 J10.40 J10.49 J10.61 J10.62 J10.63 J10.64 J11.3 J11.4 J11.7 J11.14 J11.15 J11.19 J11.22 J11.23 J11.27 J11.35 J11.36 J11.39 J11.40 J11.49 J11.61 J11.62 J11.63 J11.64 J12.1 J12.4 J12.7 J12.13 J12.16 J12.19 J12.20 J12.23 J12.26 J12.32 J12.35 J12.38 J13.M1 J13.M2 J14.A1 J14.A4 J14.A12 J14.A15 J14.A18 J14.A20 J14.A23 J14.A24 J14.A27 J14.A28 J14.A31 J14.A34 J14.A37 J14.A38 J14.A41 J14.A42 J14.A45 J14.A46 J14.A49 J14.A51 J14.A54 J14.A55 J14.A58 J14.A59 J14.A62 J14.A63 J14.A66 J14.A67 J14.A70 J14.A71 J14.A74 J14.A75 J14.A78 J14.A79 J14.A82 J14.B4 J14.B7 J14.B13 J14.B16 J14.B18 J14.B21 J14.B22 J14.B25 J14.B26 J14.B29 J14.B32 J14.B35 J14.B36 J14.B39 J14.B40 J14.B43 J14.B44 J14.B47 J14.B49 J14.B52 J14.B53 J14.B56 J14.B57 J14.B60 J14.B61 J14.B64 J14.B65 J14.B68 J14.B69 J14.B72 J14.B73 J14.B76 J14.B77 J14.B80 J15.10 J16.6 J17.5 J17.6 J18.10 J19.10 J20.1 J21.1 J22.2 J22.3 J22.4 J22.5 J23.2 J23.3 J23.4 J23.5 J24.2 J24.3 J24.4 J24.5 J25.2 J25.3 J25.4 J25.5 J26.2 J26.11 J26.20 J27.2 J27.3 J27.4 J27.5 J28.2 J28.3 J28.4 J28.5 J29.2 J29.3 J29.4 J29.5 J30.2 J30.3 J30.4 J30.5 J31.2 J31.3 J31.4 J31.5 J34.2 J34.3 J34.4 J34.5 J35.1 J35.3 J35.5 J37.4 J37.5 J37.6(GND2) J49.4 J49.5 J49.6 J49.10 J50.2 J50.3 J50.4 J50.5 J51.3 MTH3.1(GND) MTH4.1(GND) MTH5.1(GND) Q1.E(EMITTER) Q2.E(EMITTER) Q3.E(EMITTER) R12.1 R19.1 R28.2 R30.2 R32.2 R36.2 R41.2 R42.2 R47.2 R48.2 R50.2 R52.2 R53.2 R56.2 R58.2 R60.2 R62.2 R63.2 R66.2 R68.2 R70.2 R72.2 R85.1 R86.2 R87.1 R89.2 R97.1 R99.2 R110.1 R111.1 R112.1 R113.1 R114.1 R115.1 R116.2 R117.2 R118.2 R119.2 R120.2 R121.2 R122.2 R123.2 R124.1 R125.1 R126.1 R127.1 R128.1 R129.1 R130.1 R131.1 R132.1 R134.1 R135.2 R136.2 R140.1 R142.1 R143.2 R190.2 R191.1 R192.1 R193.1 R200.1 R204.1 R205.1 R206.1 R208.1 R223.1 R229.2 R230.2 R238.1 R249.1 R250.1 R253.1 R254.1 R295.2 R298.2 R300.1 R310.2 R313.2 R314.2 R315.2 R316.2 R317.2 R318.2 R319.2 R320.2 R321.2 R322.2 R323.2 R324.2 R325.2 R326.2 R327.2 R328.2 R329.2 R330.2 R331.2 R332.2 R333.2 R334.2 R337.2 R353.1 R358.2 R374.1 R377.2 R402.2 R404.2 R407.1 R417.1 R419.1 R424.1 R425.1 R428.1 R434.1 R455.2 R468.1 R470.1 R471.1 R472.1 R478.1 R505.2 R512.2 R515.1 R517.2 R519.1 R523.1 R524.1 R530.2 R538.1 R540.2 R547.1 R548.2 R559.1 R565.2 R641.2 R644.1 R667.2 R734.1 R742.1 R747.1 R767.1 R839.2 R841.2 R842.2 R843.2 R846.1 R847.2 R848.2 R849.1 R850.1 R851.2 R852.2 R855.2 R858.1 R859.1 R860.1 R861.1 R862.1 R863.1 R864.1 R865.1 R866.1 R867.1 R870.1 R871.1 R919.2 R920.2 R931.2 R932.2 R933.2 R934.2 R935.2 R936.2 R937.2 R938.2 R949.2 R951.1 R971.2 R973.2 R975.2 R976.1 R980.2 R985.2 R989.1 R1000.1 R1003.1 R1005.1 R1006.1 R1007.1 R1008.1 R1009.1 R1010.1 R1058.2 R1059.2 R1060.2 R1061.2 R1062.2 R1063.2 R1065.1 R1119.1 R1152.2 R1154.2 R5286.2 R5392.2 R5398.2 R5407.2 R5416.2 R5425.2 R5434.2 R5443.2 R5452.2 R5467.1 R5468.1 R5876.2 R5978.1 R5979.1 R5980.1 R5981.1 R6019.1 R6036.1 R6037.2 R6042.1 S1.1 S2.1 S3.1 S4.1 S5.1 S6.1 S7.1 S8.1 S10.1 S13.1 S14.1 S15.1 S16.1 S17.1 S18.1 ST1.2 ST2.2 ST3.2 ST4.2 ST5.2 ST6.2 ST8.2 ST9.2 ST10.2 ST11.2 ST13.2 ST16.2 ST18.2 ST19.2 ST20.2 ST21.2 SW1.5(B4) SW1.6 SW1.7 SW1.8 SW2.9(B8) SW2.10 SW2.11 SW2.12 SW2.13 SW2.14 SW2.15 SW2.16 SW3.9(B8) SW3.10 SW3.11 SW3.12 SW3.13 SW3.14 SW3.15 SW3.16 SW4.5(B4) SW4.6 SW4.7 SW4.8 SW5.5(B4) SW5.6 SW5.7 SW5.8 SW8.3 SW8.6 SW9.3 SW9.4(A4) SW10.3 SW10.4(A4) U1.A2 U1.A4 U1.A18 U1.A32 U1.A46 U1.A58 U1.A60 U1.AA40 U1.AA50 U1.AA54 U1.AA58 U1.AA60 U1.AB21 U1.AB41 U1.AB49 U1.AB51 U1.AB53 U1.AB57 U1.AB59 U1.AC20 U1.AC24 U1.AC26 U1.AC28 U1.AC30 U1.AC32 U1.AC34 U1.AC36 U1.AC38 U1.AC40 U1.AC48 U1.AC50 U1.AC52 U1.AC54 U1.AC58 U1.AC60 U1.AD41 U1.AD47 U1.AD51 U1.AD55 U1.AD57 U1.AD61 U1.AE2 U1.AE4 U1.AE6 U1.AE8 U1.AE10 U1.AE12 U1.AE14 U1.AE16 U1.AE18 U1.AE20 U1.AE22 U1.AE24 U1.AE26 U1.AE28 U1.AE30 U1.AE32 U1.AE34 U1.AE36 U1.AE38 U1.AE40 U1.AE42 U1.AE46 U1.AE50 U1.AE54 U1.AE56 U1.AE60 U1.AE62 U1.AF11 U1.AF13 U1.AF15 U1.AF17 U1.AF39 U1.AF45 U1.AF47 U1.AF49 U1.AF51 U1.AF53 U1.AF57 U1.AF59 U1.AG2 U1.AG8 U1.AG10 U1.AG12 U1.AG14 U1.AG16 U1.AG18 U1.AG20 U1.AG22 U1.AG24 U1.AG26 U1.AG28 U1.AG30 U1.AG32 U1.AG34 U1.AG36 U1.AG38 U1.AG40 U1.AG42 U1.AG44 U1.AG48 U1.AG50 U1.AG52 U1.AG54 U1.AG58 U1.AG60 U1.AH1 U1.AH3 U1.AH7 U1.AH9 U1.AH39 U1.AH47 U1.AH51 U1.AH55 U1.AH57 U1.AH61 U1.AJ4 U1.AJ6 U1.AJ10 U1.AJ18 U1.AJ22 U1.AJ38 U1.AJ40 U1.AJ42 U1.AJ44 U1.AJ50 U1.AJ54 U1.AJ56 U1.AJ60 U1.AJ62 U1.AK3 U1.AK5 U1.AK9 U1.AK11 U1.AK19 U1.AK43 U1.AK45 U1.AK47 U1.AK49 U1.AK51 U1.AK53 U1.AK57 U1.AK59 U1.AL2 U1.AL6 U1.AL8 U1.AL12 U1.AL18 U1.AL20 U1.AL22 U1.AL24 U1.AL26 U1.AL28 U1.AL30 U1.AL32 U1.AL34 U1.AL36 U1.AL38 U1.AL40 U1.AL42 U1.AL44 U1.AL46 U1.AL48 U1.AL50 U1.AL52 U1.AL54 U1.AL58 U1.AL60 U1.AM1 U1.AM3 U1.AM7 U1.AM9 U1.AM13 U1.AM15 U1.AM17 U1.AM43 U1.AM45 U1.AM47 U1.AM51 U1.AM55 U1.AM57 U1.AM61 U1.AN4 U1.AN6 U1.AN10 U1.AN12 U1.AN22 U1.AN24 U1.AN26 U1.AN28 U1.AN30 U1.AN32 U1.AN34 U1.AN36 U1.AN38 U1.AN40 U1.AN42 U1.AN44 U1.AN50 U1.AN54 U1.AN56 U1.AN60 U1.AN62 U1.AP3 U1.AP5 U1.AP9 U1.AP11 U1.AP15 U1.AP19 U1.AP43 U1.AP45 U1.AP47 U1.AP51 U1.AP53 U1.AP57 U1.AP59 U1.AR2 U1.AR6 U1.AR8 U1.AR12 U1.AR22 U1.AR24 U1.AR26 U1.AR38 U1.AR40 U1.AR42 U1.AR46 U1.AR50 U1.AR52 U1.AR54 U1.AR58 U1.AR60 U1.AT1 U1.AT3 U1.AT7 U1.AT9 U1.AT15 U1.AT43 U1.AT45 U1.AT47 U1.AT51 U1.AT55 U1.AT57 U1.AT61 U1.AU4 U1.AU6 U1.AU10 U1.AU12 U1.AU14 U1.AU16 U1.AU18 U1.AU22 U1.AU24 U1.AU26 U1.AU38 U1.AU40 U1.AU42 U1.AU48 U1.AU50 U1.AU54 U1.AU56 U1.AU60 U1.AU62 U1.AV3 U1.AV5 U1.AV9 U1.AV11 U1.AV13 U1.AV17 U1.AV19 U1.AV45 U1.AV51 U1.AV53 U1.AV57 U1.AV59 U1.AW2 U1.AW6 U1.AW8 U1.AW12 U1.AW16 U1.AW18 U1.AW22 U1.AW24 U1.AW26 U1.AW38 U1.AW40 U1.AW42 U1.AW48 U1.AW50 U1.AW52 U1.AW54 U1.AW58 U1.AW60 U1.AY1 U1.AY3 U1.AY7 U1.AY9 U1.AY13 U1.AY45 U1.AY51 U1.AY55 U1.AY57 U1.AY61 U1.B1 U1.B3 U1.B11 U1.B25 U1.B39 U1.B53 U1.B59 U1.B61 U1.BA4 U1.BA6 U1.BA10 U1.BA12 U1.BA16 U1.BA18 U1.BA20 U1.BA22 U1.BA24 U1.BA38 U1.BA40 U1.BA42 U1.BA46 U1.BA48 U1.BA50 U1.BA54 U1.BA56 U1.BA60 U1.BA62 U1.BB3 U1.BB5 U1.BB9 U1.BB11 U1.BB13 U1.BB43 U1.BB45 U1.BB47 U1.BB51 U1.BB53 U1.BB57 U1.BB59 U1.BC2 U1.BC6 U1.BC8 U1.BC12 U1.BC16 U1.BC18 U1.BC22 U1.BC24 U1.BC26 U1.BC38 U1.BC40 U1.BC42 U1.BC50 U1.BC52 U1.BC54 U1.BC58 U1.BC60 U1.BD1 U1.BD3 U1.BD7 U1.BD9 U1.BD13 U1.BD15 U1.BD17 U1.BD45 U1.BD47 U1.BD51 U1.BD55 U1.BD57 U1.BD61 U1.BE4 U1.BE6 U1.BE10 U1.BE12 U1.BE18 U1.BE22 U1.BE24 U1.BE26 U1.BE38 U1.BE40 U1.BE42 U1.BE48 U1.BE50 U1.BE54 U1.BE56 U1.BE60 U1.BE62 U1.BF3 U1.BF5 U1.BF9 U1.BF11 U1.BF13 U1.BF15 U1.BF17 U1.BF19 U1.BF45 U1.BF47 U1.BF49 U1.BF51 U1.BF53 U1.BF57 U1.BF59 U1.BG2 U1.BG6 U1.BG8 U1.BG12 U1.BG18 U1.BG20 U1.BG22 U1.BG24 U1.BG26 U1.BG38 U1.BG40 U1.BG42 U1.BG44 U1.BG46 U1.BG48 U1.BG50 U1.BG52 U1.BG54 U1.BG58 U1.BG60 U1.BH1 U1.BH3 U1.BH7 U1.BH9 U1.BH13 U1.BH15 U1.BH17 U1.BH51 U1.BH55 U1.BH57 U1.BH61 U1.BJ4 U1.BJ6 U1.BJ10 U1.BJ12 U1.BJ16 U1.BJ18 U1.BJ22 U1.BJ24 U1.BJ26 U1.BJ38 U1.BJ40 U1.BJ42 U1.BJ44 U1.BJ46 U1.BJ48 U1.BJ50 U1.BJ54 U1.BJ56 U1.BJ60 U1.BJ62 U1.BK3 U1.BK5 U1.BK9 U1.BK11 U1.BK13 U1.BK43 U1.BK45 U1.BK47 U1.BK51 U1.BK53 U1.BK57 U1.BK59 U1.BL2 U1.BL6 U1.BL8 U1.BL12 U1.BL16 U1.BL18 U1.BL22 U1.BL24 U1.BL26 U1.BL28 U1.BL30 U1.BL32 U1.BL34 U1.BL36 U1.BL38 U1.BL40 U1.BL42 U1.BL52 U1.BL54 U1.BL58 U1.BL60 U1.BM1 U1.BM3 U1.BM7 U1.BM9 U1.BM13 U1.BM19 U1.BM51 U1.BM55 U1.BM57 U1.BM61 U1.BN4 U1.BN6 U1.BN10 U1.BN12 U1.BN16 U1.BN18 U1.BN20 U1.BN22 U1.BN24 U1.BN26 U1.BN28 U1.BN30 U1.BN32 U1.BN34 U1.BN36 U1.BN38 U1.BN40 U1.BN42 U1.BN48 U1.BN54 U1.BN56 U1.BN60 U1.BN62 U1.BP3 U1.BP5 U1.BP9 U1.BP11 U1.BP13 U1.BP43 U1.BP45 U1.BP49 U1.BP51 U1.BP53 U1.BP57 U1.BP59 U1.BR2 U1.BR6 U1.BR8 U1.BR12 U1.BR14 U1.BR16 U1.BR18 U1.BR22 U1.BR38 U1.BR40 U1.BR42 U1.BR46 U1.BR48 U1.BR52 U1.BR54 U1.BR58 U1.BR60 U1.BT1 U1.BT3 U1.BT7 U1.BT9 U1.BT13 U1.BT15 U1.BT17 U1.BT25 U1.BT55 U1.BT57 U1.BT61 U1.BU4 U1.BU6 U1.BU10 U1.BU12 U1.BU18 U1.BU20 U1.BU22 U1.BU24 U1.BU26 U1.BU28 U1.BU30 U1.BU32 U1.BU34 U1.BU36 U1.BU38 U1.BU40 U1.BU42 U1.BU54 U1.BU56 U1.BU62 U1.BV3 U1.BV5 U1.BV9 U1.BV11 U1.BV25 U1.BV57 U1.BV59 U1.BV61 U1.BW2 U1.BW6 U1.BW8 U1.BW12 U1.BW14 U1.BW16 U1.BW20 U1.BW22 U1.BW24 U1.BW26 U1.BW28 U1.BW30 U1.BW32 U1.BW34 U1.BW36 U1.BW38 U1.BW40 U1.BW42 U1.BW44 U1.BW46 U1.BW48 U1.BW50 U1.BW52 U1.BW54 U1.BW56 U1.BW58 U1.BW60 U1.BW62 U1.BY1 U1.BY3 U1.BY7 U1.BY9 U1.BY13 U1.BY23 U1.BY51 U1.BY59 U1.C2 U1.C4 U1.C18 U1.C32 U1.C46 U1.C60 U1.C62 U1.CA2 U1.CA4 U1.CA6 U1.CA8 U1.CA10 U1.CA12 U1.CA20 U1.CA22 U1.CA24 U1.CA26 U1.CA28 U1.CA30 U1.CA32 U1.CA34 U1.CA36 U1.CA38 U1.CA40 U1.CA42 U1.CA44 U1.CA46 U1.CB3 U1.CB5 U1.CB9 U1.CB11 U1.CB23 U1.CB55 U1.CC4 U1.CC6 U1.CC10 U1.CC12 U1.CC26 U1.CC40 U1.CC42 U1.CC44 U1.CC46 U1.CC54 U1.CD1 U1.CD3 U1.CD5 U1.CD7 U1.CD9 U1.CD11 U1.CD13 U1.CD15 U1.CD17 U1.CD19 U1.CD21 U1.CD23 U1.CD25 U1.CD27 U1.CD29 U1.CD31 U1.CD33 U1.CD35 U1.CD37 U1.CD39 U1.CD41 U1.CD43 U1.CD45 U1.CD47 U1.CD49 U1.CD51 U1.CD53 U1.CD55 U1.CD57 U1.CD59 U1.CD61 U1.CE2 U1.CE16 U1.CE30 U1.CE44 U1.CE58 U1.CF9 U1.CF23 U1.CF37 U1.CF51 U1.CG2 U1.CG16 U1.CG30 U1.CG44 U1.CG58 U1.CH9 U1.CH23 U1.CH37 U1.CH51 U1.CJ2 U1.CJ4 U1.CJ6 U1.CJ8 U1.CJ10 U1.CJ12 U1.CJ14 U1.CJ16 U1.CJ18 U1.CJ20 U1.CJ22 U1.CJ24 U1.CJ26 U1.CJ28 U1.CJ30 U1.CJ32 U1.CJ34 U1.CJ36 U1.CJ38 U1.CJ40 U1.CJ42 U1.CJ44 U1.CJ46 U1.CJ48 U1.CJ50 U1.CJ52 U1.CJ54 U1.CJ56 U1.CJ58 U1.CJ60 U1.CJ62 U1.CK9 U1.CK23 U1.CK37 U1.CK51 U1.CL2 U1.CL16 U1.CL30 U1.CL44 U1.CL58 U1.CM9 U1.CM23 U1.CM37 U1.CM51 U1.CN2 U1.CN16 U1.CN30 U1.CN44 U1.CN58 U1.CP1 U1.CP3 U1.CP5 U1.CP7 U1.CP9 U1.CP11 U1.CP13 U1.CP15 U1.CP17 U1.CP19 U1.CP21 U1.CP23 U1.CP25 U1.CP27 U1.CP29 U1.CP31 U1.CP33 U1.CP35 U1.CP37 U1.CP39 U1.CP41 U1.CP43 U1.CP45 U1.CP47 U1.CP49 U1.CP51 U1.CP53 U1.CP55 U1.CP57 U1.CP59 U1.CP61 U1.CR2 U1.CR16 U1.CR30 U1.CR44 U1.CR58 U1.CT9 U1.CT23 U1.CT37 U1.CT51 U1.CU2 U1.CU16 U1.CU30 U1.CU44 U1.CU58 U1.CV9 U1.CV23 U1.CV37 U1.CV51 U1.CW2 U1.CW4 U1.CW6 U1.CW8 U1.CW10 U1.CW12 U1.CW14 U1.CW16 U1.CW18 U1.CW20 U1.CW22 U1.CW24 U1.CW26 U1.CW28 U1.CW30 U1.CW32 U1.CW34 U1.CW36 U1.CW38 U1.CW40 U1.CW42 U1.CW44 U1.CW46 U1.CW48 U1.CW50 U1.CW52 U1.CW54 U1.CW56 U1.CW58 U1.CW60 U1.CW62 U1.CY1 U1.CY9 U1.CY23 U1.CY37 U1.CY51 U1.CY61 U1.D1 U1.D3 U1.D11 U1.D25 U1.D39 U1.D53 U1.D61 U1.DA2 U1.DA16 U1.DA30 U1.DA44 U1.DA58 U1.DA60 U1.DA62 U1.DB1 U1.DB3 U1.DB9 U1.DB23 U1.DB37 U1.DB51 U1.DB59 U1.DB61 U1.DC2 U1.DC4 U1.DC16 U1.DC30 U1.DC44 U1.DC58 U1.DC60 U1.E2 U1.E4 U1.E6 U1.E8 U1.E10 U1.E12 U1.E14 U1.E16 U1.E18 U1.E20 U1.E22 U1.E24 U1.E26 U1.E28 U1.E30 U1.E32 U1.E34 U1.E36 U1.E38 U1.E40 U1.E42 U1.E44 U1.E46 U1.E48 U1.E50 U1.E52 U1.E54 U1.E56 U1.E58 U1.E60 U1.E62 U1.F11 U1.F25 U1.F39 U1.F53 U1.G4 U1.G18 U1.G32 U1.G46 U1.G60 U1.H11 U1.H25 U1.H39 U1.H53 U1.J4 U1.J18 U1.J32 U1.J46 U1.J60 U1.K1 U1.K3 U1.K5 U1.K7 U1.K9 U1.K11 U1.K13 U1.K15 U1.K17 U1.K19 U1.K21 U1.K23 U1.K25 U1.K27 U1.K29 U1.K31 U1.K33 U1.K35 U1.K37 U1.K39 U1.K41 U1.K43 U1.K45 U1.K47 U1.K49 U1.K51 U1.K53 U1.K55 U1.K57 U1.K59 U1.K61 U1.L4 U1.L18 U1.L32 U1.L46 U1.L60 U1.M11 U1.M25 U1.M39 U1.M53 U1.N4 U1.N18 U1.N32 U1.N46 U1.N60 U1.P11 U1.P25 U1.P39 U1.P53 U1.R2 U1.R4 U1.R6 U1.R8 U1.R10 U1.R12 U1.R14 U1.R16 U1.R18 U1.R20 U1.R22 U1.R24 U1.R26 U1.R28 U1.R30 U1.R32 U1.R34 U1.R36 U1.R38 U1.R40 U1.R42 U1.R44 U1.R46 U1.R48 U1.R50 U1.R52 U1.R54 U1.R56 U1.R58 U1.R60 U1.R62 U1.T11 U1.T25 U1.T39 U1.T53 U1.U4 U1.U18 U1.U32 U1.U46 U1.U60 U1.V11 U1.V25 U1.V39 U1.V53 U1.W4 U1.W18 U1.W32 U1.W46 U1.W60 U1.Y1 U1.Y3 U1.Y5 U1.Y7 U1.Y9 U1.Y11 U1.Y13 U1.Y15 U1.Y17 U1.Y19 U1.Y21 U1.Y23 U1.Y25 U1.Y27 U1.Y29 U1.Y31 U1.Y33 U1.Y35 U1.Y37 U1.Y39 U1.Y41 U1.Y43 U1.Y45 U1.Y47 U1.Y49 U1.Y51 U1.Y53 U1.Y55 U1.Y57 U1.Y59 U1.Y61 U2.B4 U3.A2 U3.A8 U3.B2 U3.C9 U3.D2 U3.D8 U3.E1 U3.E3 U3.E8 U3.F1 U3.G8 U3.H1 U3.H9 U3.K1 U3.K9 U3.N1 U3.T1 U4.A2 U4.A8 U4.B2 U4.C9 U4.D2 U4.D8 U4.E1 U4.E3 U4.E8 U4.F1 U4.G8 U4.H1 U4.H9 U4.K1 U4.K9 U4.N1 U4.T1 U5.A2 U5.A8 U5.B2 U5.C9 U5.D2 U5.D8 U5.E1 U5.E3 U5.E8 U5.F1 U5.G8 U5.H1 U5.H9 U5.K1 U5.K9 U5.N1 U5.T1 U6.A2 U6.A8 U6.B2 U6.C9 U6.D2 U6.D8 U6.E1 U6.E3 U6.E8 U6.F1 U6.G8 U6.H1 U6.H9 U6.K1 U6.K9 U6.N1 U6.T1 U7.A2 U7.A8 U7.B2 U7.C9 U7.D2 U7.D8 U7.E1 U7.E3 U7.E8 U7.F1 U7.G8 U7.H1 U7.H9 U7.K1 U7.K9 U7.N1 U7.T1 U10.B4 U11.B4 U12.1 U12.4 U12.7 U12.13 U12.16 U12.19 U12.20 U12.23 U12.26 U12.32 U12.35 U12.38 U12.39 U12.42 U12.45 U12.51 U12.54 U12.57 U12.58 U12.61 U12.64 U12.70 U12.73 U12.76 U13.B4 U14.B4 U15.27 U15.53 U15.61 U15.64 U15.65 U15.97(VSS) U16.B4 U17.B4 U18.B2 U19.B2 U20.1 U21.6 U21.10 U21.12 U21.14 U21.26 U21.28 U21.41 U21.53 U21.56 U21.57 U22.1 U23.A1 U23.A18 U23.B6 U23.B10 U23.B15 U23.D3 U23.E2 U23.E3 U23.E6 U23.E10 U23.E13 U23.F8 U23.F17 U23.G2 U23.G4 U23.H14 U23.J10 U23.J17 U23.K6 U23.K9 U23.K13 U23.L4 U23.M14 U23.N2 U23.N5 U23.N10 U23.N12 U23.N17 U23.R7 U23.U4 U23.U10 U23.U14 U23.V1 U23.V18 U24.12 U25.12 U28.1 U29.A1 U29.A18 U29.B6 U29.B10 U29.B15 U29.D3 U29.E2 U29.E3 U29.E6 U29.E10 U29.E13 U29.F8 U29.F17 U29.G2 U29.G4 U29.H14 U29.J10 U29.J17 U29.K6 U29.K9 U29.K13 U29.L4 U29.M14 U29.N2 U29.N5 U29.N10 U29.N12 U29.N17 U29.R7 U29.U4 U29.U10 U29.U14 U29.V1 U29.V18 U31.21 U31.25 U32.1 U32.4 U32.6 U32.30 U32.31 U32.32 U32.33 U32.34 U32.35 U32.36 U32.37 U32.38 U32.39 U33.1 U33.4 U33.6 U33.7 U33.30 U33.31 U33.32 U33.33 U33.34 U33.35 U33.37 U33.38 U33.39 U34.6 U34.33 U35.8 U35.32 U35.33 U36.4 U36.6 U36.23 U36.25 U37.6 U37.23 U37.25 U38.65 U39.2 U40.B4 U41.B4 U42.B4 U43.4 U44.1 U44.2 U44.3 U44.4 U45.4 U46.15 U48.7 U48.17 U49.B3 U49.C3 U49.D3 U49.D4 U49.E3 U51.1 U51.9 U52.B3 U52.C3 U52.D3 U52.D4 U52.E3 U53.A3 U53.A4 U53.A5 U53.A6 U53.B1 U53.B3 U53.B4 U53.B5 U53.B6 U53.C1 U53.C2 U53.C3 U53.C4 U53.C5 U53.C6 U53.D2 U53.D3 U53.D4 U53.D5 U53.D6 U53.E5 U53.E6 U53.F5 U53.F6 U53.F7 U53.F8 U53.G5 U53.G6 U53.G7 U53.G8 U53.H5 U53.H6 U53.H7 U53.H8 U53.J2 U53.J3 U53.J4 U53.J5 U53.J6 U53.K2 U53.K3 U53.K4 U53.K5 U53.K6 U53.L1 U53.L3 U53.L4 U53.L5 U53.L6 U53.M3 U53.M4 U53.M5 U53.M6 U54.40 U54.41(VSENSE1-) U54.53 U57.A3 U57.A4 U57.A5 U57.A6 U57.B1 U57.B3 U57.B4 U57.B5 U57.B6 U57.C1 U57.C2 U57.C3 U57.C4 U57.C5 U57.C6 U57.D2 U57.D3 U57.D4 U57.D5 U57.D6 U57.E5 U57.E6 U57.F5 U57.F6 U57.F7 U57.F8 U57.G5 U57.G6 U57.G7 U57.G8 U57.H5 U57.H6 U57.H7 U57.H8 U57.J2 U57.J3 U57.J4 U57.J5 U57.J6 U57.K2 U57.K3 U57.K4 U57.K5 U57.K6 U57.L1 U57.L3 U57.L4 U57.L5 U57.L6 U57.M3 U57.M4 U57.M5 U57.M6 U58.A3 U58.A4 U58.A5 U58.A6 U58.B1 U58.B3 U58.B4 U58.B5 U58.B6 U58.C1 U58.C2 U58.C3 U58.C4 U58.C5 U58.C6 U58.D2 U58.D3 U58.D4 U58.D5 U58.D6 U58.E5 U58.E6 U58.F5 U58.F6 U58.F7 U58.F8 U58.G5 U58.G6 U58.G7 U58.G8 U58.H5 U58.H6 U58.H7 U58.H8 U58.J2 U58.J3 U58.J4 U58.J5 U58.J6 U58.K2 U58.K3 U58.K4 U58.K5 U58.K6 U58.L1 U58.L3 U58.L4 U58.L5 U58.L6 U58.M3 U58.M4 U58.M5 U58.M6 U59.A4 U59.A6 U59.A7 U59.A8 U59.A9 U59.A10 U59.B4 U59.B5 U59.B6 U59.B7 U59.B8 U59.B9 U59.C4 U59.C6 U59.C7 U59.C8 U59.C9 U59.D4 U59.D7 U59.E3 U59.F3 U59.F10 U59.G3 U59.G10 U59.G11 U59.G12 U59.H3 U59.H10 U59.J4 U59.J10 U59.K4 U59.K7 U59.K8 U59.K9 U59.L4 U59.L5 U59.L6 U59.L7 U59.L8 U59.L9 U59.M4 U59.M6 U59.M7 U59.M8 U59.M9 U59.M10 U60.A1 U60.A2 U60.A3 U60.A4 U60.A5 U60.A6 U60.A7 U60.A8 U60.A9 U60.A10 U60.A11 U60.B1 U60.B9 U60.B10 U60.B11 U60.F3 U60.F7 U60.F8 U60.G1 U60.G2 U60.G3 U60.G4 U60.G5 U60.G6 U60.G7 U60.G8 U61.A1 U61.A2 U61.A3 U61.A4 U61.A5 U61.A6 U61.A7 U61.A8 U61.A9 U61.A10 U61.A11 U61.B1 U61.B9 U61.B10 U61.B11 U61.F3 U61.F7 U61.F8 U61.G1 U61.G2 U61.G3 U61.G4 U61.G5 U61.G6 U61.G7 U61.G8 U62.A1 U62.A2 U62.A3 U62.A4 U62.A5 U62.A6 U62.A7 U62.A8 U62.A9 U62.A10 U62.A11 U62.B1 U62.B9 U62.B10 U62.B11 U62.F3 U62.F7 U62.F8 U62.G1 U62.G2 U62.G3 U62.G4 U62.G5 U62.G6 U62.G7 U62.G8 U63.A1 U63.A2 U63.A3 U63.A4 U63.A5 U63.A6 U63.A7 U63.A8 U63.A9 U63.A10 U63.A11 U63.B1 U63.B9 U63.B10 U63.B11 U63.F3 U63.F7 U63.F8 U63.G1 U63.G2 U63.G3 U63.G4 U63.G5 U63.G6 U63.G7 U63.G8 U64.A1 U64.A2 U64.A3 U64.A4 U64.A5 U64.A6 U64.A7 U64.A8 U64.A9 U64.A10 U64.A11 U64.B1 U64.B9 U64.B10 U64.B11 U64.F3 U64.F7 U64.F8 U64.G1 U64.G2 U64.G3 U64.G4 U64.G5 U64.G6 U64.G7 U64.G8 U65.B3 U65.C3 U65.D3 U65.D4 U65.E3 U66.B3 U66.C3 U66.D3 U66.D4 U66.E3 U67.4 U67.8 U67.11 U68.A1 U68.A2 U68.A3 U68.A4 U68.A5 U68.A6 U68.A7 U68.A8 U68.A9 U68.A10 U68.A11 U68.B1 U68.B9 U68.B10 U68.B11 U68.F3 U68.F7 U68.F8 U68.G1 U68.G2 U68.G3 U68.G4 U68.G5 U68.G6 U68.G7 U68.G8 U69.4 U69.8 U69.11 U70.A1 U70.A2 U70.A3 U70.A4 U70.A5 U70.A6 U70.A7 U70.A8 U70.A9 U70.A10 U70.A11 U70.B1 U70.B9 U70.B10 U70.B11 U70.F3 U70.F7 U70.F8 U70.G1 U70.G2 U70.G3 U70.G4 U70.G5 U70.G6 U70.G7 U70.G8 U71.A1 U71.A2 U71.A3 U71.A4 U71.A5 U71.A6 U71.A7 U71.A8 U71.A9 U71.A10 U71.A11 U71.B1 U71.B9 U71.B10 U71.B11 U71.F3 U71.F7 U71.F8 U71.G1 U71.G2 U71.G3 U71.G4 U71.G5 U71.G6 U71.G7 U71.G8 U72.B3 U72.C3 U72.D3 U72.D4 U72.E3 U79.B4 U80.2 U81.4 U82.8 U82.10 U82.12 U84.4 U84.7 U87.7 U87.8 U87.9 U87.17 U87.18 U87.19 U87.27 U87.31 U87.39 U87.40 U87.41 U88.7 U88.8 U88.9 U88.17 U88.18 U88.19 U88.27 U88.31 U88.39 U88.40 U88.41 U89.7 U89.8 U89.9 U89.17 U89.18 U89.19 U89.27 U89.31 U89.39 U89.40 U89.41 U90.7 U90.8 U90.9 U90.17 U90.18 U90.19 U90.27 U90.31 U90.39 U90.40 U90.41 V4.1 X1.2 X2.2 X3.2 Y1.2 Y1.4 Y2.3 Y3.2 Y3.4 Y4.2 Y4.4 Y5.2 Y5.4
GND_ETHE: C624.1 J15.11 J15.12 R980.1
GND_QSFP_CAGE: B1.1 B1.2 B1.3 B1.4 B1.5 B1.6 B1.7 B1.8 B1.9(PIN9) B1.10 B1.11 C579.1 R229.1
GND_QSFPDD_CAGE: C558.1 R190.1 U12.79 U12.80 U12.81 U12.82 U12.83 U12.84 U12.85(CG9) U12.86 U12.87 U12.88
GND_USB: C667.1 CN1.5 CN1.6 R298.1
GNDSENSE: C11.1 R95.1 U1.BA26
VBUS_5V: C668.1 CN1.1 R299.1 U20.4(VCC)
VCC_FPGA_TESTI2C: C650.1 C651.1 C656.1 C657.1 J17.3 R269.2 R270.2 R271.2 U17.B1
VCC_FPGA_VID: C18.1 C19.1 C20.1 C21.1 C22.1 C23.1 C24.1 C25.1 C26.1 C27.1 C28.1 C29.1 C30.1 C31.1 C32.1 C33.1 C34.1 C35.1 C36.1 C37.1 C41.1 C42.1 C43.1 C44.1 C45.1 C46.1 C47.1 C48.1 C49.1 C50.1 C80.1 C81.1 C82.1 C83.1 C84.1 C85.1 C87.1 C88.1 C89.1 C90.1 C91.1 C92.1 C93.1 C94.1 C95.1 C96.1 C97.1 C98.1 C99.1 C100.1 C101.1 C102.1 C103.1 C104.1 C105.1 C106.1 C107.1 C108.1 C109.1 C1290.1 C1291.1 C1292.1 C1293.1 C1294.1 C1295.1 C1296.2 C1297.2 C1298.2 C1299.2 C1300.2 C1301.2 C1302.2 C1303.2 C1304.2 C1305.2 C1306.2 C1307.2 C1308.2 C1309.2 C1310.2 C1337.1 C1338.1 C1339.1 C1340.1 C1341.1 C1342.1 C1343.1 C1344.1 C1345.1 C1346.1 C1347.1 C1348.1 C1349.1 C1350.1 C1351.1 C1352.1 C1353.1 C1354.1 C1355.1 C1356.1 C1357.1 C1358.1 C1359.1 C1360.1 C1361.1 C1362.1 C1363.1 C1364.1 C1365.1 C1366.1 C1367.1 C1368.1 C1369.1 C1370.1 C1371.1 C1372.1 C1373.1 C1374.1 C1375.1 C1376.1 C1660.2 C1661.2 C1664.1(P) C1682.2 C1683.2 C1687.1(P) C1703.2 C1704.2 C1709.1(P) C1726.2 C1727.2 C1733.1(P) C2119.1(P) C2120.2 C2121.2 C2122.1(P) C2123.2 C2124.2 C2125.1(P) C2126.2 C2127.2 C2128.1(P) C2129.2 C2130.2 L1.2 L47.2 L48.2 L49.2 R950.1 R952.1 U1.AF27 U1.AF29 U1.AF31 U1.AF33 U1.AF35 U1.AF41 U1.AH27 U1.AH29 U1.AH31 U1.AH33 U1.AH35 U1.AH41 U1.AK21 U1.AK25 U1.AK27 U1.AK29 U1.AK31 U1.AK33 U1.AK35 U1.AK37 U1.AK39 U1.AK41 U1.AM21 U1.AM23 U1.AM25 U1.AM27 U1.AM29 U1.AM31 U1.AM33 U1.AM35 U1.AM37 U1.AM39 U1.AM41 U1.AP21 U1.AP23 U1.AP25 U1.AP37 U1.AP39 U1.AP41 U1.AT21 U1.AT23 U1.AT25 U1.AT37 U1.AT39 U1.AT41 U1.AV21 U1.AV23 U1.AV25 U1.AV37 U1.AV39 U1.AV41 U1.AY21 U1.AY23 U1.AY25 U1.AY37 U1.AY39 U1.AY41 U1.BB21 U1.BB23 U1.BB37 U1.BB39 U1.BB41 U1.BD21 U1.BD23 U1.BD25 U1.BD37 U1.BD39 U1.BD41 U1.BF21 U1.BF23 U1.BF25 U1.BF37 U1.BF39 U1.BF41 U1.BH21 U1.BH23 U1.BH25 U1.BH37 U1.BH39 U1.BH41 U1.BK21 U1.BK23 U1.BK25 U1.BK37 U1.BK39 U1.BK41 U1.BM21 U1.BM23 U1.BM25 U1.BM27 U1.BM29 U1.BM31 U1.BM33 U1.BM35 U1.BM37 U1.BM39 U1.BM41 U1.BP21 U1.BP23 U1.BP25 U1.BP27 U1.BP29 U1.BP31 U1.BP33 U1.BP35 U1.BP37 U1.BP39 U1.BP41 U1.BT21 U1.BT23 U1.BT27 U1.BT29 U1.BT31 U1.BT33 U1.BT35 U1.BV21 U1.BV23 U1.BV27 U1.BV29 U1.BV31 U1.BV33 U1.BV35
VCC_PWM0: R1100.1 U54.5
VCC_PWM2: R1111.1 U54.2
VCC_PWM3: R5894.1 U54.1
VCC_PWM4: R1105.1 U54.50
VCC_TESTI2C_1.2V: C652.1 C653.1 C654.1 C655.1 J17.8 R272.2 R273.2 R274.2 R279.2 U17.B2(VL)
VCCA_PLL_FPGA_1.2V: C228.1 C229.1 C230.1 C231.1 C232.1 C233.1 C234.1 C235.1 C1424.1 C1425.1 C1426.1 L41.2 U1.AA28 U1.AA30 U1.AA32 U1.AA34 U1.CC28 U1.CC30 U1.CC32 U1.CC34
VCCA_PWRMAX_3.3V: C719.1 C720.2 C721.1 C722.1 C723.1 C724.1 C725.1 C726.1 L16.2 U23.F3 U23.F4 U23.F6 U23.F14 U23.M6 U23.P13
VCCA_SYSMAX_3.3V: C754.1 C755.2 C756.1 C757.1 C758.1 C759.1 C760.1 C761.1 L17.2 U29.F3 U29.F4 U29.F6 U29.F14 U29.M6 U29.P13
VCCBAT: BT1.1 R93.2 U46.14
VCCBAT_FPGA_1.8V: C1628.1 R92.1 R93.1 U1.CA48 U1.CC48
VCCCLK_GXE_FPGA_2.5V: C1377.1 R728.2 TP179.1(TP) U1.AR18 U32.17 V19.1
VCCCLK_GXP_FPGA_1.8V: C262.1 C263.1 C1623.1 C1624.1 C1625.1 C1626.1 L42.2 U1.BH45 U1.BH47
VCCFUSEWR_SDM_FPGA_2.4V: C371.1 C1319.1 R736.2 TP180.1(TP) U1.BY49 U1.CB49 U32.18 V21.1
VCCFUSEWR_SDM_FPGA_2.4V_SET: Q7.1 R982.2 U23.C8
VCCH_FPGA_0.9V: C120.1 C121.1 C122.1 C124.1 C125.1 C126.1 C127.1 C130.1 C132.1 C133.1 C134.1 C135.1 C136.1 C139.1 C140.2 C141.1 C142.1 C143.1 C144.1 C145.1 C146.1 C147.2 C148.2 C149.2 C150.2 C151.1 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C164.2 C165.2 C197.1 C198.1 C201.1 C202.1 C1798.1 C1799.1 C1801.1 C1802.1 C1803.1 C1804.1 C1805.1 C1807.1 C1808.1 C1809.1 C1810.1 C1811.1 C1812.1 C1813.1 L2.1 L5.1 L39.1 R96.1 TP171.1(TP) U1.AR44 U1.AU20 U1.AU44 U1.AV43 U1.AW20 U1.AW44 U1.AY19 U1.AY43 U1.BA44 U1.BB19 U1.BC20 U1.BC44 U1.BD19 U1.BD43 U1.BE20 U1.BE44 U1.BF43 U1.BH19 U1.BH43 U1.BJ20 U1.BK19 U1.BL20 U1.BP19 U1.BR20 U1.BR44 U1.BT19 U1.BT43 U57.A7 U57.A8 U57.A9 U57.A10 U57.B7 U57.B8 U57.B9 U57.B10 U57.B11 U57.B12 U57.C7 U57.C8 U57.C9 U57.D7 U57.K7 U57.K8 U57.K9 U57.K10 U57.K11 U57.L7 U57.L8 U57.L9 U57.L10 U57.L11 U57.L12 U57.M7 U57.M8 U57.M9 U57.M10
VCCH_GXE_FPGA_1.1V: C192.1 C193.1 C209.1 C210.1 C245.2 C246.2 C261.1 C268.1 C269.1 C270.1 C271.1 C272.1 C273.1 C274.1 C1948.2 R703.2 TP176.1(TP) U1.AY17 U1.BB17 U1.BK17 U1.BM17 U1.BP17 U32.14 V13.1
VCCH_GXP_FPGA_1.8V: C203.2 C204.2 C205.1 C206.1 C254.1 C255.1 C256.1 C257.1 C258.1 C259.1 C260.1 L6.2 U1.AN46 U1.AU46 U1.AV47 U1.AW46 U1.AY47 U1.BC46 U1.BE46
VCCH_VDD33: R1138.2 R1139.2 R5458.2 R5459.2 R5460.2 R5463.1 U57.E8
VCCIO_FPGA_1.2V: C14.1 C15.1 C16.2 C275.1 C276.1 C277.1 C278.1 C279.1 C280.1 C281.1 C282.1 C283.1 C284.1 C285.1 C286.1 C287.1 C288.1 C289.1 C290.1 C291.1 C292.1 C293.2 C294.2 C337.2 C338.2 C374.1 C548.1 C553.1 C575.1 C578.1 C627.1 C658.1 C659.1 C661.1 C662.1 C732.1 C733.1 C734.1 C767.1 C768.1 C769.1 C770.1 C771.1 C772.1 C773.1 C774.1 C775.1 C935.1 C938.1 C941.1 C1116.1 C1117.1 C1118.1 C1119.1 C1120.1 C1121.1 C1122.1 C1123.1 C1124.1 C1330.1 C1378.2 C1379.2 C1380.2 C1381.1 C1382.1 C1383.1 C1384.1 C1385.1 C1468.1 C1469.1 C1470.1 C1471.1 C1472.1 C1473.1 C1474.1 C1475.1 C1476.1 C1477.1 C1478.1 C1479.1 C1480.1 C1481.1 C1482.1 C1483.1 C1484.2 C1485.2 C1486.2 C1487.2 C1488.2 C1499.1 C1500.1 C1501.1 C1502.1 C1503.1 C1504.1 C1505.1 C1506.1 C1507.1 C1508.1 C1509.1 C1510.1 C1511.1 C1512.1 C1513.1 C1514.1 C1515.2 C1516.2 C1517.2 C1518.2 C1519.2 C1530.1 C1531.1 C1532.1 C1533.1 C1534.1 C1535.1 C1536.1 C1537.1 C1546.2 C1547.2 C1781.1 C1842.1 C1934.1 C2064.1 C2065.1 C2066.1 C2067.1 J16.5 J17.7 L41.1 R55.2 R57.2 R65.2 R67.2 R98.2 R105.2 R106.2 R108.2 R133.1 R138.2 R139.1 R141.1 R189.2 R202.2 R203.2 R207.2 R209.2 R210.2 R211.2 R212.2 R213.2 R214.2 R215.2 R216.2 R217.2 R226.2 R227.2 R228.2 R245.1 R246.1 R247.1 R248.1 R251.2 R275.2 R276.2 R277.2 R278.2 R280.2 R281.2 R282.2 R283.2 R380.2 R381.2 R382.2 R383.2 R479.2 R666.2 R878.2 R879.2 R880.2 R881.2 R891.2 R892.2 R893.2 R894.2 R895.2 R896.2 R897.2 R898.2 R913.2 R914.2 R999.2 R1153.1 TP173.1(TP) U1.AB25 U1.AB27 U1.AB29 U1.AB31 U1.AB33 U1.AB35 U1.AB37 U1.AB39 U1.AD25 U1.AD27 U1.AD29 U1.AD31 U1.AD33 U1.AD35 U1.AD37 U1.AD39 U1.AF37 U1.AH37 U1.AJ24 U1.AJ26 U1.AJ28 U1.BR24 U1.BR26 U1.BR28 U1.BT37 U1.BV37 U1.BV43 U1.BY25 U1.BY27 U1.BY33 U1.BY35 U1.BY37 U1.BY39 U1.CB25 U1.CB27 U1.CB33 U1.CB35 U1.CB37 U1.CB39 U2.B2(VL) U3.A1 U3.A9 U3.B3 U3.B9 U3.C1 U3.D1 U3.D9 U3.F2 U3.F8 U3.G1 U3.G7 U3.G9 U3.J1 U3.J2 U3.J8 U3.J9 U3.L1 U3.L9 U3.R1 U3.T9 U4.A1 U4.A9 U4.B3 U4.B9 U4.C1 U4.D1 U4.D9 U4.F2 U4.F8 U4.G1 U4.G7 U4.G9 U4.J1 U4.J2 U4.J8 U4.J9 U4.L1 U4.L9 U4.R1 U4.T9 U5.A1 U5.A9 U5.B3 U5.B9 U5.C1 U5.D1 U5.D9 U5.F2 U5.F8 U5.G1 U5.G7 U5.G9 U5.J1 U5.J2 U5.J8 U5.J9 U5.L1 U5.L9 U5.R1 U5.T9 U6.A1 U6.A9 U6.B3 U6.B9 U6.C1 U6.D1 U6.D9 U6.F2 U6.F8 U6.G1 U6.G7 U6.G9 U6.J1 U6.J2 U6.J8 U6.J9 U6.L1 U6.L9 U6.R1 U6.T9 U7.A1 U7.A9 U7.B3 U7.B9 U7.C1 U7.D1 U7.D9 U7.F2 U7.F8 U7.G1 U7.G7 U7.G9 U7.J1 U7.J2 U7.J8 U7.J9 U7.L1 U7.L9 U7.R1 U7.T9 U10.B2(VL) U11.B2(VL) U13.B2(VL) U14.B2(VL) U16.B2(VL) U18.B4(VCCB) U19.B4(VCCB) U23.P11 U23.P12 U29.D11 U29.E11 U29.E12 U29.G13 U29.G14 U29.H13 U29.J13 U29.J14 U40.B2(VL) U41.B2(VL) U42.B2(VL) U59.A1 U59.A2 U59.A3 U59.B1 U59.B2 U59.B3 U59.C1 U59.C2 U59.C3 U59.D1 U59.D2 U59.D3 U59.J1 U59.J2 U59.J3 U59.K1 U59.K2 U59.K3 U59.L1 U59.L2 U59.L3 U59.M1 U59.M2 U59.M3 U69.2 U79.B2(VL)
VCCIO_FPGA_1.5V: C1386.1 C1387.1 C1388.1 C1389.2 C1950.2 R27.2 R29.2 R31.2 R34.2 R39.2 R40.1 R45.2 R46.1 R49.2 R51.2 R718.1 TP178.1(TP) U1.BY29 U1.BY31 U1.CB29 U1.CB31 U32.16 V17.1
VCCIO_FPGA_1.8V: C2.2 C3.2 C6.1 C344.1 C345.1 C346.1 C347.1 C348.2 C349.2 C520.1 C521.1 C522.1 C523.1 C524.1 C525.1 C526.1 C527.1 C528.1 C529.1 C530.1 C531.1 C735.1 C736.1 C737.1 C738.1 C776.1 C777.1 C778.1 C779.1 C780.1 C781.1 C782.1 C783.1 C784.1 C785.1 C786.1 C787.1 C788.1 C789.1 C790.1 C942.2 C1412.1 C1413.1 C1414.1 C1415.1 C1416.1 C1417.1 C1949.2 J5.2 J5.59 J10.1 J10.2 J11.1 J11.2 R1.2 R2.2 R7.2 R18.1 R20.1 R21.1 R22.1 R61.1 R69.1 R71.1 R80.2 R81.2 R82.2 R83.2 R84.1 R88.2 R92.2 R182.2 R183.2 R483.1 R485.1 R499.2 R921.1 R948.1 R1004.2 R1024.1 TP177.1(TP) U1.AD21 U1.AF21 U1.AH21 U1.BY41 U1.CB41 U23.D11 U23.E11 U23.E12 U29.K14 U29.L5 U29.L6 U29.L13 U29.L14 U29.M5 U29.M13 U29.N9 U29.P7 U29.P8 U29.P9 U29.P11 U29.P12 U32.15 U43.1 V25.1
VCCL_HPS_FPGA_0.9V: C12.1 C13.1 C17.2 C38.2 C163.2 C1946.2 L9.2 R681.2 R952.2 TP174.1(TP) U1.AF23 U1.AF25 U1.AH23 U1.AH25 U1.AK23 U32.12 V9.1
VCCL_SDM_FPGA_0.8V: C71.1 C73.1 C74.1 C75.1 C76.2 C77.2 C199.2 C1947.2 L8.2 R690.1 TP175.1(TP) U1.BT39 U1.BT41 U1.BV39 U1.BV41 U32.13 V11.1
VCCLPLLDIG_HPS_FPGA_0.9V: C78.1 C79.1 C1586.1 L9.1 U1.AB23 U1.AD23
VCCLPLLDIG_SDM_FPGA_0.8V: C39.1 C40.1 C252.1 L8.1 U1.BY45 U1.CB45
VCCLSENSE: C11.2 R94.1 U1.BB25
VCCPT_FLTR_FPGA_1.8V: C222.1 C223.1 C224.1 C225.1 C226.1 C227.1 C1879.1 C1880.1 C1881.1 L51.1 R15.2 U1.AA22 U1.AC22 U1.BY43 U1.BY47 U1.CB43 U1.CB47
VCCPT_FPGA_1.8V: C213.1 C214.1 C215.1 C216.1 C217.1 C218.1 C247.2 C248.2 C249.2 C250.2 C1094.1 C1095.1 C1096.1 C1097.1 C1098.1 C1099.1 C1100.1 C1101.1 C1102.1 C1103.1 C1104.1 C1627.1 L6.1 L42.1 L51.2 R643.1 TP172.1(TP) U1.AJ30 U1.AJ32 U1.AJ34 U1.AJ36 U1.BR30 U1.BR32 U1.BR34 U1.BR36 U58.A7 U58.A8 U58.A9 U58.A10 U58.B7 U58.B8 U58.B9 U58.B10 U58.B11 U58.B12 U58.C7 U58.C8 U58.C9 U58.D7 U58.K7 U58.K8 U58.K9 U58.K10 U58.K11 U58.L7 U58.L8 U58.L9 U58.L10 U58.L11 U58.L12 U58.M7 U58.M8 U58.M9 U58.M10
VCCRT_GXE_FPGA_0.9V: C166.1 C167.1 C168.1 C169.1 C170.1 C171.1 C172.1 C173.1 C175.1 C176.1 C177.1 C178.1 C179.1 C180.1 C181.2 C194.2 C195.1 C196.1 C212.1 C253.1 C339.1 C1316.1 C1317.1 C1318.1 L39.2 U1.AV15 U1.AW14 U1.AY15 U1.BA14 U1.BB15 U1.BC14 U1.BE14 U1.BG14 U1.BJ14 U1.BK15 U1.BL14 U1.BM15 U1.BN14 U1.BP15
VCCRT_GXP_FPGA_0.9V: C182.1 C183.1 C184.1 C185.1 C186.1 C187.1 C188.1 C189.1 C190.1 C191.1 C207.1 C208.1 C211.1 L2.2 U1.AM49 U1.AN48 U1.AP49 U1.AR48 U1.AT49 U1.AV49 U1.AY49 U1.BB49 U1.BC48 U1.BD49
VCCRTPLL_GXE_FPGA_0.9V: C161.1 C162.1 C350.1 C351.1 C352.1 L5.2 U1.BE16 U1.BG16
VDD_SODIMM: C328.1 C377.1 C387.1 C1427.1 C1428.1 C1429.1 C1430.1 C1431.1 C1432.1 C1433.1 C1434.1 C1435.1 C1436.1 C1437.1 C1438.1 C1439.1 C1440.1 C1441.1 C1442.1 C1443.1 C1444.1 C1445.1 C1446.1 C1447.1 C1448.1 C1609.1 C1610.1 C1611.1 C1774.1 C1840.1 C1931.1 C1951.2 CON1.111 CON1.112 CON1.117 CON1.118 CON1.123 CON1.124 CON1.129 CON1.130 CON1.135 CON1.136 CON1.141 CON1.142 CON1.147 CON1.148 CON1.153 CON1.154 CON1.159 CON1.160 CON1.163 R104.1 R109.2 R750.2 R1151.1 TP181.1(TP) U32.19 U67.2 V23.1
24M_XTALIN: C665.1 U21.5 Y1.1
24M_XTALOUT: C666.1 U21.4(XTALOUT) Y1.3
ADI_I2C_ALERTN: J35.6 R569.1 R654.1 R676.2 R927.2 R1131.1 SW6.3
ADI_I2C_ALERTN_R: R1131.2 R5458.1 U57.H11
ADI_I2C_SCL: J35.2 R564.1 R648.1 R673.1 R925.2 R1139.1 SW6.1 U53.J12 U57.J12 U58.J12 U59.E6
ADI_I2C_SDA: J35.4 R566.1 R647.1 R672.1 R926.2 R1138.1 SW6.2 U53.H10 U57.H10 U58.H10 U59.D6
AVST_CLK: R981.2 U1.H49
AVST_D0: U1.B47 U29.C17
AVST_D1: U1.D47 U29.E15
AVST_D2: U1.A48 U29.D15
AVST_D3: U1.C48 U29.C18
AVST_D4: U1.B49 U29.B18
AVST_D5: U1.D49 U29.G11
AVST_D6: U1.A50 U29.G12
AVST_D7: U1.C50 U29.D18
AVST_D8: U1.D51 U29.E16
AVST_D9: U1.A52 U29.D16
AVST_D10: U1.C52 U29.G16
AVST_D11: U1.F47 U29.F16
AVST_D12: U1.H47 U29.F15
AVST_D13: U1.G48 U29.G15
AVST_D14: U1.J48 U29.H11
AVST_D15: U1.F49 U29.H12
AVST_D16: U1.B55 U29.J16
AVST_D17: U1.D55 U29.H16
AVST_D18: U1.A56 U29.J15
AVST_D19: U1.C56 U29.H15
AVST_D20: U1.B57 U29.J11
AVST_D21: U1.D57 U29.J12
AVST_D22: U1.C58 U29.H17
AVST_D23: U1.D59 U29.G17
AVST_D24: U1.F61 U29.H18
AVST_D25: U1.H61 U29.G18
AVST_D26: U1.G54 U29.K18
AVST_D27: U1.J54 U29.J18
AVST_D28: U1.F55 U29.L17
AVST_D29: U1.H55 U29.K17
AVST_D30: U1.G56 U29.M17
AVST_D31: U1.J56 U29.L18
AVST_DATA_VALID: U1.B51 U29.E17
AVST_READY: U1.F57 U29.K12
BLASTER_DISN: J19.2 R341.1 U23.U18
CG1: U12.77
CG2: U12.78
CLEANER_GPIO0: J26.8 R453.1 U38.45 U79.C4
CLEANER_GPIO1: J26.9 R872.1 U38.24 U40.C1
CLEANER_GPIO2: J26.18 R873.1 U38.60 U40.C2
CLEANER_GPIO3: J26.4 R470.2 R911.1 U38.40 U40.C3
CLEANER_GPIO4: J26.6 R471.2 R912.1 U38.41 U40.C4
CLEANER_GPIO5: J26.3 R874.1 U38.12 U41.C1
CLEANER_GPIO6: J26.5 R875.1 U38.13 U41.C2
CLEANER_HW_CTRL: J26.12 R455.1 R910.1 U38.64
CLEANER_IN0_N: C860.2 R457.1 U38.2
CLEANER_IN0_P: C859.2 R457.2 U38.1
CLEANER_IN1_N: C863.2 R456.1 U38.15
CLEANER_IN1_P: C862.2 R456.2 U38.14
CLEANER_IN2_N: C868.2 R460.1 U38.11
CLEANER_IN2_P: C865.2 R460.2 U38.10
CLEANER_IN3: R464.1 R468.2 U38.5
CLEANER_INSEL00: J26.7 R887.1 U38.20 U42.C1
CLEANER_INSEL01: J26.1 R888.1 U38.17 U42.C2
CLEANER_INSEL10: J26.13 R889.1 U38.28 U42.C3
CLEANER_INSEL11: J26.15 R890.1 U38.29 U42.C4
CLEANER_OSC_EN: R476.2 R920.1 U39.1
CLEANER_SCL: J26.17 R883.1 U38.36 U41.C3
CLEANER_SDA: J26.19 R884.1 U38.35 U41.C4
CLEANER_STATUS0: J26.16 R885.2 R1062.1 U38.55 U79.C1
CLEANER_STATUS1: J26.14 R886.2 R1063.1 U38.56 U79.C2
CLEANER_VDDAPLL1: C910.1 C914.2 L29.2 U38.37
CLEANER_VDDAPLL2: C922.1 C923.2 L32.2 U38.49
CLEANER_VDDDIG: C916.1 C917.2 L30.2 U38.8
CLEANER_VDDIN0: C887.1 C888.2 L21.2 U38.3
CLEANER_VDDIN1: C893.1 C894.2 L23.2 U38.16
CLEANER_VDDIN2: C901.1 C902.2 L25.2 U38.9
CLEANER_VDDIN3: C907.1 C908.2 L27.2 U38.4
CLEANER_VDDO0: C889.2 C890.1 L22.2 U38.21
CLEANER_VDDO1: C897.2 C898.1 L24.2 U38.25
CLEANER_VDDO6: C919.2 C920.1 L31.2 U38.59
CLEANER_VDDO7: C927.2 C928.1 L33.2 U38.63
CLEANER_VDDO23: C903.2 C904.1 L26.2 U38.30
CLEANER_VDDO45: C911.2 C912.1 L28.2 U38.50
CLEANER_VDDTCXO: C925.1 C926.2 C1332.2 L34.2 L40.1 U38.19
CLEANER_VDDXO: C882.2 C931.1 C932.2 L20.1 L35.2 U38.42
CLEANER_XO_N: C1331.1 U38.44
CLEARNER_0_1HZ: R947.1 U38.22
CLEARNER_7_1HZ: R475.1 U38.62
CLEARNER_RECOVERY_N0: C860.1 U1.CY27
CLEARNER_RECOVERY_N1: C863.1 U1.CY29
CLEARNER_RECOVERY_N2: C868.1 J29.1
CLEARNER_RECOVERY_P0: C859.1 U1.DB27
CLEARNER_RECOVERY_P1: C862.1 U1.DB29
CLEARNER_RECOVERY_P2: C865.1 J27.1
CLEARNER_SYSTEM_N: C866.2 R37.2 R39.1 R41.1 R908.1 U1.CR24
CLEARNER_SYSTEM_P: C861.2 R37.1 R45.1 R47.1 R907.1 U1.CU24
CLK_50M_PWRMAX: R447.1 U23.M3
CLK_50M_SYSMAX: R441.1 U29.D10
CLKCLEANER_GPIO0: R999.1 U1.CF53 U79.A4
CLKCLEANER_GPIO1: R913.1 U1.CF57 U40.A1
CLKCLEANER_GPIO2: R914.1 U1.CH57 U40.A2
CLKCLEANER_GPIO3: R878.1 U1.CE56 U40.A3
CLKCLEANER_GPIO4: R879.1 U1.CG56 U40.A4
CLKCLEANER_GPIO5: R880.1 U1.CF55 U41.A1
CLKCLEANER_GPIO6: R881.1 U1.CH55 U41.A2
CLKCLEANER_INSEL00: R895.1 U1.CE52 U42.A1
CLKCLEANER_INSEL01: R896.1 U1.CG52 U42.A2
CLKCLEANER_INSEL10: R897.1 U1.CK57 U42.A3
CLKCLEANER_INSEL11: R898.1 U1.CM57 U42.A4
CLKCLEANER_IO_TSN: R479.1 R931.1 R1064.1 U29.F18 U40.B3 U41.B3 U42.B3
CLKCLEANER_SCL: R891.1 U1.CK55 U41.A3
CLKCLEANER_SDA: R892.1 U1.CE48 U41.A4
CLKCLEANER_STATUS0: R893.1 U1.CE54 U79.A1
CLKCLEANER_STATUS1: R894.1 U1.CG54 U79.A2
DAOUT0: C2118.2 R5875.1 U54.11
DDR4_COMP_A0: R1033.1 U1.T17 U3.P3 U4.P3 U5.P3 U6.P3 U7.P3
DDR4_COMP_A1: R1040.1 U1.V17 U3.P7 U4.P7 U5.P7 U6.P7 U7.P7
DDR4_COMP_A2: R1037.1 U1.U16 U3.R3 U4.R3 U5.R3 U6.R3 U7.R3
DDR4_COMP_A3: R1035.1 U1.W16 U3.N7 U4.N7 U5.N7 U6.N7 U7.N7
DDR4_COMP_A4: R1047.1 U1.T15 U3.N3 U4.N3 U5.N3 U6.N3 U7.N3
DDR4_COMP_A5: R1034.1 U1.V15 U3.P8 U4.P8 U5.P8 U6.P8 U7.P8
DDR4_COMP_A6: R1052.1 U1.U14 U3.P2 U4.P2 U5.P2 U6.P2 U7.P2
DDR4_COMP_A7: R1051.1 U1.W14 U3.R8 U4.R8 U5.R8 U6.R8 U7.R8
DDR4_COMP_A8: R1050.1 U1.T13 U3.R2 U4.R2 U5.R2 U6.R2 U7.R2
DDR4_COMP_A9: R1038.1 U1.V13 U3.R7 U4.R7 U5.R7 U6.R7 U7.R7
DDR4_COMP_A10: R1046.1 U1.U12 U3.M3 U4.M3 U5.M3 U6.M3 U7.M3
DDR4_COMP_A11: R1039.1 U1.W12 U3.T2 U4.T2 U5.T2 U6.T2 U7.T2
DDR4_COMP_A12: R1042.1 U1.P9 U3.M7 U4.M7 U5.M7 U6.M7 U7.M7
DDR4_COMP_A13: R1048.1 U1.L8 U3.T8 U4.T8 U5.T8 U6.T8 U7.T8
DDR4_COMP_A14: R1036.1 U1.N8 U3.L2 U4.L2 U5.L2 U6.L2 U7.L2
DDR4_COMP_A15: R1043.1 U1.M7 U3.M8 U4.M8 U5.M8 U6.M8 U7.M8
DDR4_COMP_A16: R1030.1 U1.P7 U3.L8 U4.L8 U5.L8 U6.L8 U7.L8
DDR4_COMP_ACTN: R1029.1 U1.N16 U3.L3 U4.L3 U5.L3 U6.L3 U7.L3
DDR4_COMP_ALERTN: R138.1 U1.L6 U3.P9 U4.P9 U5.P9 U6.P9 U7.P9
DDR4_COMP_BA0: R1041.1 U1.N6 U3.N2 U4.N2 U5.N2 U6.N2 U7.N2
DDR4_COMP_BA1: R1032.1 U1.M5 U3.N8 U4.N8 U5.N8 U6.N8 U7.N8
DDR4_COMP_BG0: R1031.1 U1.P5 U3.M2 U4.M2 U5.M2 U6.M2 U7.M2
DDR4_COMP_BG1: R137.1 R932.1 R933.1 R934.1 R935.1 R936.1 U1.M17 U3.M9 U4.M9 U5.M9 U6.M9 U7.M9
DDR4_COMP_CKE: R142.2 R144.1 U1.L14 U3.K2 U4.K2 U5.K2 U6.K2 U7.K2
DDR4_COMP_CLKN: R146.1 U1.P13 U3.K8 U4.K8 U5.K8 U6.K8 U7.K8
DDR4_COMP_CLKP: R145.1 U1.M13 U3.K7 U4.K7 U5.K7 U6.K7 U7.K7
DDR4_COMP_CSN: R1045.1 U1.L16 U3.L7 U4.L7 U5.L7 U6.L7 U7.L7
DDR4_COMP_DBIN0: U1.F7 U3.E7
DDR4_COMP_DBIN1: U1.B7 U3.E2
DDR4_COMP_DBIN2: U1.G14 U4.E7
DDR4_COMP_DBIN3: U1.A14 U4.E2
DDR4_COMP_DBIN4: U1.T21 U5.E7
DDR4_COMP_DBIN5: U1.M21 U5.E2
DDR4_COMP_DBIN6: U1.U28 U6.E7
DDR4_COMP_DBIN7: U1.L28 U6.E2
DDR4_COMP_DBIN8: U1.T7 U7.E7
DDR4_COMP_DQ0: U1.F9 U3.G2
DDR4_COMP_DQ1: U1.G6 U3.F7
DDR4_COMP_DQ2: U1.G10 U3.H3
DDR4_COMP_DQ3: U1.J6 U3.H7
DDR4_COMP_DQ4: U1.H9 U3.H2
DDR4_COMP_DQ5: U1.F5 U3.H8
DDR4_COMP_DQ6: U1.J10 U3.J3
DDR4_COMP_DQ7: U1.H5 U3.J7
DDR4_COMP_DQ8: U1.B9 U3.A3
DDR4_COMP_DQ9: U1.D5 U3.B8
DDR4_COMP_DQ10: U1.D9 U3.C3
DDR4_COMP_DQ11: U1.C6 U3.C7
DDR4_COMP_DQ12: U1.C10 U3.C2
DDR4_COMP_DQ13: U1.B5 U3.C8
DDR4_COMP_DQ14: U1.A10 U3.D3
DDR4_COMP_DQ15: U1.A6 U3.D7
DDR4_COMP_DQ16: U1.G16 U4.G2
DDR4_COMP_DQ17: U1.H13 U4.F7
DDR4_COMP_DQ18: U1.F17 U4.H3
DDR4_COMP_DQ19: U1.F13 U4.H7
DDR4_COMP_DQ20: U1.J16 U4.H2
DDR4_COMP_DQ21: U1.G12 U4.H8
DDR4_COMP_DQ22: U1.H17 U4.J3
DDR4_COMP_DQ23: U1.J12 U4.J7
DDR4_COMP_DQ24: U1.A16 U4.A3
DDR4_COMP_DQ25: U1.A12 U4.B8
DDR4_COMP_DQ26: U1.C16 U4.C3
DDR4_COMP_DQ27: U1.B13 U4.C7
DDR4_COMP_DQ28: U1.D17 U4.C2
DDR4_COMP_DQ29: U1.C12 U4.C8
DDR4_COMP_DQ30: U1.B17 U4.D3
DDR4_COMP_DQ31: U1.D13 U4.D7
DDR4_COMP_DQ32: U1.T23 U5.G2
DDR4_COMP_DQ33: U1.U20 U5.F7
DDR4_COMP_DQ34: U1.U24 U5.H3
DDR4_COMP_DQ35: U1.V19 U5.H7
DDR4_COMP_DQ36: U1.V23 U5.H2
DDR4_COMP_DQ37: U1.T19 U5.H8
DDR4_COMP_DQ38: U1.W24 U5.J3
DDR4_COMP_DQ39: U1.W20 U5.J7
DDR4_COMP_DQ40: U1.P23 U5.A3
DDR4_COMP_DQ41: U1.P19 U5.B8
DDR4_COMP_DQ42: U1.M23 U5.C3
DDR4_COMP_DQ43: U1.N20 U5.C7
DDR4_COMP_DQ44: U1.L24 U5.C2
DDR4_COMP_DQ45: U1.M19 U5.C8
DDR4_COMP_DQ46: U1.N24 U5.D3
DDR4_COMP_DQ47: U1.L20 U5.D7
DDR4_COMP_DQ48: U1.U30 U6.G2
DDR4_COMP_DQ49: U1.T27 U6.F7
DDR4_COMP_DQ50: U1.T31 U6.H3
DDR4_COMP_DQ51: U1.W26 U6.H7
DDR4_COMP_DQ52: U1.W30 U6.H2
DDR4_COMP_DQ53: U1.U26 U6.H8
DDR4_COMP_DQ54: U1.V31 U6.J3
DDR4_COMP_DQ55: U1.V27 U6.J7
DDR4_COMP_DQ56: U1.L30 U6.A3
DDR4_COMP_DQ57: U1.N26 U6.B8
DDR4_COMP_DQ58: U1.N30 U6.C3
DDR4_COMP_DQ59: U1.P27 U6.C7
DDR4_COMP_DQ60: U1.P31 U6.C2
DDR4_COMP_DQ61: U1.L26 U6.C8
DDR4_COMP_DQ62: U1.M31 U6.D3
DDR4_COMP_DQ63: U1.M27 U6.D7
DDR4_COMP_DQ64: U1.U10 U7.G2
DDR4_COMP_DQ65: U1.T5 U7.F7
DDR4_COMP_DQ66: U1.T9 U7.H3
DDR4_COMP_DQ67: U1.V5 U7.H7
DDR4_COMP_DQ68: U1.V9 U7.H2
DDR4_COMP_DQ69: U1.U6 U7.H8
DDR4_COMP_DQ70: U1.W10 U7.J3
DDR4_COMP_DQ71: U1.W6 U7.J7
DDR4_COMP_DQSN0: U1.J8 U3.F3
DDR4_COMP_DQSN1: U1.C8 U3.A7
DDR4_COMP_DQSN2: U1.H15 U4.F3
DDR4_COMP_DQSN3: U1.D15 U4.A7
DDR4_COMP_DQSN4: U1.W22 U5.F3
DDR4_COMP_DQSN5: U1.N22 U5.A7
DDR4_COMP_DQSN6: U1.V29 U6.F3
DDR4_COMP_DQSN7: U1.P29 U6.A7
DDR4_COMP_DQSN8: U1.W8 U7.F3
DDR4_COMP_DQSP0: U1.G8 U3.G3
DDR4_COMP_DQSP1: U1.A8 U3.B7
DDR4_COMP_DQSP2: U1.F15 U4.G3
DDR4_COMP_DQSP3: U1.B15 U4.B7
DDR4_COMP_DQSP4: U1.U22 U5.G3
DDR4_COMP_DQSP5: U1.L22 U5.B7
DDR4_COMP_DQSP6: U1.T29 U6.G3
DDR4_COMP_DQSP7: U1.M29 U6.B7
DDR4_COMP_DQSP8: U1.U8 U7.G3
DDR4_COMP_ODT: R1044.1 U1.M15 U3.K3 U4.K3 U5.K3 U6.K3 U7.K3
DDR4_COMP_PAR: R1049.1 U1.N12 U3.T3 U4.T3 U5.T3 U6.T3 U7.T3
DDR4_COMP_REFCLKN: C852.2 R64.2 R65.1 R66.1 R906.1 U1.N10
DDR4_COMP_REFCLKP: C853.2 R64.1 R67.1 R68.1 R905.1 U1.L10
DDR4_COMP_RESETN: R139.2 R140.2 U1.P17 U3.P1 U4.P1 U5.P1 U6.P1 U7.P1
DDR4_COMP_RZQ: R63.1 U1.M9
DDR4_COMP_TEN: R141.2 R143.1 U3.N9 U4.N9 U5.N9 U6.N9 U7.N9
DS1339_INTN: R508.2 U29.B8 U46.2
EN0_1.8V_R: R639.1 R640.1 R641.1 U58.F11 U58.G12
EN0_3.3V_R: R554.1 R555.1 R565.1 U53.F11 U53.G12
EN_1.2V: R791.2 U23.T1 U25.10
EN_1.8V: R770.2 U23.P2 U25.8
EN_2.5V: R779.2 U23.L7 U25.9
EN_3.3V: R555.2 U23.G6 U24.3
EN_12V: R537.2 R544.2 U23.D4 U24.2
EN_VCC_FPGA_VID: C1637.2 R1075.1 U23.B1 U24.4 U54.20
EN_VCCCLK_GXE_FPGA_2.5V: R732.2 U23.M1 U25.3
EN_VCCFUSEWR_SDM_FPGA_2.4V: R740.2 U23.K8 U25.4
EN_VCCH_FPGA_0.9V: R1141.1 U23.E5 U24.5
EN_VCCH_FPGA_0.9V_R: R1130.2 R1140.1 R1141.2 U57.F11 U57.G12
EN_VCCH_GXE_FPGA_1.1V: R701.2 U23.K2 U24.10
EN_VCCIO_FPGA_1.2V: R662.1 U23.F1 U24.7
EN_VCCIO_FPGA_1.5V: R722.2 U23.L1 U25.2
EN_VCCIO_FPGA_1.8V: R1014.2 U23.K4 U24.11
EN_VCCL_HPS_FPGA_0.9V: R680.2 U23.J2 U24.8
EN_VCCL_SDM_FPGA_0.8V: R693.2 U23.J6 U24.9
EN_VCCPT_FPGA_1.8V: R640.2 U23.G3 U24.6
EN_VDD_SODIMM: R754.2 U23.R3 U25.7
EN_VTT_DDR4_0.6V: R766.2 U23.N1 U25.5
EN_VTT_SODIMM_0.6V: R746.2 U23.M4 U25.6
ETH_INTN: R247.2 U1.CN56 U16.A3
ETH_IO_TSN: R251.1 R843.1 U16.B3 U29.A16
ETH_LED_LINK10: R267.1 U15.59 U15.76
ETH_LED_LINK100: R266.1 U15.74
ETH_LED_LINK1000: R265.1 U15.60 U15.73
ETH_LED_RX: R264.1 U15.58 U15.69
ETH_LED_TX: R263.1 U15.68
ETH_MDC: R246.2 U1.CL50 U16.A2
ETH_MDIO: R245.2 U1.CE46 U16.A1
ETH_RSET: R253.2 U15.30
ETH_RSTN: R248.2 U1.CL56 U16.A4
ETH_SGMII_RXN: C631.2 R23.2 R40.2 R42.1 U1.CF21
ETH_SGMII_RXP: C630.2 R23.1 R46.2 R48.1 U1.CH21
ETH_SGMII_TXN: C629.2 U1.CE22
ETH_SGMII_TXP: C628.2 U1.CG22
ETH_T_INTN: R243.2 U15.23 U16.C3
ETH_T_RSTN: R244.2 R1000.2 U15.28 U16.C4
ETH_T_SGMII_RXN: C631.1 U15.75
ETH_T_SGMII_RXP: C630.1 U15.77
ETH_T_SGMII_TXN: C629.1 U15.81
ETH_T_SGMII_TXP: C628.1 U15.82
ETH_XTAL_25MHZ: U15.55 X1.3
EXT_JTAG_TCK: J19.1 R353.2 R356.1 U23.N14
EXT_JTAG_TDI: J19.9 R349.1 U23.R16
EXT_JTAG_TDO: J19.3 U23.T16
EXT_JTAG_TMS: J19.5 R350.1 U23.P14
EXT_PROC_RSTN: J19.6 U23.M11
EXT_RESERVED: J19.8 R340.1 U23.M12
EXT_RESERVED1: J19.7 U23.T18
F2M_I2C_SCL: R380.1 U1.J38 U29.D14
F2M_I2C_SDA: R381.1 U1.J36 U29.E14
FAN_RPM: R401.1 U29.A4
FAULT: R6043.1 R6093.1 R6094.1 R6095.1 R6096.1 U54.18 U54.19
FAULT0_N: R5316.1 U53.G11
FAULT0_N_1: R5338.1 U58.G11
FAULT1_N: R5317.1 U53.H12
FAULT1_N_1: R5339.1 U58.H12
FLASH_DC0_IO0: J10.5 R961.2 U29.T3
FLASH_DC0_IO1: J10.6 R953.1 U29.M2
FLASH_DC0_IO2: J10.16 R957.1 U29.P2
FLASH_DC0_IO3: J10.17 R965.2 U29.P1
FLASH_DC0_IO4: J10.8 R954.1 U29.M3
FLASH_DC0_IO5: J10.9 R963.2 U29.N1
FLASH_DC0_IO6: J10.25 R966.2 U29.P3
FLASH_DC0_IO7: J10.21 R967.2 U29.R3
FLASH_DC0_IO8: J10.18 R958.1 U29.M1
FLASH_DC0_IO9: J10.20 R959.1 U29.N3
FLASH_DC0_IO10: J10.10 R955.1 U29.L7
FLASH_DC0_IO11: J10.11 R964.2 U29.K8
FLASH_DC0_IO12: J10.12 R956.1 U29.M4
FLASH_DC0_IO13: J10.13 R962.2 U29.L3
FLASH_DC0_IO14: J10.24 R960.1 U29.L8
FLASH_DC0_IO15: J10.26 U29.M7
FLASH_DC0_IO16: J10.28 U29.T1
FLASH_DC0_IO17: J10.29 U29.T2
FLASH_DC0_IO18: J10.30 U29.N4
FLASH_DC0_IO19: J10.31 U29.P4
FLASH_DC0_IO20: J10.32 U29.U1
FLASH_DC0_IO21: J10.33 U29.U2
FLASH_DC0_IO22: J10.34 U29.R4
FLASH_DC0_IO23: J10.37 U29.T4
FLASH_DC0_IO24: J10.38 U29.U3
FLASH_DC0_IO25: J10.41 U29.V2
FLASH_DC0_IO26: J10.42 U29.P6
FLASH_DC0_IO27: J10.43 U29.P5
FLASH_DC0_IO28: J10.44 U29.V3
FLASH_DC0_IO29: J10.45 U29.V4
FLASH_DC0_IO30: J10.46 U29.R5
FLASH_DC0_IO31: J10.47 U29.R6
FLASH_DC0_IO32: J10.48 U29.U5
FLASH_DC0_IO33: J10.50 U29.V5
FLASH_DC0_IO34: J10.51 U29.T5
FLASH_DC0_IO35: J10.52 U29.T6
FLASH_DC0_IO36: J10.53 U29.T7
FLASH_DC0_IO37: J10.54 U29.T8
FLASH_DC0_IO38: J10.56 U29.N7
FLASH_DC0_IO39: J10.57 U29.N8
FLASH_DC0_PRSNTN: R178.2 R180.1 R354.1 U23.R18 U29.D6
FLASH_DC0_RSTN: J10.55 R182.1 U29.U6
FLASH_DC1_IO0: J11.5 U29.P10
FLASH_DC1_IO1: J11.6 U29.N11
FLASH_DC1_IO2: J11.16 U29.U12
FLASH_DC1_IO3: J11.17 U29.U13
FLASH_DC1_IO4: J11.8 U29.M10
