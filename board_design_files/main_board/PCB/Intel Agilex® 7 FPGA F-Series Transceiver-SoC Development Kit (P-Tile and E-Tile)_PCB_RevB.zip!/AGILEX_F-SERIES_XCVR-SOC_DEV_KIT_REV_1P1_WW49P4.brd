# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_COMP_DQ59: length 41.8
  TOP w0.137: U6.C7 v2(121.23,142.52)
  ART05 w0.114: 108.75,118.3 108.75,117.69 108.44,117.39 arc(108.33,117.15) 108.38,116.9 arc(108.44,116.75) 108.46,116.6 arc(108.38,116.23) 108.17,115.91 v2(107.86,115.6)
  ART05 w0.135: v2(121.23,142.52) 120.83,142.11 120.83,140.72 121.05,140.49 122.24,140.49 122.37,140.35 122.37,140 122.27,139.9 121.61,139.9 121.43,139.72 121.43,139.44 121.57,139.3 122.24,139.3 122.37,139.17 122.37,138.9 122.24,138.76 121.57,138.76 121.43,138.63 121.43,138.36 121.57,138.22 122.24,138.22 122.4,138.06 122.4,137.74 122.24,137.58 120.3,137.58 120.16,137.45 120.16,137.18 120.3,137.04 121.33,137.04 121.46,136.91 121.46,136.5 121.36,136.4 120.52,136.4 120.29,136.17 120.29,135.66 120.01,135.38 119.44,135.38 119.3,135.25 119.3,134.34 110.34,125.37 110.34,120.78 109.81,120.26 109.81,119.37 108.75,118.3
DDR4_COMP_DQ60: length 45
  TOP w0.137: U6.C2 v2(125.23,142.52)
  ART05 w0.135: v2(125.23,142.52) 125.25,142.52 125.63,142.14 125.63,140.06 125.49,139.92 125.02,139.92 124.89,139.79 124.89,139.52 125.02,139.38 125.49,139.38 125.63,139.25 125.63,138.98 125.49,138.84 125.02,138.84 124.89,138.71 124.89,138.44 125.02,138.3 125.49,138.3 125.63,138.17 125.63,137.89 125.49,137.76 125.02,137.76 124.89,137.63 124.89,137.35 125.02,137.22 125.49,137.22 125.63,137.08 125.63,136.81 125.49,136.68 125.02,136.68 124.89,136.54 124.89,136.27 125.02,136.14 125.49,136.14 125.63,136 125.63,135.61 123.52,133.5 123.52,132.49 118.59,127.56 115.92,127.56 115.11,126.75 115.11,123.69 115.24,123.55 116.88,123.55 117.02,123.42 117.02,123.15 116.88,123.01 115.24,123.01 115.11,122.88 115.11,122.61 115.24,122.47 115.84,122.47 115.97,122.34 115.97,122.07 115.84,121.93 115.24,121.93 115.11,121.8 115.11,120.04 113.59,118.51 arc(113.53,118.43) 113.51,118.34 113.51,117.55 arc(113.38,117.23) 113.06,117.1 113.06,117.1 arc(112.81,117.03) 112.63,116.85 112.62,116.85 arc(112.44,116.67) 112.19,116.6 arc(111.94,116.53) 111.76,116.35 111.76,116.35 111.33,115.92 v2(111.33,115.6)
DDR4_COMP_DQ61: length 40.3
  TOP w0.137: U6.C8 v2(119.62,142.52)
  ART05 w0.135: v2(107,117.1) 106.55,117.54 106.55,118.24 106.91,118.59 107.11,118.59 107.74,119.23 107.74,121.26 109.09,122.6 109.09,126.26 117.26,134.43 117.26,139.69 117.12,139.83 116.51,139.83 116.38,139.96 116.38,140.23 116.51,140.37 117.12,140.37 117.26,140.5 117.26,145.1 117.39,145.24 118.15,145.24 118.29,145.1 118.29,142.27 118.42,142.14 119.25,142.14 v2(119.62,142.52)
DDR4_COMP_DQ62: length 44.5
  TOP w0.137: U6.D3 v2(123.62,143.32)
  ART05 w0.135: v2(111.33,116.6) 111.33,116.92 111.76,117.35 111.76,117.35 arc(111.94,117.53) 112.19,117.6 arc(112.44,117.67) 112.62,117.85 112.63,117.85 arc(112.68,117.97) 112.69,118.1 112.69,118.28 114.7,120.29 114.7,121.65 114.57,121.79 113.92,121.79 113.79,121.92 113.79,122.19 113.92,122.33 114.57,122.33 114.7,122.46 114.7,122.73 114.57,122.87 113.92,122.87 113.79,123 113.79,123.27 113.92,123.41 114.57,123.41 114.7,123.54 114.7,123.82 114.57,123.95 113.92,123.95 113.79,124.08 113.79,124.36 113.92,124.49 114.57,124.49 114.7,124.63 114.7,124.9 114.57,125.03 113.92,125.03 113.79,125.17 113.79,125.44 113.92,125.57 114.57,125.57 114.7,125.71 114.7,126.85 115.85,127.99 118.39,127.99 121.55,131.15 121.55,131.34 121.12,131.77 121.12,131.96 121.31,132.16 121.5,132.16 121.89,131.76 122.08,131.76 122.28,131.96 122.28,132.15 121.88,132.54 121.88,132.73 122.07,132.92 122.26,132.92 122.67,132.52 122.86,132.52 123.05,132.71 123.05,132.9 122.65,133.3 122.65,133.49 124.48,135.33 124.48,140.28 124.81,140.61 124.81,142.79 124.68,142.92 124.23,142.92 123.84,143.32 v2(123.62,143.32)
DDR4_COMP_DQ63: length 41.9
  TOP w0.137: U6.D7 v2(121.23,143.32)
  ART05 w0.114: 108.27,117.63 arc(108.26,117.51) 108.21,117.4 107.96,116.96 arc(107.89,116.78) v2(107.86,116.6)
  ART05 w0.135: 108.27,117.63 108.27,118.4 109.19,119.33 109.19,120.37 109.95,121.13 109.95,125.73 118.79,134.56 118.79,135.06 118.65,135.19 118.2,135.19 118.06,135.33 118.06,135.77 118.19,135.9 119.6,135.9 119.73,136.03 119.73,136.31 119.6,136.44 118.19,136.44 118.06,136.58 118.06,136.97 118.19,137.11 119.62,137.11 119.76,137.24 119.76,138.05 119.89,138.19 120.79,138.19 120.93,138.32 120.93,138.59 120.79,138.73 119.89,138.73 119.76,138.86 119.76,139.13 119.89,139.27 120.79,139.27 120.93,139.4 120.93,139.67 120.79,139.81 119.89,139.81 119.76,139.94 119.76,140.41 120.04,140.69 120.04,142.72 120.24,142.92 120.84,142.92 v2(121.23,143.32)
DDR4_COMP_DQ64: length 68.6
  TOP w0.137: U7.G2 v2(79.51,145.72)
  ART07 w0.114: 89.36,117.37 89.38,117.38 arc(89.71,117.5) 90.01,117.32 90.02,117.3
  ART07 w0.135: v2(93.14,114.1) 93.54,114.5 93.54,116.36 93.32,116.59 92.94,116.59 92.43,117.09 92.05,117.09 91.52,116.56 91.14,116.57 arc(91,116.67) 90.89,116.8 90.89,116.81 arc(90.74,116.95) 90.54,117 arc(90.24,117.08) 90.02,117.3 ; v2(79.51,145.72) 79.51,145.71 79.91,145.31 79.91,139.79 80.05,139.66 81.88,139.66 82.01,139.52 82.01,139.2 81.88,139.06 79.3,139.06 79.17,138.93 79.17,138.22 79.32,138.07 82.01,138.07 82.19,137.9 82.19,137.48 82.06,137.34 79.35,137.34 79.22,137.21 79.22,136.89 79.35,136.75 82.06,136.75 82.19,136.62 82.19,136.25 82.06,136.12 80.24,136.12 80.11,135.98 80.11,135.66 80.24,135.53 82.06,135.53 82.19,135.39 82.19,134.6 82.06,134.46 81.82,134.46 81.68,134.33 81.68,134 81.82,133.87 82.06,133.87 82.19,133.74 82.19,133.41 82.06,133.28 81.82,133.28 81.68,133.14 81.68,132.82 81.82,132.69 82.06,132.69 82.19,132.55 82.19,132.23 82.06,132.09 81.82,132.09 81.68,131.96 81.68,131.64 81.82,131.5 82.06,131.5 82.19,131.37 82.19,131.05 82.06,130.91 81.82,130.91 81.68,130.78 81.68,130.45 81.82,130.32 82.06,130.32 82.19,130.18 82.19,129.86 82.06,129.73 81.82,129.73 81.68,129.59 81.68,129.27 81.82,129.14 82.06,129.14 82.19,129 82.19,119.71 82.38,119.52 82.57,119.52 82.67,119.63 82.86,119.63 83.09,119.4 83.09,119.21 82.99,119.11 82.99,118.92 83.26,118.64 83.57,118.64 83.7,118.78 83.7,119.96 83.83,120.09 84.16,120.09 84.29,119.96 84.29,118.78 84.43,118.64 84.72,118.64 84.86,118.78 84.86,119.94 85.06,120.14 85.44,120.14 85.75,119.83 arc(85.79,119.78) 85.8,119.71 85.8,118.94 arc(85.82,118.84) 85.88,118.76 85.99,118.65 arc(86.03,118.63) 86.07,118.61 arc(86.35,118.52) 86.56,118.31 86.56,118.3 arc(86.78,118.08) 87.08,118 arc(87.28,117.95) 87.43,117.81 87.43,117.8 arc(87.65,117.59) 87.94,117.5 87.95,117.5 arc(88.15,117.45) 88.29,117.31 88.3,117.3 arc(88.51,117.08) 88.81,117 arc(89.09,117.08) 89.29,117.28 arc(89.33,117.33) 89.36,117.37
DDR4_COMP_DQ65: length 64
  TOP w0.137: U7.F7 v2(75.51,144.92)
  ART07 w0.135: v2(75.51,144.92) 75.99,144.43 75.99,143.92 75.79,143.71 72.62,143.71 71.93,143.02 71.93,142.83 72.61,142.15 72.61,141.96 72.39,141.73 72.2,141.73 71.51,142.42 71.32,142.42 71.09,142.19 71.09,142 71.78,141.31 71.78,141.12 71.55,140.89 71.36,140.89 70.67,141.58 70.48,141.58 69.82,140.92 69.82,140.58 69.96,140.45 71.47,140.45 71.6,140.31 71.6,139.99 71.47,139.86 69.96,139.86 69.82,139.72 69.82,139.36 69.96,139.23 70.72,139.23 70.86,139.09 70.86,138.77 70.72,138.64 69.96,138.64 69.82,138.5 69.82,137.91 69.96,137.77 70.72,137.77 70.86,137.64 70.86,137.32 70.72,137.18 69.96,137.18 69.82,137.05 69.82,136.72 69.96,136.59 70.72,136.59 70.86,136.45 70.86,136.13 70.72,136 69.96,136 69.82,135.86 69.82,135.54 69.96,135.41 70.72,135.41 70.86,135.27 70.86,134.95 70.72,134.81 69.96,134.81 69.82,134.68 69.82,134.36 69.96,134.22 70.72,134.22 70.86,134.09 70.86,133.76 70.72,133.63 69.96,133.63 69.82,133.5 69.82,133.11 69.96,132.97 70.2,132.97 70.33,132.84 70.33,132.52 70.11,132.29 70.11,132.1 75.16,127.05 75.16,124.23 75.38,124 75.97,124 78.1,121.87 78.1,119.73 78.48,119.35 78.99,119.35 83.28,115.06 85.57,115.06 85.95,114.68 86.33,114.68 86.84,114.17 87.35,114.17 87.78,114.6 v2(88.81,114.6)
DDR4_COMP_DQ66: length 67.7
  TOP w0.137: U7.H3 v2(77.9,146.52)
  ART07 w0.114: 87.55,116.38 87.68,116.5 87.95,116.5 arc(88.15,116.45) 88.29,116.31 88.3,116.3 arc(88.51,116.08) 88.81,116 88.82,116 arc(89.11,116.09) 89.33,116.3 89.33,116.31 arc(89.68,116.5) 90.03,116.31 90.03,116.3 arc(90.25,116.08) 90.54,116 arc(90.74,115.95) 90.89,115.81 90.89,115.8 arc(91.11,115.59) 91.4,115.5 91.41,115.5 arc(91.61,115.45) 91.76,115.31 91.76,115.3 arc(91.98,115.08) 92.28,115 arc(92.48,114.95) 92.62,114.81 92.63,114.8 arc(92.68,114.6) 92.63,114.4 92.62,114.39 arc(92.51,114.27) 92.35,114.2 92.28,114.28 v2(92.28,114.6)
  ART07 w0.135: v2(77.9,146.52) 78.31,146.11 78.31,140.67 77.06,139.42 76.67,139.42 75.98,138.73 75.98,137.5 75.84,137.36 75.52,137.36 75.38,137.5 75.38,138.92 75.25,139.06 74.93,139.06 74.79,138.92 74.79,137.5 74.66,137.36 74.34,137.36 74.2,137.5 74.2,138.92 74.07,139.06 73.8,139.06 73.23,138.48 73.23,138.12 73.36,137.99 73.68,137.99 73.81,137.85 73.81,137.53 73.68,137.4 73.36,137.4 73.23,137.26 73.23,134.8 75.61,132.41 75.61,130.83 78.02,128.43 78.21,128.43 78.43,128.66 78.63,128.66 78.85,128.43 78.85,128.24 78.62,128.01 78.62,127.82 80.13,126.32 81.04,126.32 81.18,126.18 81.18,125.86 81.04,125.72 80.22,125.72 80.08,125.59 80.08,125.27 80.22,125.13 81.04,125.13 81.18,125 81.18,124.67 81.04,124.54 80.22,124.54 80.08,124.4 80.08,124.08 80.22,123.95 81.04,123.95 81.18,123.81 81.18,123.49 81.04,123.36 80.22,123.36 80.08,123.22 80.08,122.9 80.22,122.76 81.04,122.76 81.18,122.63 81.18,122.31 81.04,122.17 80.22,122.17 80.08,122.04 80.08,121.72 80.22,121.58 81.04,121.58 81.18,121.45 81.18,121.12 81.04,120.99 80.22,120.99 80.08,120.85 80.08,120.53 80.22,120.4 81.04,120.4 81.18,120.26 81.18,119.33 83.41,117.09 85.57,117.09 86.08,116.59 86.46,116.59 86.88,116.17 87.34,116.17 87.55,116.38
DDR4_COMP_DQ67: length 64.4
  TOP w0.137: U7.H7 v2(75.51,146.52)
  ART07 w0.135: v2(75.51,146.52) 75.1,146.1 74.5,146.1 74.3,145.9 74.3,145.52 74.09,145.31 72.72,145.31 68.91,141.5 68.91,129.82 69.78,128.95 69.78,128.76 69.08,128.06 69.08,127.87 69.31,127.64 69.5,127.64 70.2,128.34 70.39,128.34 70.62,128.11 70.62,127.92 69.92,127.22 69.92,127.03 70.15,126.8 70.34,126.8 71.03,127.5 71.22,127.5 71.45,127.27 71.45,127.08 70.75,126.38 70.75,126.19 70.98,125.97 71.17,125.97 71.87,126.66 72.06,126.66 73.58,125.14 73.58,123.75 74.13,123.19 74.13,123 73.78,122.65 73.78,122.46 74.01,122.23 74.2,122.23 74.55,122.59 74.74,122.59 75.66,121.67 76.05,121.67 77.19,120.52 77.19,117.63 77.85,116.97 78.94,116.97 79.3,116.6 79.49,116.6 79.85,116.96 80.04,116.96 80.27,116.73 80.27,116.54 79.91,116.18 79.91,115.99 80.14,115.77 80.33,115.77 80.69,116.12 80.88,116.12 81.11,115.89 81.11,115.7 80.75,115.35 80.75,115.16 80.98,114.93 81.17,114.93 81.52,115.28 81.71,115.28 81.94,115.06 81.94,114.87 81.59,114.51 81.59,114.32 81.81,114.09 82.01,114.09 82.36,114.45 82.55,114.45 82.78,114.22 82.78,114.03 82.42,113.67 82.42,113.48 82.88,113.03 85.57,113.03 85.95,112.65 86.33,112.65 86.84,112.14 87.35,112.14 87.81,112.6 87.95,112.6 arc(88.1,112.63) 88.23,112.72 88.49,112.98 88.49,113.28 v2(88.81,113.6)
DDR4_COMP_DQ68: length 66.7
  TOP w0.137: U7.H2 v2(79.51,146.52)
  ART07 w0.114: v2(92.28,113.6) 92.28,113.92 92.36,114.01 arc(92.61,114.11) 92.79,114.3 arc(92.87,114.6) 92.79,114.9 arc(92.57,115.11) 92.28,115.2 92.28,115.2 arc(92.07,115.25) 91.93,115.39 91.92,115.4 arc(91.71,115.62) 91.41,115.7 arc(91.21,115.75) 91.06,115.89 91.06,115.9 arc(90.84,116.11) 90.55,116.2 90.54,116.2 arc(90.34,116.25) 90.19,116.39 90.19,116.4 arc(89.97,116.62) 89.68,116.7 89.67,116.7 arc(89.38,116.61) 89.16,116.4 89.16,116.39 arc(88.81,116.2) 88.46,116.39 88.46,116.4 arc(88.24,116.62) 87.95,116.7 87.74,116.7 87.61,116.82
  ART07 w0.135: v2(79.51,146.52) 79.1,146.1 79.1,140.74 78.69,140.33 78.69,140.02 78.55,139.89 78.24,139.89 78.1,139.75 78.1,139.43 78.24,139.29 78.55,139.29 78.69,139.16 78.69,138.78 78.55,138.65 76.81,138.65 76.68,138.51 76.68,138.19 76.81,138.06 78.55,138.06 78.69,137.92 78.69,137.6 78.55,137.46 76.89,137.46 76.76,137.33 76.76,137.01 76.89,136.87 78.55,136.87 78.69,136.74 78.69,136.44 78.55,136.31 77.3,136.31 77.16,136.17 77.16,134.72 77.33,134.56 77.86,134.56 77.99,134.69 77.99,135.68 78.13,135.81 78.45,135.81 78.59,135.68 78.59,134.78 78.72,134.64 79.04,134.64 79.18,134.78 79.18,135.68 79.31,135.81 79.63,135.81 79.77,135.68 79.77,134.65 79.9,134.52 81.14,134.52 81.28,134.38 81.28,128.76 81.14,128.63 79.96,128.63 79.83,128.49 79.83,128.17 79.96,128.03 81.52,128.03 81.66,127.9 81.66,127.58 81.52,127.44 80.47,127.44 80.34,127.31 80.34,126.99 80.47,126.85 81.52,126.85 81.66,126.72 81.66,119.43 82.83,118.26 arc(83.05,118.11) 83.31,118.06 arc(83.31,118.06) 83.32,118.06 83.58,118.06 83.71,117.92 83.71,117.53 83.85,117.4 84.17,117.4 84.3,117.53 84.3,117.92 84.44,118.06 85.57,118.06 arc(85.63,118.05) 85.69,118.01 85.96,117.74 arc(86.05,117.68) 86.15,117.65 86.3,117.63 arc(86.51,117.56) 86.67,117.4 86.68,117.39 arc(86.82,117.25) 87.02,117.2 87.03,117.2 arc(87.32,117.11) 87.54,116.9 87.61,116.82
DDR4_COMP_DQ69: length 65.6
  TOP w0.137: U7.H8 v2(73.9,146.52)
  ART07 w0.135: v2(89.68,114.1) 89.51,113.93 89.51,113.66 89.24,113.4 89.24,112.85 arc(89.31,112.6) 89.24,112.35 arc(89.06,112.17) 88.81,112.1 88.81,112.1 arc(88.56,112.03) 88.38,111.85 88.38,111.85 arc(88.19,111.67) 87.95,111.6 87.69,111.6 87.21,111.12 86.84,111.12 86.33,111.63 86.08,111.63 85.7,112.01 83.23,112.01 79.3,115.95 77.77,115.95 76.78,116.94 76.78,119.94 76.22,120.5 75.08,120.5 73.23,122.35 73.23,124.58 73.09,124.71 72.77,124.71 72.63,124.58 72.63,123.8 72.5,123.66 72.18,123.66 72.04,123.8 72.04,124.58 71.91,124.71 70.81,124.71 70.22,125.3 70.22,125.49 70.44,125.71 70.44,125.9 70.21,126.13 70.02,126.13 69.8,125.91 69.61,125.91 69.39,126.14 69.39,126.33 69.6,126.55 69.6,126.74 69.37,126.96 69.18,126.96 68.97,126.75 68.78,126.75 68.55,126.97 68.55,127.45 68.42,127.58 68.25,127.58 68.12,127.72 68.12,128.04 68.25,128.18 68.42,128.18 68.55,128.31 68.55,128.63 68.42,128.77 68.25,128.77 68.12,128.9 68.12,129.23 68.25,129.36 68.42,129.36 68.55,129.49 68.55,129.82 68.42,129.95 68.25,129.95 68.12,130.09 68.12,130.41 68.25,130.54 68.42,130.54 68.55,130.68 68.55,131 68.42,131.14 68.25,131.14 68.12,131.27 68.12,131.59 68.25,131.73 68.42,131.73 68.55,131.86 68.55,132.18 68.42,132.32 68.25,132.32 68.12,132.45 68.12,132.78 68.25,132.91 68.42,132.91 68.55,133.05 68.55,133.37 68.42,133.5 68.25,133.5 68.12,133.64 68.12,133.96 68.25,134.09 68.42,134.09 68.55,134.23 68.55,134.55 68.42,134.69 68.25,134.69 68.12,134.82 68.12,135.14 68.25,135.28 68.42,135.28 68.55,135.41 68.55,135.74 68.42,135.87 68.25,135.87 68.12,136 68.12,136.33 68.25,136.46 68.42,136.46 68.55,136.6 68.55,136.92 68.42,137.05 68.25,137.05 68.12,137.19 68.12,137.51 68.25,137.65 68.42,137.65 68.55,137.78 68.55,138.1 68.42,138.24 68.25,138.24 68.12,138.37 68.12,138.69 68.25,138.83 68.42,138.83 68.55,138.96 68.55,139.29 68.42,139.42 68.25,139.42 68.12,139.56 68.12,139.88 68.25,140.01 68.42,140.01 68.55,140.15 68.55,140.47 68.42,140.6 68.25,140.6 68.12,140.74 68.12,141.06 68.25,141.2 68.42,141.2 68.55,141.33 68.55,141.99 72.69,146.13 73.51,146.13 v2(73.9,146.52)
DDR4_COMP_DQ70: length 68.5
  TOP w0.137: U7.J3 v2(77.9,147.32)
  ART07 w0.114: 89.98,117.69 89.31,117.69
  ART07 w0.135: 89.98,117.69 90.3,118.01 90.88,118.01 91.29,117.6 91.67,117.6 92.07,118.01 92.53,118.01 92.99,117.55 93.37,117.55 93.83,117.09 94.08,117.09 94.46,116.71 94.46,114.3 94.21,114.05 93.83,114.05 93.14,113.36 v2(93.14,113.1) ; 89.31,117.69 88.84,118.15 88.57,118.15 88.11,118.62 87.73,118.62 87.22,119.13 86.97,119.13 86.64,119.45 86.64,120.37 86.44,120.57 86.03,120.57 85.49,121.11 85.19,121.11 84.76,120.67 82.88,120.67 82.67,120.88 82.67,121.33 82.81,121.46 84.06,121.46 84.2,121.6 84.2,121.92 84.06,122.05 82.81,122.05 82.67,122.19 82.67,122.51 82.81,122.65 84.06,122.65 84.2,122.78 84.2,123.1 84.06,123.24 82.81,123.24 82.67,123.37 82.67,123.7 82.81,123.83 84.06,123.83 84.2,123.97 84.2,124.29 84.06,124.42 82.81,124.42 82.67,124.56 82.67,139.9 82.32,140.26 80.91,140.26 80.77,140.39 80.77,140.66 80.91,140.79 81.4,140.79 81.53,140.93 81.53,141.25 81.4,141.38 80.91,141.38 80.77,141.52 80.77,141.84 80.91,141.98 81.88,141.98 82.01,142.11 82.01,142.43 81.88,142.57 80.91,142.57 80.77,142.7 80.77,143.03 80.91,143.16 81.88,143.16 82.01,143.29 82.01,143.62 81.88,143.75 80.91,143.75 80.77,143.89 80.77,144.21 80.91,144.34 81.88,144.34 82.01,144.48 82.01,144.8 81.88,144.94 80.91,144.94 80.77,145.07 80.77,145.39 80.91,145.53 81.88,145.53 82.01,145.66 82.01,145.98 81.88,146.12 80.91,146.12 80.77,146.25 80.77,146.58 80.42,146.94 78.28,146.94 v2(77.9,147.32)
DDR4_COMP_DQ71: length 66
  TOP w0.137: U7.J7 v2(75.51,147.32)
  ART07 w0.135: v2(75.51,147.32) 75.11,146.91 72.8,146.91 67.76,141.88 67.76,141.24 67.63,141.1 67.42,141.1 67.28,140.97 67.28,140.64 67.42,140.51 67.63,140.51 67.76,140.37 67.76,140.05 67.63,139.92 67.42,139.92 67.28,139.78 67.28,139.46 67.42,139.33 67.63,139.33 67.76,139.19 67.76,138.87 67.63,138.73 67.42,138.73 67.28,138.6 67.28,138.28 67.42,138.14 67.63,138.14 67.76,138.01 67.76,137.68 67.63,137.55 67.42,137.55 67.28,137.42 67.28,137.09 67.42,136.96 67.63,136.96 67.76,136.82 67.76,136.5 67.63,136.37 67.42,136.37 67.28,136.23 67.28,135.91 67.42,135.77 67.63,135.77 67.76,135.64 67.76,135.32 67.63,135.18 67.42,135.18 67.28,135.05 67.28,134.73 67.42,134.59 67.63,134.59 67.76,134.46 67.76,134.13 67.63,134 67.42,134 67.28,133.86 67.28,133.54 67.42,133.41 67.63,133.41 67.76,133.27 67.76,132.95 67.63,132.82 67.42,132.82 67.28,132.68 67.28,132.36 67.42,132.22 67.63,132.22 67.76,132.09 67.76,131.77 67.63,131.63 67.42,131.63 67.28,131.5 67.28,131.17 67.42,131.04 67.63,131.04 67.76,130.91 67.76,130.58 67.63,130.45 67.42,130.45 67.28,130.31 67.28,129.99 67.42,129.86 67.63,129.86 67.76,129.72 67.76,129.4 67.63,129.26 67.42,129.26 67.28,129.13 67.28,128.81 67.42,128.67 67.63,128.67 67.76,128.54 67.76,128.22 67.63,128.08 67.42,128.08 67.28,127.95 67.28,127.62 67.42,127.49 67.63,127.49 67.76,127.35 67.76,127.25 71.65,123.37 71.65,123.19 72.29,122.55 72.36,122.55 75.56,119.35 76.1,119.35 76.38,119.07 76.38,116.69 78.28,114.78 79.88,114.78 83.54,111.12 85.57,111.12 86.08,110.62 86.46,110.62 86.97,110.11 87.35,110.11 87.84,110.6 87.95,110.6 arc(88.19,110.67) 88.38,110.85 88.38,110.85 arc(88.56,111.03) 88.81,111.1 88.81,111.1 arc(89.06,111.17) 89.24,111.35 89.25,111.35 arc(89.43,111.53) 89.68,111.6 arc(89.93,111.67) 90.11,111.85 90.11,111.85 arc(90.18,112.1) 90.11,112.35 v2(89.68,113.1)
DDR4_COMP_DQSN0: length 35.4
  TOP w0.137: U3.F3 v2(89.33,144.92)
  ART07 w0.114: v2(91.41,118.1) 91.41,118.42 91.5,118.51 arc(91.74,118.61) 91.92,118.8 arc(92,119.1) 91.92,119.4 arc(91.87,119.6) 91.92,119.8 arc(92,120.1) 91.92,120.4 arc(91.87,120.6) 91.92,120.8 arc(92,121.1) 91.93,121.39 91.92,121.4 arc(91.87,121.6) 91.92,121.8 arc(91.98,121.95) 92,122.1 92,122.36 91.61,122.76
  ART07 w0.135: v2(89.33,144.92) 89.33,145.19 89.2,145.33 88.79,145.33 88.57,145.11 88.57,140.08 88.71,139.95 89.59,139.95 89.86,139.67 89.86,139.15 89.59,138.88 88.71,138.88 88.57,138.75 88.57,138.42 88.71,138.29 89.59,138.29 89.86,138.02 89.86,137.5 89.59,137.23 88.71,137.23 88.57,137.09 88.57,128.95 88.72,128.81 89.76,128.81 90.65,127.92 90.65,124.34 91.54,123.45 91.54,122.83 91.61,122.76
DDR4_COMP_DQSN1: length 28.8
  TOP w0.137: U3.A7 v2(86.94,140.92)
  ART05 w0.135: v2(91.41,121.1) 90.95,121.56 90.95,121.93 90.68,122.2 90.68,123.52 89.66,124.54 89.66,128.65 88.82,129.49 88.82,129.88 89.81,130.87 89.81,131.06 89.58,131.29 89.39,131.29 88.4,130.3 88.01,130.3 87.59,130.72 87.59,132.08 87.87,132.36 89.14,132.36 89.28,132.49 89.28,132.81 89.14,132.95 88.27,132.95 88,133.22 88,140.91 87.87,141.05 87.07,141.05 v2(86.94,140.92)
DDR4_COMP_DQSN2: length 34.4
  TOP w0.137: U4.F3 v2(100.76,144.92)
  ART07 w0.114: v2(97.47,118.6) 97.47,118.92 97.56,119.01 arc(97.81,119.11) 97.99,119.3 arc(98.07,119.6) 97.99,119.9 arc(97.93,120.1) 97.99,120.3 97.99,120.31 arc(98.07,120.6) 97.99,120.9 arc(97.93,121.1) 97.99,121.3 arc(98.07,121.6) 97.99,121.9 arc(97.94,121.96) 97.89,122.02 97.89,122.02 97.89,122.14
  ART07 w0.135: v2(100.76,144.92) 100.8,144.95 100.8,145.19 100.63,145.36 100.25,145.36 99.99,145.62 99.99,146.64 99.85,146.78 99.4,146.78 99.24,146.62 99.24,140.54 98.4,139.7 98.4,139.11 98.4,139.11 98.43,139.08 99.14,139.08 99.41,138.8 99.41,138.29 99.14,138.01 98.43,138.01 98.3,137.88 98.3,135.4 97.89,135 97.89,122.14
DDR4_COMP_DQSN3: length 32.3
  TOP w0.137: U4.A7 v2(98.37,140.92)
  ART05 w0.135: v2(98.37,140.92) 98.45,140.99 98.46,140.99 98.48,141.01 98.74,141.01 98.87,140.88 98.87,140.13 97.2,138.45 97.2,136.24 97.06,136.11 96.59,136.11 96.31,135.84 96.31,135.32 96.59,135.04 97.04,135.04 97.2,134.88 97.2,134.59 97.06,134.45 96.59,134.45 96.31,134.18 96.31,133.66 96.59,133.39 97.04,133.39 97.2,133.23 97.2,132.93 97.06,132.8 96.59,132.8 96.31,132.52 96.31,132 96.59,131.73 97.04,131.73 97.2,131.57 97.2,131.27 97.06,131.14 96.59,131.14 96.31,130.87 96.31,130.35 96.59,130.08 97.04,130.08 97.2,129.92 97.2,129.62 97.06,129.48 96.59,129.48 96.31,129.21 96.31,128.69 96.59,128.42 97.04,128.42 97.2,128.26 97.2,127.96 97.06,127.83 96.59,127.83 96.31,127.56 96.31,127.04 96.59,126.76 97.04,126.76 97.2,126.6 97.2,126.31 97.06,126.17 96.59,126.17 96.31,125.9 96.31,125.38 96.59,125.11 97.04,125.11 97.2,124.95 97.2,124.65 97.06,124.52 96.59,124.52 96.31,124.24 96.31,123.72 96.59,123.45 96.88,123.45 97.04,123.29 97.04,121.03 v2(97.47,120.6)
DDR4_COMP_DQSN4: length 43.5
  TOP w0.137: U5.F3 v2(112.19,144.92)
  ART07 w0.114: 103.99,117.7 103.99,117.69 103.99,117.6 arc(104.01,117.5) 104.05,117.4 arc(104.13,117.1) 104.05,116.8 arc(103.99,116.6) 104.05,116.4 arc(104.13,116.1) 104.05,115.8 arc(103.99,115.6) 104.05,115.4 arc(104.13,115.1) 104.05,114.8 arc(103.99,114.6) 104.05,114.4 arc(104.13,114.1) 104.05,113.8 arc(103.88,113.61) 103.64,113.52 arc(103.63,113.51) 103.62,113.51 103.53,113.42 v2(103.53,113.1)
  ART07 w0.135: 103.99,117.7 103.99,118.74 104.24,119 104.24,122.08 104.37,122.22 104.8,122.22 105.08,122.49 105.08,123.01 104.8,123.28 104.37,123.28 104.24,123.42 104.24,123.82 104.49,124.08 104.49,126.41 108.89,130.81 108.89,132.82 109.22,133.15 109.22,137.26 111.59,139.63 111.59,140.08 111.31,140.36 110.66,140.36 110.52,140.49 110.52,140.81 110.66,140.95 111.31,140.95 111.59,141.22 111.59,141.74 111.31,142.01 110.66,142.01 110.52,142.15 110.52,142.47 110.66,142.6 111.36,142.6 111.63,142.88 111.63,143.4 111.36,143.67 110.66,143.67 110.52,143.8 110.52,144.13 110.66,144.26 111.31,144.26 111.59,144.53 111.59,145.17 111.72,145.3 112.06,145.3 112.19,145.17 v2(112.19,144.92)
DDR4_COMP_DQSN5: length 41.8
  TOP w0.137: U5.A7 v2(109.8,140.92)
  ART05 w0.135: v2(103.53,116.1) 103.12,116.81 103.12,119.61 102.89,119.84 102.89,120.44 103.07,120.62 103.07,121.96 104.34,123.24 104.34,126.77 106.12,128.55 106.12,129.18 106.46,129.52 107.09,129.52 108.07,130.5 108.07,130.82 107.93,130.95 107.02,130.95 106.75,131.23 106.75,131.87 107.02,132.15 108.65,132.15 108.79,132.28 108.79,132.6 108.65,132.74 106.97,132.74 106.7,133.01 106.7,133.76 106.99,134.06 108.06,134.06 108.19,134.19 108.19,134.51 108.06,134.65 106.51,134.65 106.24,134.92 106.24,135.42 106.54,135.71 108.06,135.71 108.19,135.85 108.19,136.17 108.06,136.31 106.79,136.31 106.52,136.58 106.52,137.18 106.83,137.5 108.13,137.5 108.27,137.64 108.27,138.52 110.34,140.59 110.34,140.84 110.26,140.92 v2(109.8,140.92)
DDR4_COMP_DQSN6: length 56.8
  TOP w0.137: U6.F3 v2(123.62,144.92)
  ART07 w0.114: 110.95,117.86 110.95,117.83 110.92,117.81 110.92,117.46 110.98,117.41 110.98,117.4 arc(111.06,117.1) 110.98,116.8 arc(110.92,116.6) 110.98,116.4 arc(111.06,116.1) 110.98,115.8 arc(110.92,115.6) 110.98,115.4 arc(111.06,115.1) 110.98,114.8 arc(110.76,114.59) 110.47,114.5 110.46,114.5 arc(110.26,114.45) 110.11,114.31 110.11,114.3 arc(109.93,114.11) 109.68,114.01 109.6,113.92 v2(109.6,113.6)
  ART07 w0.135: v2(123.62,144.92) 123.66,144.95 123.66,145.19 123.52,145.33 123.2,145.33 122.63,145.9 122.44,145.9 121.97,145.43 121.97,145.24 122.3,144.91 122.3,144.44 122.43,144.3 122.91,144.3 123.19,144.03 123.19,143.51 122.91,143.24 122.43,143.24 122.3,143.1 122.3,142.78 122.43,142.65 122.91,142.65 123.19,142.37 123.19,141.86 122.91,141.58 122.43,141.58 122.3,141.45 122.3,140.62 122.43,140.48 123.3,140.48 123.58,140.21 123.58,139.69 123.3,139.42 122.61,139.42 122.48,139.28 122.48,138.96 122.61,138.83 123.25,138.83 123.53,138.55 123.53,138.04 123.25,137.76 122.61,137.76 122.48,137.63 122.48,136.9 122.61,136.76 123.24,136.76 123.52,136.49 123.52,135.97 123.24,135.7 122.61,135.7 122.29,135.37 122.29,134.92 123.23,133.98 123.23,133.6 122.86,133.23 122.48,133.23 121.53,134.17 121.34,134.17 121.12,133.94 121.12,133.75 122.06,132.81 122.06,132.42 121.69,132.06 121.31,132.06 120.36,133 119.3,133 118.99,133.3 118.8,133.3 118.57,133.08 118.57,132.89 119.12,132.34 119.12,131.95 113.75,126.57 113.75,124.7 113.15,124.1 112,124.1 111.21,123.3 111.21,119.76 110.95,119.5 110.95,117.86
DDR4_COMP_DQSN7: length 43.4
  TOP w0.137: U6.A7 v2(121.23,140.92)
  ART05 w0.114: v2(109.6,115.6) 109.5,115.69 arc(109.2,116.15) 109.09,116.69 109.09,116.85 arc(109.1,116.91) 109.11,116.97 arc(109.11,116.97) 109.12,116.98 arc(109.13,117.15) 109.08,117.3 arc(109,117.6) 109.08,117.9 arc(109.12,117.96) 109.17,118.02 109.29,118.13 109.29,118.16
  ART05 w0.135: v2(121.23,140.92) 121.44,141.12 121.77,141.12 122.17,141.52 122.17,146.04 122.3,146.18 122.7,146.18 122.85,146.03 122.85,137.21 110.86,125.22 110.86,119.74 109.29,118.16
DDR4_COMP_DQSN8: length 66.9
  TOP w0.137: U7.F3 v2(77.9,144.92)
  ART07 w0.114: v2(91.41,113.1) 91.41,113.42 91.5,113.51 arc(91.51,113.51) 91.52,113.52 arc(91.75,113.61) 91.92,113.8 arc(91.92,113.8) 91.92,113.8 arc(92,114.1) 91.92,114.4 arc(91.92,114.4) 91.92,114.4 arc(91.7,114.62) 91.41,114.7 arc(91.21,114.75) 91.06,114.89 91.06,114.9 arc(90.84,115.11) 90.55,115.2 90.54,115.2 arc(90.34,115.25) 90.19,115.39 90.19,115.4 arc(90.19,115.4) 90.19,115.4 arc(89.97,115.62) 89.68,115.7 89.67,115.7 arc(89.38,115.61) 89.16,115.4 89.16,115.39 arc(88.81,115.2) 88.46,115.39 88.46,115.4 arc(88.46,115.4) 88.46,115.4 arc(88.24,115.62) 87.95,115.7 87.94,115.7 arc(87.65,115.61) 87.43,115.4 87.43,115.39 arc(87.08,115.2) 86.73,115.39 86.73,115.4 arc(86.73,115.4) 86.72,115.4 arc(86.51,115.62) 86.21,115.7 arc(86.01,115.75) 85.87,115.89 85.86,115.9 arc(85.65,116.11) 85.35,116.2 85.1,116.2 85.06,116.23
  ART07 w0.135: v2(77.9,144.92) 77.96,144.97 77.96,145.18 77.82,145.31 77.46,145.31 77.29,145.14 77.29,141.22 75.76,139.69 73.6,139.69 72.46,138.55 71.77,138.55 71.53,138.31 71.53,137.26 71.75,137.04 72.39,137.04 72.68,136.74 72.68,136.15 72.41,135.88 71.85,135.88 71.64,135.67 71.64,135.64 71.63,135.64 71.63,135.4 71.85,135.18 72.41,135.18 72.68,134.91 72.68,134.43 72.36,134.11 71.84,134.11 71.69,133.96 71.69,133.47 71.8,133.36 72.71,133.36 73.05,133.02 73.05,132.51 72.72,132.18 72.1,132.18 71.84,131.92 71.84,131.45 72.26,131.02 72.95,131.02 73.86,131.93 74.35,131.93 74.81,131.46 74.81,131.02 73.74,129.95 73.74,129.74 74.45,129.04 74.64,129.04 75.23,129.62 75.64,129.62 76.11,129.16 76.11,128.71 75.56,128.16 75.56,127.97 76.66,126.87 76.66,124.63 76.88,124.41 77.14,124.41 77.33,124.6 77.33,126.55 77.75,126.97 78.36,126.97 79.4,125.94 79.4,120.34 83.51,116.23 85.06,116.23
DDR4_COMP_DQSP0: length 35.3
  TOP w0.137: U3.G3 v2(89.33,145.72)
  ART07 w0.114: v2(91.41,119.1) 91.41,118.78 91.48,118.7 arc(91.64,118.77) 91.76,118.89 91.76,118.9 arc(91.81,119.1) 91.76,119.3 arc(91.68,119.6) 91.76,119.9 arc(91.81,120.1) 91.76,120.3 91.76,120.31 arc(91.68,120.6) 91.76,120.9 arc(91.81,121.1) 91.76,121.3 arc(91.68,121.6) 91.76,121.9 arc(91.8,122) 91.81,122.1 91.81,122.25 91.48,122.59 91.45,122.59
  ART07 w0.135: v2(89.33,145.72) 89.18,145.56 88.69,145.56 88.34,145.21 88.34,139.98 88.61,139.71 89.49,139.71 89.63,139.57 89.63,139.25 89.49,139.12 88.61,139.12 88.34,138.84 88.34,138.33 88.61,138.05 89.49,138.05 89.63,137.92 89.63,137.6 89.49,137.46 88.61,137.46 88.34,137.19 88.34,128.85 88.62,128.57 89.66,128.57 90.41,127.82 90.41,124.24 91.3,123.35 91.3,122.73 91.45,122.59
DDR4_COMP_DQSP1: length 28.5
  TOP w0.137: U3.B7 v2(86.94,141.72)
  ART05 w0.135: v2(91.41,122.1) 91.11,122.1 90.91,122.3 90.91,122.6 91.01,122.7 91.01,123 90.91,123.1 90.91,123.62 89.9,124.63 89.9,128.75 89.05,129.59 89.05,129.78 90.05,130.77 90.05,131.16 89.68,131.53 89.3,131.53 88.3,130.53 88.11,130.53 87.83,130.81 87.83,131.99 87.97,132.12 89.24,132.12 89.51,132.39 89.51,132.91 89.24,133.18 88.37,133.18 88.24,133.32 88.24,141.01 87.96,141.28 87.24,141.28 87.07,141.45 87.07,141.59 v2(86.94,141.72)
DDR4_COMP_DQSP2: length 34.3
  TOP w0.137: U4.G3 v2(100.76,145.72)
  ART07 w0.114: v2(97.47,119.6) 97.47,119.28 97.55,119.2 arc(97.7,119.27) 97.82,119.39 97.82,119.4 arc(97.88,119.6) 97.82,119.8 arc(97.74,120.1) 97.82,120.4 arc(97.88,120.6) 97.82,120.8 arc(97.74,121.1) 97.82,121.39 97.82,121.4 arc(97.88,121.6) 97.82,121.8 arc(97.79,121.85) 97.76,121.89 97.68,121.97 97.68,122.14 97.68,122.14
  ART07 w0.135: v2(100.76,145.72) 100.64,145.59 100.35,145.59 100.23,145.72 100.23,146.74 99.95,147.01 99.3,147.01 99,146.72 99,140.64 98.06,139.7 98.06,139.11 98.33,138.84 99.04,138.84 99.18,138.71 99.18,138.38 99.04,138.25 98.33,138.25 98.06,137.98 98.06,135.5 97.65,135.09 97.65,127.03 97.68,127 97.68,122.14
DDR4_COMP_DQSP3: length 32
  TOP w0.137: U4.B7 v2(98.37,141.72)
  ART05 w0.135: v2(97.47,121.6) 97.43,121.6 97.28,121.75 97.28,122.15 97.38,122.25 97.38,122.55 97.28,122.65 97.28,123.39 96.98,123.69 96.69,123.69 96.55,123.82 96.55,124.15 96.69,124.28 97.16,124.28 97.43,124.55 97.43,125.05 97.13,125.34 96.69,125.34 96.55,125.48 96.55,125.8 96.69,125.94 97.16,125.94 97.43,126.21 97.43,126.7 97.13,127 96.69,127 96.55,127.13 96.55,127.46 96.69,127.59 97.16,127.59 97.43,127.86 97.43,128.36 97.13,128.66 96.69,128.66 96.55,128.79 96.55,129.11 96.69,129.25 97.16,129.25 97.43,129.52 97.43,130.01 97.13,130.31 96.69,130.31 96.55,130.45 96.55,130.77 96.69,130.9 97.16,130.9 97.43,131.18 97.43,131.67 97.13,131.97 96.69,131.97 96.55,132.1 96.55,132.43 96.69,132.56 97.16,132.56 97.43,132.83 97.43,133.33 97.13,133.62 96.69,133.62 96.55,133.76 96.55,134.08 96.69,134.22 97.16,134.22 97.43,134.49 97.43,134.98 97.13,135.28 96.69,135.28 96.55,135.42 96.55,135.74 96.69,135.87 97.16,135.87 97.43,136.15 97.43,138.35 99.11,140.03 99.11,140.98 98.84,141.25 98.57,141.25 98.37,141.45 v2(98.37,141.72)
DDR4_COMP_DQSP4: length 43.3
  TOP w0.137: U5.G3 v2(112.19,145.72)
  ART07 w0.114: 103.75,117.65 103.8,117.6 arc(103.82,117.45) 103.88,117.3 arc(103.94,117.1) 103.88,116.9 arc(103.8,116.6) 103.88,116.3 arc(103.94,116.1) 103.88,115.9 arc(103.8,115.6) 103.88,115.3 arc(103.94,115.1) 103.88,114.9 arc(103.8,114.6) 103.88,114.3 arc(103.94,114.1) 103.88,113.9 103.88,113.89 arc(103.77,113.77) 103.61,113.7 103.53,113.78 v2(103.53,114.1)
  ART07 w0.135: v2(112.19,145.72) 112.01,145.54 111.62,145.54 111.35,145.26 111.35,144.63 111.22,144.5 110.56,144.5 110.28,144.22 110.28,143.71 110.56,143.43 111.26,143.43 111.39,143.3 111.39,142.98 111.26,142.84 110.56,142.84 110.28,142.57 110.28,142.05 110.56,141.78 111.22,141.78 111.35,141.64 111.35,141.32 111.22,141.18 110.56,141.18 110.28,140.91 110.28,140.39 110.56,140.12 111.22,140.12 111.35,139.99 111.35,139.73 108.98,137.36 108.98,133.24 108.65,132.91 108.65,130.9 104.26,126.51 104.26,124.18 104,123.92 104,123.32 104.28,123.05 104.71,123.05 104.84,122.91 104.84,122.59 104.71,122.46 104.28,122.46 104,122.18 104,119.1 103.75,118.84 103.75,117.65
DDR4_COMP_DQSP5: length 41.6
  TOP w0.137: U5.B7 v2(109.8,141.72)
  ART05 w0.135: v2(103.53,117.1) 103.35,117.28 103.35,117.68 103.45,117.78 103.45,118.08 103.35,118.18 103.35,119.71 103.12,119.94 103.12,120.35 103.3,120.52 103.3,121.87 104.58,123.14 104.58,126.68 106.35,128.45 106.35,129.09 106.55,129.29 107.19,129.29 108.3,130.4 108.3,130.92 108.03,131.19 107.12,131.19 106.98,131.32 106.98,131.78 107.12,131.91 108.75,131.91 109.02,132.18 109.02,132.7 108.75,132.98 107.07,132.98 106.93,133.11 106.93,133.66 107.09,133.82 108.16,133.82 108.43,134.09 108.43,134.61 108.16,134.89 106.61,134.89 106.47,135.02 106.47,135.32 106.63,135.48 108.16,135.48 108.43,135.75 108.43,136.27 108.16,136.54 106.89,136.54 106.75,136.68 106.75,137.08 106.93,137.26 108.23,137.26 108.51,137.54 108.51,138.42 110.58,140.49 110.58,140.94 110.36,141.15 110.1,141.15 109.77,141.49 109.77,141.68 v2(109.8,141.72)
DDR4_COMP_DQSP6: length 56.6
  TOP w0.137: U6.G3 v2(123.62,145.72)
  ART07 w0.114: v2(109.6,114.6) 109.6,114.28 109.67,114.2 arc(109.83,114.27) 109.94,114.39 109.95,114.4 arc(110.16,114.62) 110.46,114.7 arc(110.66,114.75) 110.81,114.89 110.81,114.9 arc(110.87,115.1) 110.81,115.3 arc(110.73,115.6) 110.81,115.9 arc(110.87,116.1) 110.81,116.3 arc(110.73,116.6) 110.81,116.9 arc(110.87,117.1) 110.81,117.3 110.73,117.38 110.73,117.81 110.71,117.83 110.71,117.86
  ART07 w0.135: 110.71,117.86 110.71,119.6 110.97,119.86 110.97,123.4 111.91,124.33 113.05,124.33 113.51,124.79 113.51,126.67 118.89,132.05 118.89,132.24 118.34,132.79 118.34,133.17 118.71,133.54 119.09,133.54 119.39,133.24 120.46,133.24 121.4,132.29 121.59,132.29 121.82,132.52 121.82,132.71 120.88,133.66 120.88,134.04 121.25,134.41 121.63,134.41 122.58,133.46 122.77,133.46 122.99,133.69 122.99,133.88 122.05,134.83 122.05,135.47 122.51,135.93 123.15,135.93 123.28,136.07 123.28,136.39 123.15,136.53 122.51,136.53 122.24,136.8 122.24,137.73 122.51,138 123.15,138 123.29,138.13 123.29,138.46 123.15,138.59 122.51,138.59 122.24,138.86 122.24,139.38 122.51,139.65 123.21,139.65 123.34,139.79 123.34,140.11 123.21,140.25 122.34,140.25 122.06,140.52 122.06,141.55 122.34,141.82 122.82,141.82 122.95,141.95 122.95,142.28 122.82,142.41 122.34,142.41 122.06,142.68 122.06,143.2 122.34,143.48 122.82,143.48 122.95,143.61 122.95,143.93 122.82,144.07 122.34,144.07 122.06,144.34 122.06,144.81 121.73,145.14 121.73,145.52 122.34,146.13 122.73,146.13 123.3,145.56 123.47,145.56 v2(123.62,145.72)
DDR4_COMP_DQSP7: length 43.1
  TOP w0.137: U6.B7 v2(121.23,141.72)
  ART05 w0.114: 109.45,118 109.43,117.98 109.4,117.98 109.31,117.89 arc(109.19,117.65) 109.24,117.4 109.5,116.96 arc(109.53,116.91) 109.55,116.85 arc(109.58,116.73) v2(109.6,116.6)
  ART05 w0.135: v2(121.23,141.72) 121.23,141.58 121.46,141.36 121.67,141.36 121.93,141.62 121.93,146.14 122.2,146.41 122.8,146.41 123.09,146.13 123.09,137.11 111.1,125.12 111.1,121.45 111.2,121.36 111.2,121.05 111.1,120.95 111.1,120.65 111.2,120.55 111.2,120.24 111.1,120.14 111.1,119.64 109.45,118
DDR4_COMP_DQSP8: length 66.8
  TOP w0.137: U7.G3 v2(77.9,145.72)
  ART07 w0.114: v2(91.41,114.1) 91.41,113.78 91.48,113.7 arc(91.64,113.77) 91.76,113.89 91.76,113.9 arc(91.81,114.1) 91.76,114.3 91.76,114.31 arc(91.61,114.45) 91.41,114.5 91.4,114.5 arc(91.11,114.59) 90.89,114.8 90.89,114.81 arc(90.74,114.95) 90.54,115 arc(90.25,115.08) 90.03,115.3 arc(90.03,115.3) 90.03,115.3 90.03,115.31 arc(89.68,115.5) 89.33,115.31 89.33,115.3 arc(89.11,115.09) 88.82,115 88.81,115 arc(88.52,115.08) 88.3,115.3 arc(88.3,115.3) 88.3,115.3 88.29,115.31 arc(87.95,115.5) 87.6,115.31 87.59,115.3 arc(87.38,115.09) 87.08,115 87.08,115 arc(86.78,115.08) 86.57,115.3 arc(86.57,115.3) 86.56,115.3 86.56,115.31 arc(86.41,115.45) 86.21,115.5 86.21,115.5 arc(85.91,115.59) 85.7,115.8 85.7,115.81 arc(85.55,115.95) 85.35,116 85.06,116 85.05,115.99
  ART07 w0.135: 85.05,115.99 83.41,115.99 79.16,120.24 79.16,125.84 78.27,126.74 77.85,126.74 77.57,126.46 77.57,124.5 77.23,124.17 76.79,124.17 76.43,124.53 76.43,126.77 75.32,127.88 75.32,128.26 75.87,128.81 75.87,129.06 75.54,129.39 75.32,129.39 74.74,128.8 74.35,128.8 73.51,129.64 73.51,130.05 74.57,131.11 74.57,131.36 74.25,131.69 73.96,131.69 73.05,130.78 72.17,130.78 71.6,131.35 71.6,132.02 72,132.42 72.63,132.42 72.81,132.61 72.81,132.92 72.61,133.12 71.7,133.12 71.45,133.38 71.45,134.06 71.74,134.35 72.27,134.35 72.45,134.53 72.45,134.81 72.31,134.95 71.75,134.95 71.4,135.3 71.4,135.74 71.4,135.74 71.4,135.76 71.75,136.11 72.31,136.11 72.45,136.25 72.45,136.64 72.29,136.81 71.65,136.81 71.3,137.16 71.3,138.41 71.67,138.79 72.36,138.79 73.5,139.93 75.66,139.93 77.05,141.32 77.05,145.31 77.28,145.54 77.88,145.73 v2(77.9,145.72)
DDR4_COMP_ODT: length 134.3
  TOP w0.109: U3.K3 v2(90.14,148.92) ; U7.K3 v2(78.71,148.92) ; U6.K3 v2(124.43,148.92) ; U5.K3 v2(113,148.92) ; U4.K3 v2(101.57,148.92)
  TOP w0.175: R1044.1 v2(127.99,146.43)
  ART03 w0.165: v2(124.43,148.92) 124.83,148.52 125.95,148.52 126.82,147.65 126.82,147.23 127.62,146.43 v2(127.99,146.43)
  ART05 w0.114: v2(113,148.92) 113.84,148.08 115.37,148.08 115.48,147.97 115.48,147.66 115.6,147.55 115.94,147.55 116.05,147.66 116.05,147.97 116.17,148.08 116.52,148.08 116.64,147.97 116.64,147.84 116.75,147.73 117.1,147.73 117.21,147.84 117.21,147.97 117.32,148.08 118.95,148.08 119.3,147.73 120.9,147.73 121.16,147.98 124.15,147.98 124.37,148.2 124.37,148.45 124.43,148.51 v2(124.43,148.92) ; v2(97.47,116.6) 97.38,116.7 96.25,116.7 96.06,116.89
  ART05 w0.165: 96.06,116.89 95.86,117.09 95.6,117.09 95.1,117.6 94.71,117.6 94.23,118.08 93.85,118.08 93.44,117.68 92.86,117.68 92.43,118.11 92.12,118.11 91.62,118.62 91.29,118.62 90.83,119.08 90.45,119.08 89.96,119.56 89.48,119.56 89.05,119.13 88.52,119.13 88.13,119.51 88.12,119.51 88.12,119.51 87.87,119.51 87.5,119.88 87.5,120.7 arc(87.49,120.72) 87.48,120.73 87.41,120.85 arc(87.27,120.99) 87.07,121.04 86.94,121.04 86.65,121.33 86.65,122.36 84.47,124.55 84.47,124.79 84.24,125.02 84.24,125.5 84.23,125.5 84.23,131.41 83.23,132.42 82.99,132.42 82.31,131.74 82.08,131.74 81.87,131.94 81.87,132.18 82.55,132.86 82.55,133.09 82.35,133.3 82.11,133.3 81.79,132.97 81.55,132.97 81.35,133.18 81.35,133.41 81.67,133.74 81.67,133.97 81.47,134.18 81.23,134.18 80.91,133.85 80.67,133.85 80.47,134.06 80.47,134.29 80.79,134.62 80.79,134.85 80.59,135.06 80.35,135.06 80.03,134.73 79.79,134.73 79.59,134.94 79.59,135.17 79.91,135.5 79.91,135.73 79.71,135.94 79.47,135.94 79.15,135.61 78.91,135.61 78.71,135.82 78.71,136.05 79.03,136.38 79.03,136.61 78.83,136.82 78.59,136.82 78.27,136.49 78.03,136.49 77.83,136.7 77.83,136.93 78.15,137.26 78.15,137.49 77.94,137.7 77.71,137.7 77.39,137.37 77.15,137.37 76.95,137.58 76.95,137.81 77.27,138.14 77.27,138.37 76.83,138.81 76.83,139.39 76.66,139.56 75.65,139.56 75.48,139.39 75.48,137.93 75.32,137.77 75.02,137.77 74.86,137.93 74.86,139.39 74.69,139.56 74.4,139.56 74.24,139.39 74.24,137.93 74.07,137.77 73.78,137.77 73.61,137.93 73.61,139.39 73.45,139.56 73.09,139.56 72.92,139.72 72.92,140.01 73.09,140.18 76.66,140.18 76.83,140.34 76.83,147.52 77.35,148.03 77.35,148.19 77.63,148.48 78.26,148.48 v2(78.71,148.92)
  ART07 w0.114: v2(78.71,148.92) 79.08,149.29 81.41,149.29 81.63,149.52 81.97,149.52 82.09,149.4 82.09,149.39 82.2,149.28 82.54,149.28 82.66,149.39 82.66,149.4 82.77,149.52 83.12,149.52 83.23,149.4 83.23,149.39 83.34,149.28 83.97,149.28 84.28,148.97 85.46,148.97 85.61,149.12 85.66,149.12 85.98,149.44 87.44,149.44 87.55,149.55 87.55,149.75 87.63,149.83 88.08,149.83 88.16,149.75 88.16,149.54 88.26,149.44 88.53,149.44 88.97,148.99 88.97,148.48 89.09,148.37 89.66,148.37 90.14,148.84 v2(90.14,148.92) 90.52,149.3 92.3,149.3 92.42,149.41 92.42,149.57 92.53,149.68 92.88,149.68 92.99,149.57 92.99,149.41 93.1,149.3 93.45,149.3 93.56,149.41 93.56,149.74 93.68,149.86 94.02,149.86 94.13,149.74 94.13,149.41 94.25,149.3 94.28,149.3 95.12,148.46 96.16,148.46 96.49,148.79 96.85,148.79 97.36,149.3 97.74,149.3 98.07,149.63 100.18,149.63 100.51,149.3 101.19,149.3 v2(101.57,148.92) 101.95,149.3 103.52,149.3 103.63,149.41 103.63,149.64 103.74,149.76 104.09,149.76 104.2,149.64 104.2,149.41 104.32,149.3 104.66,149.3 104.77,149.41 104.77,149.62 104.89,149.73 105.23,149.73 105.34,149.62 105.34,149.41 105.46,149.3 105.86,149.3 106.74,148.42 107.55,148.42 107.97,148.85 108.38,148.85 108.84,149.3 109.16,149.3 109.23,149.37 109.26,149.37 109.54,149.66 110.76,149.66 111.12,149.3 112.62,149.3 v2(113,148.92)
DDR4_COMP_PAR: length 130.9
  TOP w0.109: U3.T3 v2(89.34,153.72) ; v2(112.06,153.83) 112.07,153.82 112.1,153.82 U5.T3 ; U6.T3 v2(123.63,153.72) ; U7.T3 v2(77.91,153.72) ; U4.T3 v2(100.77,153.72)
  TOP w0.175: R1049.1 v2(124.31,156.34)
  ART03 w0.165: v2(94.87,116.1) 94.87,115.71 95.49,115.1 96,115.1 96.16,115.27 96.16,122.5 94.43,124.23 93.6,124.23 89.2,128.62 89.2,130.2 87.01,132.39 87.01,132.62 87.77,133.38 87.77,133.61 87.56,133.82 87.33,133.82 86.57,133.06 86.34,133.06 86.13,133.27 86.13,133.5 86.89,134.26 86.89,134.49 86.68,134.7 86.45,134.7 85.69,133.94 85.46,133.94 85.25,134.15 85.25,134.38 86.01,135.14 86.01,135.37 85.8,135.58 85.57,135.58 84.81,134.82 84.58,134.82 84.37,135.03 84.37,135.26 85.13,136.02 85.13,136.25 84.92,136.46 84.69,136.46 83.93,135.7 83.7,135.7 83.49,135.91 83.49,136.14 84.25,136.9 84.25,137.13 84.04,137.34 83.81,137.34 83.05,136.58 82.82,136.58 82.61,136.79 82.61,137.02 83.37,137.78 83.37,138.01 83.16,138.22 82.93,138.22 82.17,137.46 81.94,137.46 81.73,137.67 81.73,137.9 82.49,138.66 82.49,138.89 81.46,139.93 81.02,139.93 80.86,139.76 80.86,139 80.69,138.84 80.4,138.84 80.24,139 80.24,139.76 80.07,139.93 79.29,139.93 79.11,140.1 79.11,149.82 79.34,150.04 79.74,150.04 79.93,150.24 79.93,150.62 79.65,150.9 79.42,150.9 78.35,151.97 78.35,152.3 78.14,152.51 78.02,152.51 78.02,152.52 77.78,152.52 77.47,152.82 77.47,153.34 77.85,153.72 v2(77.91,153.72)
  ART05 w0.114: v2(77.91,153.72) 77.91,154.36 78.75,155.21 80.44,155.71 80.51,155.85 80.49,155.94 80.57,156.08 80.89,156.18 81.04,156.1 81.06,156.02 81.2,155.94 83.28,156.56 85.54,156.56 87.67,155.39 v2(89.34,153.72) 89.34,154.36 90.42,155.45 91.69,155.83 91.76,155.97 91.72,156.1 91.8,156.24 92.13,156.34 92.27,156.26 92.31,156.13 92.45,156.06 92.8,156.16 97.71,156.16 99.1,155.39 v2(100.77,153.72) 101.17,154.13 101.7,154.13 102.25,154.68 102.25,154.69 103.61,156.05 103.62,156.05 103.65,156.08 104.1,156.08 104.24,156.22 104.24,156.3 104.36,156.41 104.7,156.41 104.82,156.3 104.82,156.2 104.93,156.08 105.25,156.08 105.39,156.22 105.39,156.32 105.5,156.44 105.84,156.44 105.96,156.32 105.96,156.2 106.07,156.08 109.81,156.08 v2(112.06,153.83) 112.12,153.83 112.29,154 112.29,154.56 112.83,155.1 113.37,155.38 115.98,155.91 116.07,156.05 116.06,156.12 116.15,156.25 116.48,156.32 116.62,156.23 116.63,156.16 116.77,156.07 117.18,156.15 118.48,156.15 122.55,155.38 123.45,154.47 v2(123.63,153.72)
  ART05 w0.165: v2(123.63,153.72) 124.03,154.12 124.03,156.06 v2(124.31,156.34)
DDR4_COMP_REFCLKN: length 50.7
  ART18 w0.094: v2(93.14,116.1) 93.14,116.43 93.21,116.49 arc(93.37,116.43) 93.48,116.3 93.49,116.3 arc(93.54,116.1) 93.49,115.9 arc(93.41,115.6) 93.49,115.3 arc(93.54,115.1) 93.49,114.9 arc(93.41,114.6) 93.49,114.3 arc(93.54,114.1) 93.49,113.9 arc(93.41,113.6) 93.49,113.3 arc(93.54,113.1) 93.49,112.9 93.48,112.9 arc(93.34,112.75) 93.14,112.7 93.13,112.7 arc(92.84,112.62) 92.62,112.4 92.62,112.4 arc(92.47,112.25) 92.28,112.2 92.27,112.2 arc(91.97,112.12) 91.75,111.9 arc(91.67,111.6) 91.75,111.3 arc(91.81,111.1) 91.75,110.9 arc(91.67,110.6) 91.75,110.3 arc(91.81,110.1) 91.75,109.9 91.75,109.9 arc(91.61,109.75) 91.41,109.7 91.41,109.7 arc(91.11,109.62) 90.89,109.4 90.89,109.4 arc(90.74,109.25) 90.54,109.2 90.54,109.2 arc(90.24,109.12) 90.02,108.9 90.02,108.9 arc(89.87,108.75) 89.68,108.7 89.67,108.7 arc(89.37,108.62) 89.16,108.4 89.15,108.4 arc(89.01,108.25) 88.81,108.2 arc(88.61,108.25) 88.47,108.4 88.47,108.4 arc(88.25,108.62) 87.95,108.7 87.95,108.7 arc(87.75,108.75) 87.6,108.9 87.6,108.9 arc(87.38,109.12) 87.08,109.2 87.08,109.2 arc(86.88,109.25) 86.74,109.4 86.73,109.4 arc(86.52,109.62) 86.22,109.7 86.21,109.7 arc(85.91,109.62) 85.69,109.4 85.69,109.4 arc(85.54,109.25) 85.35,109.2 85.34,109.2 arc(85.04,109.12) 84.83,108.9 arc(84.8,108.86) 84.76,108.82 84.32,108.37 84.32,107.86 84.21,107.76 84.21,107.44 84.32,107.34 84.32,107.09 84.04,106.81 83.87,106.81 83.75,106.69 83.75,106.52 83.58,106.35 83.34,106.35 83.23,106.46 83.04,106.46 82.94,106.35 82.75,106.35 82.64,106.46 82.45,106.46 82.35,106.35 82.16,106.35 82.05,106.46 81.87,106.46 81.76,106.35 81.57,106.35 81.46,106.46 81.28,106.46 81.17,106.35 80.98,106.35 80.87,106.46 80.69,106.46 80.58,106.35 79.98,106.35 79.88,106.46 79.69,106.46 79.58,106.35 77.85,106.35 77.49,106.7 71.89,106.7 v2(71.26,107.34) 71.26,106.8 71.16,106.7 70.36,106.7 68.93,108.13 62.66,108.13 59.99,110.79 57.82,110.79 57.72,110.89 v2(57.72,111.33)
  BOTTOM w0.089: v2(57.72,111.33) R66.1
DDR4_COMP_REFCLKP: length 50.6
  ART18 w0.094: v2(93.14,117.1) 93.14,116.77 93.22,116.7 arc(93.23,116.69) 93.24,116.69 arc(93.48,116.6) 93.66,116.41 arc(93.66,116.4) 93.66,116.4 arc(93.74,116.1) 93.66,115.8 arc(93.61,115.6) 93.66,115.4 arc(93.74,115.1) 93.66,114.8 arc(93.61,114.6) 93.66,114.4 arc(93.74,114.1) 93.66,113.8 arc(93.61,113.6) 93.66,113.4 arc(93.74,113.1) 93.66,112.8 arc(93.44,112.58) 93.14,112.5 93.14,112.5 arc(92.94,112.45) 92.8,112.3 92.8,112.3 arc(92.58,112.08) 92.28,112 92.28,112 arc(92.08,111.95) 91.93,111.8 91.93,111.8 arc(91.88,111.6) 91.93,111.4 arc(92.01,111.1) 91.93,110.8 arc(91.88,110.6) 91.93,110.4 arc(92.01,110.1) 91.93,109.8 arc(91.71,109.58) 91.41,109.5 91.41,109.5 arc(91.21,109.45) 91.07,109.3 91.06,109.3 arc(90.85,109.08) 90.55,109 90.54,109 arc(90.35,108.95) 90.2,108.8 90.2,108.8 arc(89.98,108.58) 89.68,108.5 89.68,108.5 arc(89.48,108.45) 89.33,108.3 89.33,108.3 arc(88.81,108) 88.29,108.3 88.29,108.3 arc(88.14,108.45) 87.95,108.5 87.94,108.5 arc(87.64,108.58) 87.42,108.8 87.42,108.8 arc(87.28,108.95) 87.08,109 87.08,109 arc(86.78,109.08) 86.56,109.3 86.56,109.3 arc(86.41,109.45) 86.21,109.5 arc(86.02,109.45) 85.87,109.3 85.87,109.3 arc(85.65,109.08) 85.35,109 85.35,109 arc(85.15,108.95) 85,108.8 85,108.8 arc(84.96,108.73) 84.91,108.67 84.52,108.29 84.52,107 83.66,106.15 77.76,106.15 77.41,106.5 71.92,106.5 v2(71.28,105.87) 71.26,105.87 71.26,106.41 71.16,106.5 70.27,106.5 68.85,107.92 62.58,107.92 59.91,110.59 57.82,110.59 57.72,110.5 v2(57.72,110.06)
  BOTTOM w0.089: v2(57.72,110.06) R68.1
DDR4_COMP_RESETN: length 110.6
  TOP w0.109: U6.P1 v2(126.03,152.12) ; v2(80.87,152.32) 80.51,152.32 U7.P1 ; U5.P1 v2(114.6,152.12)
  TOP w0.127: U3.P1 v2(91.74,152.12) ; U4.P1 v2(103.17,152.12)
  TOP w0.175: R140.2 v2(127.99,154.56)
  ART03 w0.165: v2(127.99,154.56) 126.59,153.16 126.59,152.68 v2(126.03,152.12) ; v2(80.87,152.32) 80.96,152.32 82.01,151.27 82.01,149.22 81.65,148.86 81.65,143.06 82.8,141.91 82.8,140.79 83.87,139.72 86.61,139.72 97.09,129.25 97.09,127.97 99.64,125.42 99.64,116.03 99.21,115.6 v2(99.2,115.6)
  ART05 w0.114: v2(80.87,152.32) 80.95,152.4 80.95,152.5 81.05,152.6 81.05,152.91 81.25,153.11 81.65,153.11 81.76,153 81.76,152.84 81.88,152.73 82.22,152.73 82.33,152.84 82.33,153 82.45,153.11 82.9,153.11 83.19,152.82 83.19,152.61 83.43,152.37 83.91,152.37 84.1,152.55 84.92,152.55 85.03,152.44 85.03,152.36 85.15,152.25 85.49,152.25 85.61,152.36 85.61,152.44 85.72,152.55 86.36,152.55 86.51,152.4 86.51,152.06 86.75,151.81 86.84,151.81 86.92,151.73 87.22,151.73 87.3,151.81 87.3,151.92 87.4,152.02 87.63,152.02 87.84,151.8 87.84,151.75 87.98,151.61 88.44,151.61 88.62,151.43 89.68,151.43 89.95,151.71 90.55,151.71 90.55,151.71 91.06,151.71 91.46,152.12 v2(91.74,152.12) 92.42,152.81 92.67,152.81 92.78,152.69 92.78,152.34 92.9,152.22 93.24,152.22 93.35,152.34 93.35,152.69 93.47,152.81 94.42,152.81 94.86,152.37 95.2,152.37 95.37,152.54 97.8,152.54 98.07,152.81 98.3,152.81 99.5,151.6 100.88,151.6 101.3,152.02 101.9,152.02 102.23,151.69 102.74,151.69 v2(103.17,152.12) 103.95,152.12 104.16,152.34 104.16,152.64 104.28,152.75 104.62,152.75 104.74,152.64 104.74,152.34 104.85,152.22 105.19,152.22 105.31,152.34 105.31,152.64 105.42,152.75 105.76,152.75 105.88,152.64 105.88,152.34 105.99,152.22 106.72,152.22 107.02,152.53 109.99,152.53 110.83,151.69 112.79,151.69 113.65,152.55 114.17,152.55 v2(114.6,152.12) 114.83,152.35 116.79,152.35 116.93,152.49 117.36,152.49 117.5,152.35 118.41,152.35 118.56,152.5 121.69,152.5 121.86,152.33 121.86,152.16 121.74,152.05 121.74,151.89 122.02,151.61 122.22,151.61 122.38,151.77 122.7,151.77 122.87,151.6 122.87,151.4 122.98,151.28 123.33,151.28 123.44,151.4 123.44,151.6 123.55,151.71 124.15,151.71 124.47,152.03 124.63,152.03 124.75,151.92 124.75,151.83 124.93,151.65 125.31,151.65 125.78,152.12 v2(126.03,152.12)
  BOTTOM w0.175: R140.2 v2(127.99,154.56)
DDR4_COMP_RZQ:
  vias: v2(92.28,116.6)
DDR4_COMP_TEN: length 67.6
  TOP w0.109: U4.N9 v2(96.77,150.52) ; U7.N9 v2(73.91,150.52) ; U6.N9 v2(119.63,150.52) ; v2(85.35,150.56) 85,150.92 U3.N9 ; U5.N9 v2(108.2,150.52)
  TOP w0.175: R143.1 v2(127.99,150.11)
  ART03 w0.165: v2(127.99,150.11) 127.99,150.11 127.11,150.11 127.09,150.14 126.62,150.14 126.59,150.11 120.34,150.11 v2(119.63,150.52)
  ART05 w0.114: v2(73.91,150.52) 74.06,150.52 74.06,150.52 74.96,150.52 75.21,150.78 75.52,150.78 75.64,150.9 76.14,150.9 76.29,150.75 78.06,150.75 78.75,151.45 80.06,151.45 80.14,151.52 80.63,151.52 80.7,151.45 81.56,151.45 81.67,151.57 81.67,151.88 81.79,151.99 82.61,151.99 82.73,151.88 82.73,151.67 82.94,151.45 83.14,151.45 83.14,151.45 83.76,151.45 83.88,151.34 83.88,151.07 83.99,150.95 84.33,150.95 84.45,151.07 84.45,151.34 84.56,151.45 84.84,151.45 84.95,151.34 84.95,150.97 v2(85.35,150.56) 85.7,150.91 87.51,150.91 87.7,150.73 88.61,150.73 88.98,151.09 89.71,151.09 89.87,150.93 90.73,150.93 91.5,151.7 91.96,151.7 92.15,151.89 94.76,151.89 95.73,150.93 96.14,150.93 96.54,150.52 v2(96.77,150.52)
  ART07 w0.114: v2(96.77,150.52) 96.97,150.52 97.38,150.93 98.96,150.93 99.16,150.72 99.79,150.72 99.97,150.9 99.97,151.28 100.38,151.69 103.68,151.69 103.79,151.8 103.79,152.08 103.9,152.2 104.25,152.2 104.36,152.08 104.36,151.8 104.48,151.69 104.99,151.69 106.22,150.46 106.77,150.46 107.31,151 107.47,151 107.95,150.52 v2(108.2,150.52) 108.49,150.52 108.9,150.93 109.93,150.93 110.72,151.71 110.96,151.71 111.07,151.83 111.07,151.88 111.19,151.99 111.53,151.99 111.64,151.88 111.64,151.83 111.76,151.71 114.88,151.71 115.24,152.07 115.48,152.07 115.59,151.95 115.59,151.55 115.71,151.43 116.05,151.43 116.16,151.55 116.16,151.95 116.28,152.07 116.9,152.07 118.08,150.89 118.97,150.89 118.97,150.88 118.98,150.88 119.34,150.52 v2(119.63,150.52)
  BOTTOM w0.175: R143.1 v2(127.99,150.11)
DS1339_INTN: length 134.2
  ART03 w0.114: v2(165.07,92.78) 165.44,92.4 166.04,92.4 166.27,92.17 166.27,86.67 164.45,84.85 164.45,81.32 164.59,81.18 168.73,81.18 172.31,77.6 179.22,77.6 181.07,75.74 182.73,75.74 184.38,74.09 192.89,74.09 194.77,72.21 194.77,66.5 194.28,66.01 194.28,59.44 194.43,59.28 194.43,42.07 188.15,35.79 179.02,35.79 175.54,39.27 151.17,39.27 v2(146.27,34.36)
  BOTTOM w0.109: U46.2 v2(146.27,34.36)
