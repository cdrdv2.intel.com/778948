# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 113.88,194.2 110.91,194.2 110.91,194.22 110.5,194.22 110.5,194.48 110.91,194.48 110.91,194.72 110.5,194.72 110.5,194.98 110.91,194.98 110.91,195.22 110.5,195.22 110.5,195.48 110.91,195.48 110.91,195.6 113.88,195.6
GND on TOP (solid shape): 118.6,195.48 119.01,195.48 119.01,195.22 118.6,195.22 118.6,194.98 119.01,194.98 119.01,194.72 118.6,194.72 118.6,194.48 119.01,194.48 119.01,194.22 118.6,194.22 118.6,194.2 115.63,194.2 115.63,195.6 118.6,195.6
GND on TOP (solid shape): 126.99,193.72 124.02,193.72 124.02,193.74 123.61,193.74 123.61,194 124.02,194 124.02,194.24 123.61,194.24 123.61,194.5 124.02,194.5 124.02,194.74 123.61,194.74 123.61,195 124.02,195 124.02,195.12 126.99,195.12
GND on TOP (solid shape): 131.71,195 132.12,195 132.12,194.74 131.71,194.74 131.71,194.5 132.12,194.5 132.12,194.24 131.71,194.24 131.71,194 132.12,194 132.12,193.74 131.71,193.74 131.71,193.72 128.74,193.72 128.74,195.12 131.71,195.12
GND on TOP (solid shape): 86.33,48.9 86.33,45.47 86.09,45.22 84.07,45.22 83.81,44.96 83.82,44.96 83.82,42.67 83.31,42.16 81.15,42.16 80.98,42.34 80.98,47.29 81.23,47.55 81.23,49.05 80.87,49.4 80.87,50.16 81.08,50.37 84.86,50.37
GND on TOP (solid shape): 204.11,185.6 204.11,184.28 203.84,184 202.18,184 202.06,184.12 202.06,185.79 202.09,185.87 202.18,185.89 202.23,185.88 202.29,185.88 202.42,185.9 202.55,185.95 203.76,185.95
GND on TOP (solid shape): outline of 146 points within 201.93,181.64 217.37,186.69
GND on TOP (solid shape): outline of 307 points within 186.26,127.8 217.37,148.87
GND on TOP (solid shape): outline of 446 points within 189.26,193.31 216.69,211.63
GND on TOP (solid shape): outline of 1013 points within 28.02,116.51 62.67,126.17
GND on BOTTOM (solid shape): 27.91,193.04 27.91,186.05 27.28,185.42 24.1,185.42 23.47,186.05 23.47,189.23 20.93,191.77 20.93,194.06 22.45,195.58 25.37,195.58
GND on BOTTOM (solid shape): 54.58,217.04 54.58,213.61 54.33,213.36 48.99,213.36 47.22,211.58 44.8,211.58 43.53,212.85 43.53,214.38 46.45,217.3 54.33,217.3
GND on BOTTOM (solid shape): 200.74,215.09 200.74,205.54 200.23,205.03 198.55,205.03 197.87,205.71 197.87,210.41 196.85,211.43 194.64,211.43 193.68,212.39 193.68,215.21 194.26,215.8 200.03,215.8
GND on BOTTOM (solid shape): 75.78,195.77 75.78,191.68 72.06,187.96 66.62,187.96 65.44,189.14 65.43,189.13 63.93,189.13 63.62,189.43 63.62,193.47 64.08,193.93 65.63,193.93 69.4,197.7 73.85,197.7
GND on BOTTOM (solid shape): 16.36,169.27 16.36,168.03 16.28,167.94 16.26,167.83 16.26,167.32 16.27,167.24 16.31,167.16 16.32,167.13 16.31,167.1 16.27,167.03 16.26,166.94 16.26,166.43 16.27,166.34 16.32,166.27 16.32,165.96 16.33,165.88 16.36,165.79 16.36,162.95 16.28,162.86 16.26,162.75 16.26,162.46 15.85,162.05 13.18,162.05 12.79,162.44 12.79,166.1 12.75,166.14 12.75,169.27 13.33,169.84 15.78,169.84
GND on BOTTOM (solid shape): 199.67,184.68 199.67,183.82 200,183.49 200.2,183.49 200.51,183.34 200.81,183.49 202.06,183.49 202.13,183.46 202.16,183.38 202.16,183.37 202.27,183.1 202.54,182.98 202.68,183.01 202.81,183.1 203.2,183.49 205.51,183.49 205.8,183.2 205.93,183.2 206.02,183.18 206.11,183.2 207.47,183.2 207.59,183.2 208.98,183.2 209.19,182.98 216.38,182.98 216.48,183.08 217.32,183.08 217.42,182.98 217.42,181.74 217.32,181.64 207.62,181.64 207.04,182.22 203.02,182.22 202.9,182.09 196.93,182.09 196.67,182.35 196.67,184.63 197.03,184.99 199.36,184.99
GND on BOTTOM (solid shape): outline of 226 points within 191.11,130.66 216.51,148.79
GND on BOTTOM (solid shape): outline of 232 points within 193.73,139.83 199.54,152.53
GND on BOTTOM (solid shape): outline of 736 points within 188.37,193.01 217.42,215.87
GND on BOTTOM (solid shape): outline of 1873 points within 18.16,7.57 31.65,21.44
GND on TOP: 51.94,42.93 52.6,42.27 52.6,26.24 51.21,24.84 45.72,24.84 45.29,25.27 45.29,25.78 44.37,26.7 42.65,26.7 42.27,27.08 42.27,31.52 41.59,32.19 41.59,34.96 41.63,35 43.64,35 44.53,34.11 44.53,32.82 45.45,31.89 45.45,27.48 46.01,26.92 48.41,26.92 48.97,27.48 48.97,31.61 49.21,31.85 49.21,33.78 49.59,34.16 50.93,34.16 51.26,34.49 51.26,36.27 51.41,36.42 51.41,39.4 51.21,39.6 50.22,39.6 48.84,40.97 41.83,40.97 41.07,40.21 41.07,39.9 40.64,39.47 37.59,39.47 37.39,39.67 37.39,42.16 37.67,42.44 38.94,42.44 39.42,42.93
GND on TOP: 161.93,10.97 161.26,10.31 144.22,10.31 143.38,11.15 143.38,19.43 144.6,20.65 150.52,20.65 151.19,21.32 153.9,21.32 153.95,21.27 153.95,19.71 153.57,19.33 153.57,19.3 152.73,18.47 151.89,18.47 150.57,17.14 146.56,17.14 146.51,17.2 145.92,17.2 145.31,16.59 145.31,14.17 145.85,13.64 149.96,13.64 150.1,13.5 152.98,13.5 153.16,13.32 153.16,11.94 153.44,11.66 158.37,11.66 158.6,11.89 158.6,12.88 159.94,14.22 159.94,21.46 159.38,22.02 159,22.02 158.47,22.56 158.47,25.3 158.57,25.4 161.75,25.4 161.93,25.22
GND on TOP: 43.59,16.51 43.59,11.91 43.36,11.68 41.15,11.68 41.07,11.61 36.65,11.61 36.4,11.35 36.4,10.26 36.83,9.83 40.03,9.83 40.28,9.58 45.54,9.58 45.75,9.78 45.75,11.61 45.42,11.94 44.93,11.94 44.93,12.67 45.42,12.67 45.75,13 45.75,13.92 45.49,14.17 45.11,14.17 44.91,14.38 44.91,16.54 44.68,16.76 43.84,16.76
GND on TOP: 12.27,147.68 13.72,146.23 13.72,138.53 14.61,137.64 24.13,137.64 24.94,138.46 24.94,140.08 24.79,140.23 16.87,140.23 16.15,140.94 16.15,141.33 15.88,141.6 15.42,141.6 15.16,141.86 15.16,146.48 15.54,146.86 15.77,146.86 16.08,147.17 16.08,148.77 16.48,149.17 16.48,149.99 15.44,151.03 15.44,153.59 16.13,154.28 18.69,154.28 19,153.97 19,150.42 19.3,150.11 22.35,150.11 23.16,150.93 23.16,155.22 22.43,155.96 12.55,155.96 12.27,155.68
GND on TOP: 192.38,2.54 189.84,2.54 189.2,3.17 189.2,21.59 189.84,22.22 192.38,22.22 193.01,21.59 193.01,9.19 193.57,8.63 193.57,6.1 193.57,6.1 193.01,5.54 193.01,3.17
GND on TOP: 165.23,192.69 166.5,191.42 166.5,187.66 166.67,187.48 167.11,187.48 167.64,188.01 173.89,188.01 174.98,186.92 174.98,180.72 174.5,180.24 174.5,166.4 174.5,166.4 174.5,165.71 173.61,164.82 136.5,164.82 135.38,165.94 135.38,189.3 138.78,192.69 ; 1 cut-out
GND on TOP: 143.46,146.51 143.31,146.35 142.47,146.35 142.37,146.46 142.37,147.7 142.62,147.96 142.62,151.43 142.6,151.46 143,151.87 148.59,151.87 148.83,151.63 148.83,150.62 150.95,148.5 150.95,146.25 150.39,145.69 149.58,145.69 148.92,146.35 146.61,146.35 146.53,146.28 145.08,146.28 144.86,146.51
GND on TOP: 34.67,40.77 35.33,40.11 35.33,24.28 34.21,23.16 26.09,23.16 24.99,24.26 24.99,29.36 24.32,30.04 24.32,32.8 24.36,32.84 26.37,32.84 27.25,31.95 27.25,30.66 28.21,29.71 28.21,25.06 28.63,24.64 31.57,24.64 32,25.07 32,27.53 31.7,27.84 31.7,29.45 31.93,29.69 31.93,31.62 32.32,32 33.66,32 33.99,32.33 33.99,34.11 34.14,34.26 34.14,37.03 33.73,37.44 32.94,37.44 31.57,38.81 24.56,38.81 23.8,38.05 23.8,37.54 23.57,37.31 20.32,37.31 20.12,37.52 20.12,40.01 20.4,40.28 21.67,40.28 22.15,40.77
GND on TOP: 38.71,194.18 72.11,194.18 73.12,193.17 73.12,188.34 71.47,186.69 59.28,186.69 59.03,186.94 59.03,190.25 58.39,190.88 49.12,190.88 48.36,190.12 48.36,186.69 46.05,184.38 39.7,184.38 38.2,182.88 30.1,182.88 27.68,185.29 20.42,185.29 19.78,185.93 19.78,189.86 27.53,189.86 27.91,189.48 27.91,187.96 29.69,186.18 34.52,186.18 34.52,185.55 34.64,185.42 37.06,185.42 37.67,186.03 38.2,186.03 38.2,187.48 37.95,187.48 37.95,193.42
GND on TOP: 47.85,96.21 47.85,101.35 47.6,101.6 42.9,101.6 42.64,101.35 42.64,100.85 42.63,100.79 42.63,100.74 42.63,100.69 42.64,100.63 42.64,98.45 42.63,98.39 42.63,98.34 42.63,98.29 42.64,98.23 42.64,96.05 42.63,95.99 42.63,95.94 42.63,95.89 42.64,95.83 42.64,95.53 42.44,95.33 42.44,95.3 42.39,95.25 41.15,95.25 40.89,95 40.89,92.25 41.37,91.77 42.44,91.77 42.64,91.57 42.64,91.25 42.63,91.19 42.63,91.14 42.63,91.09 42.64,91.03 42.64,88.85 42.63,88.79 42.63,88.74 42.63,88.69 42.64,88.63 42.64,86.45 42.64,86.45 42.83,85.96 43.34,85.96 44.71,85.96 44.78,85.96 44.84,85.98 47.34,85.98 47.85,86.49 47.85,93.43 50.77,93.43 50.77,92.2 51.53,91.44 51.53,84.2 51.15,83.82 47.6,83.82 46.1,85.32 46.1,85.41 42.34,85.41 42.34,85.34 39.22,85.34 36.55,88.01 36.55,99.06 39.47,101.98 41.63,101.98 42.52,102.87 49.73,102.87 50.77,101.83 50.77,100.76 49.12,99.11 49.12,96.65 48.44,95.96 48.11,95.96
GND on TOP: 206.35,5.97 206.6,5.71 207.36,5.71 207.62,5.97 207.62,6.6 207.74,6.73 208.51,6.73 208.89,6.35 208.89,2.79 208.63,2.54 204.06,2.54 203.81,2.79 203.81,4.7 204.82,5.71 204.82,7.49 206.35,7.49
GND on TOP: 102.26,197.41 95.73,197.41 94.64,198.5 94.64,201.68 96.06,203.1 96.06,205.16 97.31,206.4 102.23,206.4 103.02,205.61 103.02,198.17 ; 1 cut-out
GND on TOP: 15.09,43.81 17.93,40.97 17.93,27.61 17.04,26.72 8.69,26.72 7.59,27.81 7.59,32.41 6.92,33.08 6.92,35.85 6.96,35.89 8.97,35.89 9.86,35 9.86,33.71 10.78,32.78 10.78,28.45 11.39,27.84 13.74,27.84 14.61,28.7 14.61,30.58 14.3,30.89 14.3,32.31 14.54,32.54 14.54,34.66 14.92,35.05 16.26,35.05 16.59,35.38 16.59,37.16 16.71,37.29 16.71,40.31 16.54,40.49 15.54,40.49 14.17,41.86 7.16,41.86 6.4,41.1 6.4,40.79 5.97,40.36 2.92,40.36 2.72,40.56 2.72,43.05 3,43.33 4.27,43.33 4.75,43.81
GND on TOP: 35.96,154.69 54.96,154.69 56.36,156.08 59.54,156.08 61.31,154.3 61.31,151.84 59.97,150.49 58.57,150.49 57.81,151.26 29.34,151.26 28.73,151.87 28.73,155.12 29.26,155.65 35,155.65
GND on TOP: 56.01,100.23 51.25,100.23 51.03,100 51.03,98.93 51.2,98.75 56.36,98.75 56.36,99.87
GND on TOP: 62.36,146.23 62.36,140.46 62.23,140.34 61.21,140.34 60.78,140.77 59.36,140.77 58.19,141.94 57.58,141.94 56.77,141.12 54.99,141.12 54.84,140.97 54.84,140.03 55.14,139.73 60.15,139.73 60.78,139.09 60.78,133.05 60.91,132.92 63.91,132.92 64.08,133.1 64.08,146.18 63.91,146.35 62.48,146.35
GND on TOP: 42.82,78.23 61.57,78.23 61.95,77.85 61.95,72.8 60.88,71.73 58.34,71.73 58.27,71.8 58.27,76.83 57.88,77.22 47.34,77.22 46.96,76.83 46.96,70.89 46.53,70.46 45.25,70.46 44.84,70.04 44.84,69.89 44.8,69.85 44.8,68.68 44.9,68.57 44.9,67.46 45.18,67.18 46.89,67.18 46.96,67.11 46.96,61.72 47.22,61.47 57.88,61.47 58.27,61.85 58.27,67.21 58.6,67.54 61.44,67.54 61.95,67.03 61.95,61.09 61.31,60.45 45.69,60.45 44.8,61.34 42.16,61.34 41.42,62.08 41.42,76.83
GND on TOP: 65.3,66.62 67.67,66.62 67.92,66.37 67.92,64.85 67.39,64.31 65,64.31 64.59,64.72 64.59,65.91
GND on TOP: 209.88,158.09 208.97,157.18 208.97,149.94 208.86,149.83 203.25,149.83 202.36,150.72 202.36,157.56 201.45,158.47 201.45,162.97 201.98,163.5 209.63,163.5 209.88,163.25
GND on TOP: 75.97,173 72.29,173 72.16,172.87 72.16,172.34 72.14,172.31 72.14,171.98 70.26,171.98 69.95,172.29 69.95,174.09 69.49,174.55 68.86,174.55 68.71,174.7 68.71,175.16 68.48,175.39 67.61,175.39 67.44,175.21 67.44,171.78 68.54,170.68 68.54,166.55 68.95,166.14 74.52,166.14 76.4,168.02 76.4,172.57
GND on TOP: 129.51,196.93 125.55,196.93 125.35,197.13 125.35,197.49 124.03,198.81 123.04,198.81 121.41,200.43 121.41,202.72 122.17,203.48 122.17,204.93 123.16,205.92 123.19,205.92 123.67,206.4 129.01,206.4 130.28,205.13 130.28,197.69 ; 1 cut-out
GND on TOP: 207.15,170.08 202.95,170.08 202.69,170.33 202.69,170.48 202.39,170.79 201.55,170.79 201.54,170.8 201.54,173.34 202.08,173.89 202.08,179.37 202.08,180.14 203.2,181.25 215.87,181.25 216.18,180.95 216.18,179.81 216,179.63 213.69,179.63 213.49,179.83 210.49,179.83 209.45,178.79 209.45,174.9 209.87,174.49 209.87,170.14 209.5,169.77 207.45,169.77
GND on TOP: 216.79,114.96 195.96,114.96 195.55,115.37 195.55,117.07 196.09,117.6 216.84,117.6 217.37,117.07 217.37,115.54
GND on TOP: 31.65,139.29 30.66,139.29 30.61,139.34 30.61,140.89 30.84,141.12 31.52,141.12 31.62,141.02 31.62,139.8 31.7,139.73 31.7,139.34
GND on TOP: 55.98,96.7 51.2,96.7 50.98,96.47 50.98,95.4 51.15,95.22 56.34,95.22 56.34,96.34
GND on TOP: 115.95,197.43 113,197.43 112.67,197.76 110.11,197.76 108.33,199.54 108.33,201.57 109.7,202.95 109.7,205.89 110.24,206.43 115.93,206.43 116.71,205.64 116.71,198.2 ; 1 cut-out
GND on TOP: 89.28,206.12 89.28,198.07 89.2,197.99 84.45,197.99 83.9,198.55 83.9,199.06 82.6,199.06 81.81,199.85 81.81,206.04 82.35,206.58 88.82,206.58
GND on TOP: 55.58,217.3 68.55,217.3 69.01,216.84 69.01,216.08 68.35,215.42 68.35,212.47 68.33,212.45 68.33,208.79 67.84,208.31 61.34,208.31 60.76,208.89 60.76,212.29 59.82,213.23 55.5,213.23 55.24,213.49 55.24,216.97
GND on TOP: 113.92,11.05 113.26,10.39 96.22,10.39 95.38,11.23 95.38,19.51 96.6,20.73 102.51,20.73 103.19,21.4 105.96,21.4 105.99,21.36 105.99,19.35 105.11,18.47 103.81,18.47 102.57,17.22 98.55,17.22 98.5,17.27 97.71,17.27 97.26,16.81 97.26,14.68 98.22,13.72 100.69,13.72 100.99,14.02 102.6,14.02 102.84,13.79 104.77,13.79 105.16,13.4 105.16,12.06 105.49,11.73 107.26,11.73 107.57,11.43 110.36,11.43 110.59,11.66 110.59,12.78 111.96,14.15 111.96,21.16 111.2,21.92 110.9,21.92 110.46,22.35 110.46,25.4 110.67,25.6 113.16,25.6 113.44,25.32 113.44,24.05 113.92,23.57
GND on TOP: 67.77,73.96 63.63,73.96 63.17,74.42 63.17,75.69 63.96,76.48 65.68,76.48 67.08,75.08 67.87,75.08 67.87,74.07
GND on TOP: 106.73,106.4 107.65,106.4 108.18,105.87 108.18,97.36 107.7,96.88 106.86,96.88 106.76,96.98 106.76,106.38
GND on TOP: 82.3,155.96 113.67,155.96 119.25,161.54 134.11,161.54 134.49,161.93 134.49,189.87 136.4,191.77 136.4,211.2 134.79,212.81 134.79,215.4 132.46,217.73 86.08,217.73 82.63,214.27 82.63,209.27 78.31,204.95 78.31,202.16 77.55,201.4 77.55,194.69 80.39,191.85 80.39,157.86 ; 6 cut-outs
GND on TOP: 57.35,41.55 55.12,41.55 54.64,42.04 54.64,45.52 53.92,46.23 51.41,46.23 50.98,46.66 50.98,48.59 51.28,48.9 55.6,48.9 57.58,50.88 61.54,50.88 61.65,50.77 61.65,49.66 61.54,49.56 59.49,49.56 59.33,49.4 59.33,48.59 59.08,48.34 58.22,48.34 58.04,48.51 58.04,49.02 57.86,49.2 57.07,49.2 56.82,48.95 56.82,46.63 57.45,46 57.45,41.66
GND on TOP: 138.68,10.92 138.02,10.26 120.98,10.26 120.14,11.1 120.14,19.38 121.36,20.6 127.28,20.6 128.32,21.64 130.56,21.64 130.71,21.49 130.71,19.76 130.56,19.61 130,19.61 129.69,19.3 129.69,18.64 129.54,18.49 128.6,18.49 127.2,17.09 123.32,17.09 123.11,17.3 122.33,17.3 121.97,16.94 121.97,14.17 122.56,13.59 127.53,13.59 128.63,12.5 129.67,12.5 129.92,12.24 129.92,11.96 130.25,11.63 134.92,11.63 135.36,12.06 135.36,12.83 136.6,14.07 136.6,14.12 136.7,14.22 136.7,20.17 135.23,21.64 135.23,24.94 135.24,24.96 135.24,25.54 135.46,25.76 138.46,25.76 138.68,25.53
GND on TOP: 182.5,208.79 182.25,209.04 178.61,209.04 178.41,208.84 178.41,206.32 179.98,204.75 179.98,203.71 179.65,203.38 179.25,203.38 179.04,203.17 179.04,202.31 179.3,202.06 179.96,202.06 180.11,201.9 180.11,200.05 180.47,199.69 181.03,199.69 181.25,199.92 181.25,204.57 182.5,205.82
GND on TOP: 116.69,107.49 118.11,107.49 119.38,106.22 119.38,96.98 118.24,95.83 116.51,95.83 115.42,96.93 115.42,106.22
GND on TOP: 90.4,25.5 93.47,25.5 93.73,25.25 93.73,11.35 93.07,10.69 76.02,10.69 75.18,11.53 75.18,19.81 76.4,21.03 82.32,21.03 82.99,21.7 85.76,21.7 85.93,21.54 85.93,19.56 85.55,19.18 85.32,19.18 85.09,18.95 85.09,18.57 84.89,18.36 83.21,18.36 82.37,17.53 78.36,17.53 78.31,17.58 77.77,17.58 77.27,17.07 77.27,14.78 78.03,14.02 81.76,14.02 81.9,13.88 84.79,13.88 84.96,13.7 84.96,11.96 85.19,11.73 90.17,11.73 90.4,11.96 90.4,13.26 91.57,14.43 91.57,20.24 91.29,20.52 91.29,21.06 90.27,22.07 90.27,25.37
GND on TOP: 19.28,188.72 19.28,185.04 19.15,184.91 17.12,184.91 16.99,185.04 16.99,188.72 17.12,188.85 19.15,188.85
GND on TOP, BOTTOM: 41.25,213.36 13.31,213.36 12.67,213.99 12.67,216.79 13.31,217.42 40.87,217.42 41.5,216.79 41.5,213.61
GND on BOTTOM: 156.82,12.5 156.82,11.94 157.12,11.63 160.38,11.63 161.04,12.29 161.04,17.42 160.83,17.63 159.59,17.63 159.38,17.42 159.38,13.92 158.98,13.51 157.4,13.51 156.95,13.06 156.95,12.62
GND on BOTTOM: 155.83,124.71 155.83,118.49 156.97,118.49 157.1,118.62 157.1,124.84 156.08,125.86 156.08,127.76 155.83,128.02 153.42,128.02 152.91,127.51 149.15,127.51 149.15,126.49 154.43,126.49 154.81,126.11 154.81,125.73
GND on BOTTOM: 75.64,96.44 77.24,96.44 77.52,96.16 77.52,94.87 77.14,94.49 75.74,94.49 75.46,94.77 75.46,96.27
GND on BOTTOM: 180.54,98.81 180.47,98.73 180.47,97.26 180.47,97.25 180.47,95.53 180.44,95.5 180.64,95.3 181.25,95.3 181.74,95.78 181.74,106.6 181.66,106.68 180.62,106.68 180.54,106.6
GND on BOTTOM: 182.93,134.24 182.93,130 179.83,130 178.99,130.83 178.99,134.31 179,134.33 179,139.61 179.55,140.16 182.73,140.16 183.11,139.78 183.11,134.42
GND on BOTTOM: 51.61,169.54 52.42,170.36 52.42,175.59 51.86,176.15 51,176.15 50.59,175.74 50.59,174.78 50.06,174.24 50.06,172.19 49.91,172.03 48.87,172.03 48.36,172.54 47.42,172.54 47.42,169.85 47.72,169.54
GND on BOTTOM: 21.56,179.7 27.4,179.7 28.29,178.82 28.29,173.99 27.4,173.1 21.31,173.1 20.93,173.48 20.93,179.07
GND on BOTTOM: 187.42,95.88 185.52,93.98 184.38,93.98 184.12,93.73 184.12,93.09 184.25,92.96 189.84,92.96 190.22,93.34 190.22,94.11 189.96,94.36 189.96,95.63 189.71,95.88
GND on BOTTOM: 115.49,197.89 109.02,197.89 108.71,198.2 108.71,200.99 110.52,202.79 110.52,205.84 111.33,206.65 115.24,206.65 116.74,205.16 116.74,199.14
GND on BOTTOM: 92.96,16.48 92.96,12.52 92.23,11.79 90.6,11.79 90.59,11.8 89.09,11.8 88.54,12.34 88.54,13.23 88.65,13.34 91.08,13.34 91.72,13.97 91.72,16.54 91.8,16.61 92.84,16.61
GND on BOTTOM: 96.22,206.45 96.22,203.25 94.84,201.88 94.84,197.94 95.1,197.69 96.22,197.69 96.34,197.82 101.73,197.82 102.87,198.96 102.87,206.02 102.13,206.76 96.52,206.76
GND on BOTTOM: 82.27,20.52 83.36,21.62 84.73,21.62 85.04,21.31 85.04,11.38 84.53,10.87 77.34,10.87 76.61,11.61 76.61,20.07 77.06,20.52
GND on BOTTOM: 64.57,68.12 66.01,68.12 67.28,66.85 67.28,65.74 65.74,64.19 65.18,64.19 64.57,64.8
GND on BOTTOM: 42.62,31.29 41.43,32.49 41.43,33.78 41.61,33.96 50.55,33.96 51.46,33.05 51.46,31.75 52.1,31.11 52.1,27.25 51.66,26.82 43.28,26.82 42.62,27.48
GND on BOTTOM: 128.14,75.89 121.59,75.89 121.49,75.79 121.49,74.29 121.77,74.01 128.04,74.01 128.29,74.27 128.29,75.74
GND on BOTTOM: 179.3,60.58 181.58,60.58 181.96,60.2 187.68,60.2 188.06,59.82 188.06,51.82 187.93,51.69 187.17,51.69 186.79,52.07 179.55,52.07 179.04,52.58 179.04,60.32
GND on BOTTOM: 43.46,15.01 43.46,11.66 43,11.2 43,9.83 43.33,9.5 45.39,9.5 45.8,9.91 45.8,13.69 45.24,14.25 44.98,14.25 44.73,14.5 44.73,15.09 44.65,15.16 43.61,15.16
GND on BOTTOM: 36.17,92.89 42.49,92.89 42.75,92.63 42.75,88.65 41.98,87.88 34.01,87.88 33.75,88.14 33.75,89.2 33.93,89.38 35.1,89.38 35.23,89.25 36.7,89.25 36.88,89.43 36.88,91.31 36.01,92.18 36.01,92.73
GND on BOTTOM: 150.39,20.52 151.46,21.59 152.93,21.59 153.09,21.44 153.09,11.66 151.43,10.01 145.87,10.01 144.5,11.38 144.5,19.66 145.36,20.52
GND on BOTTOM: 45.47,40.64 48.36,40.64 49.43,39.57 49.43,39.19 49.76,38.86 49.76,38.25 50.14,37.87 50.95,37.87 51.44,38.35 51.44,41.61 51.18,41.86 45.44,41.86 45.19,41.61 45.19,40.92
GND on BOTTOM: 136.4,196.27 136.4,194.39 134.49,192.48 134.49,161.93 134.11,161.54 119.25,161.54 115.7,157.99 112.52,157.99 110.49,155.96 82.3,155.96 80.77,157.48 80.77,184.43 77.9,187.3 77.9,194.61 74.7,197.82 74.7,201.63 80.01,206.93 84.45,206.93 85.45,207.92 85.45,212.22 90.65,217.42 130.18,217.42 130.23,217.37 132.66,217.37 134.29,215.75 134.29,213.31 137.06,210.54 137.06,196.93 ; 2 cut-outs
GND on BOTTOM: 18.06,137.95 18.26,138.15 18.26,138.81 18.14,138.94 17.93,138.94 17.48,139.4 17.48,147.78 16.12,149.14 16.12,153.71 16.59,154.18 18.82,154.18 19.02,153.97 19.02,150.52 19,150.5 19.53,149.96 22.15,149.96 22.43,150.24 22.43,154.86 21.46,155.83 12.95,155.83 12.28,155.16 12.28,138.44 12.78,137.95
GND on BOTTOM: 71.45,217.47 71.88,217.04 71.88,208.58 71.55,208.25 69.01,208.25 68.55,207.8 64.57,207.8 64.62,207.75 61.37,207.75 60.71,208.41 60.71,212.45 59.79,213.36 59.28,213.36 59.21,213.28 56.11,213.28 55.16,214.24 55.16,217.21 55.42,217.47
GND on BOTTOM: 102.16,20.36 103.42,21.62 104.93,21.62 105.05,21.49 105.05,11.23 104.62,10.79 97.61,10.79 97.16,11.25 97.16,19.84 97.68,20.36
GND on BOTTOM: 187.71,121.69 189.41,121.69 189.61,121.49 189.61,119.99 190.27,119.33 190.27,117.96 189.84,117.53 187.66,117.53 187.46,117.72 187.46,121.45
GND on BOTTOM: 55.85,140.82 55.85,141.1 55.91,141.15 56.46,141.15 57.23,141.91 61.16,141.91 61.82,141.25 61.82,139.6 61.7,139.47 56.44,139.47 56.01,139.9 56.01,140.67
GND on BOTTOM: 39.22,193.93 65.5,193.93 67.16,195.58 68.04,195.58 69.31,194.31 69.31,187.96 68.04,186.69 52.96,186.69 52.55,187.1 52.55,190.12 51.79,190.88 40.74,190.88 39.98,190.12 39.98,185.29 39.47,184.78 37.69,184.78 37.31,185.17 37.31,186.05 38.14,186.88 38.14,192.85
GND on BOTTOM: 73.05,91.87 74.85,91.87 74.95,91.77 74.95,85.52 74.75,85.32 73.23,85.32 72.77,85.77 72.77,91.59
GND on BOTTOM: 86.61,48.01 86.61,46.1 84.04,43.52 84.04,42.2 83.39,41.55 81.23,41.55 80.75,42.04 80.75,46.58 82.12,47.96 82.12,49.73 82.55,50.16 85.72,50.16 85.85,50.04 85.85,48.77
GND on BOTTOM: 185.12,80.49 185.12,78.63 185.65,78.1 187.04,78.1 187.42,77.72 189.87,77.72 190.3,78.16 190.3,80.62 189.43,81.48 189.43,82.55 186.03,82.55 186.03,81.41
GND on BOTTOM: 78.23,167.61 77.19,166.57 58.6,166.57 55.37,169.8 55.37,182.63 56.01,183.26 77.22,183.26 78.23,182.25
GND on BOTTOM: 41.37,53.39 46.28,53.39 46.38,53.29 46.38,50.39 46.25,50.27 41.4,50.27 41.25,50.42 41.25,53.26
GND on BOTTOM: 52.45,110.54 52.45,108.2 52.35,108.1 50.14,108.1 49.93,108.3 49.93,110.59 49.98,110.64 52.35,110.64
GND on BOTTOM: 133.41,11.98 133.6,11.79 137.39,11.79 138.02,12.42 138.02,17.22 137.36,17.88 136.42,17.88 136.07,17.53 136.07,14.02 135.66,13.61 134.04,13.61 133.81,13.39 133.76,13.39 133.6,13.23 133.6,13.13 133.41,12.94
GND on BOTTOM: 137.54,75.51 138.38,75.51 138.45,75.44 138.45,74.09 138.3,73.94 137.54,73.94 137.39,74.09 137.39,75.36
GND on BOTTOM: 80.49,102.31 80.49,88.65 80.9,88.24 81.48,88.24 81.76,87.96 81.76,83.69 81.43,83.36 81.43,76.71 83.36,74.78 92.02,74.78 92.43,75.18 96.21,75.18 96.54,74.85 103.25,74.85 103.45,74.65 103.45,72.19 102.94,71.68 83,71.68 78.59,76.1 78.59,101.95 78.94,102.31
GND on BOTTOM: 21.49,53.44 26.31,53.44 26.49,53.26 26.49,50.44 26.31,50.27 21.44,50.27 21.31,50.39 21.31,53.26
GND on BOTTOM: 28.22,38.51 31.32,38.51 32.08,37.74 32.08,34.52 32.18,34.42 32.94,34.42 33.02,34.49 33.5,34.49 34.24,35.23 34.24,39.4 33.78,39.85 28.19,39.85 28.04,39.7 28.04,38.68
GND on BOTTOM: 184.02,170.69 193.45,170.69 193.47,170.71 193.47,173.69 193.19,173.96 184.33,173.96 184.02,173.66
GND on BOTTOM: 151.38,204.47 151.89,203.96 151.89,197.74 151.26,197.1 149.61,197.1 149.22,197.49 149.22,204.09 149.61,204.47
GND on BOTTOM: 10.92,41.25 13.94,41.25 14.68,40.51 14.68,38.05 14.99,37.74 16.26,37.74 16.59,38.07 16.59,41.73 15.98,42.34 10.92,42.34 10.67,42.09 10.67,41.5
GND on BOTTOM: 7.47,32.33 6.73,33.07 6.73,34.72 6.99,34.98 16.21,34.98 17.48,33.71 17.48,28.07 16.97,27.56 7.72,27.56 7.47,27.81
GND on BOTTOM: 25.53,29.11 24.16,30.48 24.16,31.75 24.28,31.88 33.76,31.88 35.08,30.56 35.08,25.12 34.14,24.18 25.96,24.18 25.53,24.61
GND on BOTTOM: 192.35,118.49 192.35,112.85 193.85,111.35 209.75,111.35 211.94,113.54 217.02,113.54 217.32,113.84 217.32,117.22 217.25,117.3 211.84,117.3 208.89,114.35 202.95,114.35 199.64,117.65 195.68,117.65 194.69,118.64 192.51,118.64
GND on BOTTOM: 162.86,192.66 138.74,192.66 135.98,189.9 135.98,189.87 135.38,189.27 135.38,165.35 136.02,164.72 173.35,164.72 174.75,166.12 174.75,178.05 177.8,181.1 177.8,187.38 177.09,188.09 167.94,188.09 167.64,187.78 162.86,192.56
GND on BOTTOM: 77.7,125.73 77.7,112.95 77.93,112.73 83.77,112.73 83.87,112.83 83.87,113.84 81.23,116.48 81.23,124.28 79.78,125.73
GND on BOTTOM: 203.2,168.63 202.77,169.06 202.77,171.02 201.5,172.29 201.5,173.84 202.36,174.7 202.36,181 203.2,181.84 206.83,181.84 207.52,181.15 215.95,181.15 216.08,181.03 216.08,179.73 215.95,179.6 213.84,179.6 213.46,179.98 209.55,179.98 208.84,179.27 208.84,174.73 209.58,173.99 213.61,173.99 214.15,173.46 214.15,158.8 213.61,158.27 210.59,158.27 209.58,157.25 209.58,149.81 209.22,149.45 202.84,149.45 202.34,149.96 202.34,157.63 202.74,158.04 205.51,158.04 206.34,158.86 206.34,167.12 205.84,167.61 204.11,167.61 203.2,168.53 ; 2 cut-outs
GND on BOTTOM: 130.45,199.75 126.21,199.75 125.73,200.23 125.73,206.17 126.11,206.55 129.34,206.55 130.45,205.44
GND on BOTTOM: 166.22,83.72 167.69,83.72 168.1,84.12 175.51,84.12 175.92,83.72 178.26,83.72 178.41,83.57 178.41,82.5 178.28,82.37 166.27,82.37 166.14,82.5 166.14,83.64
GND on BOTTOM: 84.55,127.89 93.57,127.89 93.7,127.76 93.7,126.87 84.55,126.87
GND on BOTTOM: 126.92,20.05 128.44,21.56 129.64,21.56 129.77,21.44 129.77,11.76 128.68,10.67 123.22,10.67 122.07,11.81 122.07,19.43 122.69,20.05
GND on BOTTOM: 162.69,78.33 162.69,72.16 163.25,71.6 164.03,71.6 165.25,72.82 165.25,77.5 164.34,78.41 162.76,78.41
GND on BOTTOM: 185.65,108.15 185.65,106.32 185.09,105.77 185.09,104.06 185.29,103.86 190.22,103.86 190.32,103.96 190.32,105.59 189.92,105.99 189.92,108.03 189.66,108.28 185.78,108.28
GND on BOTTOM: 168.55,104.24 169.93,104.24 170.69,103.48 173.53,103.48 174.29,104.24 175.56,104.24 176.4,103.4 178.16,103.4 178.18,103.43 178.18,105.59 178,105.77 163.63,105.77 163.28,105.42 163.3,105.41 163.3,104.62 162.76,104.09 162.76,103.66 162.92,103.5 164.54,103.5 165.3,104.27 166.42,104.27 167.26,103.43 167.74,103.43
GND on BOTTOM: 32.61,171.7 32.74,171.58 32.74,169.54 32.48,169.29 32.23,169.29 30.58,170.94 30.58,171.7
GND on BOTTOM: 148.18,93.57 155.07,93.57 155.45,93.19 155.45,92.61 154.66,91.82 148.03,91.82 147.75,92.1 147.75,93.14
GND on BOTTOM: 147.32,146.38 148.21,145.49 151.66,145.49 152.27,146.1 152.27,147.96 148.72,151.51 144.25,151.51 143.92,151.18 143.92,149.66 144.15,149.43 146.66,149.43 147.32,148.77
GND on BOTTOM: 182.25,209.04 182.5,208.79 182.5,205.82 181.25,204.57 181.25,201.93 182.63,200.56 184.02,200.56 184.38,200.91 184.38,201.4 184.66,201.68 187.32,201.68 187.81,201.19 187.81,193.65 187.4,193.24 173.96,193.24 171.07,196.14 171.07,201.6 171.48,202.01 172.92,202.01 173.51,201.42 176.17,201.42 176.71,200.89 178.56,200.89 179.04,201.37 179.04,203.43 179.15,203.53 179.81,203.53 179.98,203.71 179.98,204.34 178.71,205.61 178.71,208.76 178.99,209.04
GND on BOTTOM: 115.67,96.65 115.92,96.9 115.92,106.55 115.67,106.81 107.92,106.81 107.67,106.55 107.67,97.03 108.05,96.65
GND on BOTTOM: 108.51,13.51 108.51,12.73 109.17,12.06 112.55,12.06 113.18,12.7 113.18,17.37 112.75,17.81 111.66,17.81 111.43,17.58 111.43,14 111,13.56 108.56,13.56
GND on GND02, GND04, GND06, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 2.29,216.15 2.29,217.42 216.15,217.42 216.15,216.15 217.42,216.15 217.42,2.29 216.15,2.29 216.15,1.02 2.29,1.02 2.29,2.29 1.02,2.29 1.02,216.15
GND on ART03: 169.94,209.3 169.94,199.89 171.07,198.75 174.88,198.75 180.09,193.55 190.39,193.55 192.42,195.58 192.42,209.3
GND on ART03: 16.28,4.16 41.86,4.16 43.81,2.21 43.81,1.37 43.46,1.02 16.51,1.02 15.92,1.6 15.92,3.81
GND on ART03: 80.52,199.64 134.26,199.64 135.36,198.55 135.36,194.44 134.62,193.7 134.62,178.56 128.65,172.59 81.28,172.59 79.5,174.37 79.5,198.63
GND on ART05: 134.62,208.79 134.62,168.53 133.73,167.64 81.28,167.64 78.71,170.21 78.71,198.2 74.3,202.62 74.3,212.98 75.18,213.87 81.43,213.87 81.97,213.33 81.97,212.17 83.13,211 84.18,211 91.44,218.26 125.15,218.26 ; 2 cut-outs
GND on ART07: 134.62,208.79 134.62,168.53 133.73,167.64 81.28,167.64 79.12,169.8 79.12,199.59 77.17,199.59 75.06,201.7 74.02,201.7 72.39,203.33 72.39,204.37 72.29,204.47 71.37,204.47 71.25,204.34 69.22,204.34 67.94,205.61 67.94,214.12 69.1,215.28 69.1,216.85 69.62,217.37 126.03,217.37 ; 4 cut-outs
GND on ART16: 69.47,215.65 127.76,215.65 134.62,208.79 134.62,168.53 133.73,167.64 81.28,167.64 79.12,169.8 79.12,201.29 75.95,204.47 71.37,204.47 71.25,204.34 67.01,204.34 66.19,205.16 66.19,212.37
GND on ART18: 134.62,208.79 134.62,168.53 133.73,167.64 81.28,167.64 79.12,169.8 79.12,196.72 71.5,204.34 69.22,204.34 67.94,205.61 67.94,214.12 71.5,217.68 125.73,217.68 ; 1 cut-out
GND on ART20: 91.06,199.14 132.72,199.14 135.13,196.72 135.13,169.42 134.11,168.4 81.03,168.4 80.01,169.42 80.01,196.85 80.04,196.88 80.04,200.66 80.9,201.52 84.66,201.52 86.26,199.92 90.27,199.92
GND_ETHE on TOP (solid shape): outline of 266 points within 1.02,3.17 9.37,26.31
GND_QSFP_CAGE on TOP (solid shape): 50.19,84.86 48.62,84.86 48.62,87.86 50.19,87.86
GND_QSFP_CAGE on TOP (solid shape): 41.22,104.24 41.22,102.46 38.22,102.46 38.22,103.34 34.93,103.34 34.93,101.25 33.57,101.25 33.57,86.23 34.93,86.23 34.93,84.14 42.72,84.14 42.72,85.03 45.72,85.03 45.72,83.24 42.86,83.24 -0.38,83.24 -0.38,104.24 38.33,104.24
GND_QSFP_CAGE on BOTTOM (solid shape): 18.69,104.24 37.82,104.24 37.82,104.24 41.22,104.24 41.22,102.46 38.22,102.46 38.22,103.34 34.93,103.34 34.93,101.25 33.57,101.25 33.57,86.23 34.93,86.23 34.93,84.14 42.72,84.14 42.72,85.03 45.72,85.03 45.72,83.24 42.86,83.24 -0.38,83.24 -0.38,104.24 5.41,104.24 9.6,108.43 14.5,108.43
GND_QSFPDD_CAGE on BOTTOM: 41.02,80.87 41.71,80.19 41.71,75.16 41.05,74.5 34.31,74.5 34.31,63.12 35.1,62.33 45.75,62.33 45.75,62.31 46.2,61.85 46.2,59.08 45.54,58.42 18.18,58.42 14.45,54.69 12.44,54.69 12.43,54.7 9.66,54.7 5.89,58.47 2.41,58.47 1.04,59.84 1.04,80.87
GND_USB on BOTTOM (solid shape): 9.49,181.4 9.49,177.97 7.84,176.32 7.84,170.99 8.86,169.97 11.52,169.97 12.22,169.27 12.22,162.23 11.91,161.92 5.18,161.92 4.79,162.31 4.79,181.34 5.36,181.91 8.98,181.91
VCC_FPGA_VID on TOP: 76.05,125.98 76.05,112.91 75.9,112.77 71.61,112.77 70.87,113.51 70.87,117.16 70.24,117.78 65,117.78 63.83,118.95 63.83,126.38 64.96,127.51 74.52,127.51
VCC_FPGA_VID on TOP: 131.19,185.67 131.7,185.17 131.7,164.21 130.56,163.07 118.87,163.07 116.46,160.66 84.53,160.66 83.95,161.24 83.95,179.98 83.67,180.26 83.67,185.14 84.2,185.67 104.01,185.67 104.65,185.04 104.65,168.91 105.16,168.4 110.57,168.4 110.85,168.68 110.85,172.42 111.38,172.95 111.38,175.95 110.74,176.58 110.74,184.91 111.51,185.67
VCC_FPGA_VID on BOTTOM: 105.92,106.81 107.19,106.81 107.29,106.71 107.29,97.41 107.16,97.28 105.92,97.28 105.66,97.54 105.66,106.55
VCC_FPGA_VID on BOTTOM: 131.19,185.67 131.7,185.17 131.7,164.21 130.56,163.07 118.87,163.07 116.46,160.66 84.07,160.66 83.44,161.29 83.44,172.14 84.05,172.75 84.05,184.68 85.04,185.67 104.01,185.67 104.65,185.04 104.65,168.53 104.9,168.28 110.49,168.28 110.74,168.53 110.74,171.98 111.34,172.58 111.34,176.77 110.74,177.37 110.74,184.91 111.51,185.67
VCC_FPGA_VID on BOTTOM: 118.62,106.93 118.87,106.68 118.87,97.41 118.24,96.77 116.69,96.77 116.43,97.03 116.43,106.68 116.69,106.93
VCC_FPGA_VID on GND02: 98.45,170.81 98.45,169.04 98.7,168.78 100.74,168.78 100.99,169.04 100.99,170.81 100.74,171.07 98.7,171.07
VCC_FPGA_VID on GND02: 114.25,170.84 114.25,169.06 114.5,168.81 116.54,168.81 116.79,169.06 116.79,170.84 116.54,171.09 114.5,171.09
VCC_FPGA_VID on GND02: 87.2,170.87 87.2,169.09 87.45,168.83 89.48,168.83 89.74,169.09 89.74,170.87 89.48,171.12 87.45,171.12
VCC_FPGA_VID on GND02: 125.48,170.87 125.48,169.09 125.73,168.83 127.76,168.83 128.02,169.09 128.02,170.87 127.76,171.12 125.73,171.12
VCC_FPGA_VID on GND02, GND04, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 97.79,184.48 98.55,185.24 103.23,185.24 104.09,184.38 104.09,178.28 103.56,177.75 98.42,177.75 97.79,178.38
VCC_FPGA_VID on GND02, GND04, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 89.92,178.82 89.66,178.56 84.79,178.56 84.4,178.94 84.4,184.84 84.86,185.29 89.2,185.29 89.92,184.58
VCC_FPGA_VID on GND02, GND04, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 125.48,178.82 125.48,184.91 126.09,185.52 130.78,185.52 131.37,184.94 131.37,178.51 130.96,178.1 126.19,178.1
VCC_FPGA_VID on GND02, GND04, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 117.6,178.31 117.35,178.05 112.01,178.05 111.61,178.46 111.61,184.89 111.89,185.17 117.14,185.17 117.6,184.71
VCC_FPGA_VID on GND04: 125.43,170.81 125.43,169.04 125.68,168.78 127.71,168.78 127.97,169.04 127.97,170.81 127.71,171.07 125.68,171.07
VCC_FPGA_VID on GND04, GND06, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 98.42,170.81 98.42,169.04 98.68,168.78 100.71,168.78 100.97,169.04 100.97,170.81 100.71,171.07 98.68,171.07
VCC_FPGA_VID on GND04, GND06, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 114.17,170.81 114.17,169.04 114.43,168.78 116.46,168.78 116.71,169.04 116.71,170.81 116.46,171.07 114.43,171.07
VCC_FPGA_VID on GND04, GND06, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 87.12,170.81 87.12,169.04 87.38,168.78 89.41,168.78 89.66,169.04 89.66,170.81 89.41,171.07 87.38,171.07
VCC_FPGA_VID on GND06: 98.55,185.24 103.23,185.24 104.09,184.38 104.09,178.28 103.56,177.75 98.42,177.75 97.79,178.38 97.79,184.48
VCC_FPGA_VID on GND06: 111.89,185.17 117.14,185.17 117.6,184.71 117.6,178.31 117.35,178.05 112.01,178.05 111.61,178.46 111.61,184.89
VCC_FPGA_VID on GND06: 84.86,185.29 89.2,185.29 89.92,184.58 89.92,178.82 89.66,178.56 84.79,178.56 84.4,178.94 84.4,184.84
VCC_FPGA_VID on GND06: 126.09,185.52 130.78,185.52 131.37,184.94 131.37,178.51 130.96,178.1 126.19,178.1 125.48,178.82 125.48,184.91
VCC_FPGA_VID on GND06, GND08, GND10, GND13, GND15, GND17, GND19, GND21: 125.48,170.81 125.48,169.04 125.73,168.78 127.76,168.78 128.02,169.04 128.02,170.81 127.76,171.07 125.73,171.07
VCC_FPGA_VID on POWER11: 59.64,172.47 191.36,172.47 193.01,170.81 193.01,133.48 191.62,132.08 183.64,132.08 182.11,130.56 170.17,130.56 168.63,129.01 168.63,108.56 164.71,104.65 157.09,104.65 155.04,102.59 155.04,79.09 153.29,77.34 85.04,77.34 57.38,105.01 57.38,170.2 ; 2 cut-outs
VCC_FPGA_VID on POWER12: 59.64,172.47 191.36,172.47 193.01,170.81 193.01,133.48 191.62,132.08 183.64,132.08 182.11,130.56 170.17,130.56 168.63,129.01 168.63,108.56 164.71,104.65 157.09,104.65 155.04,102.59 155.04,79.09 153.29,77.34 85.04,77.34 68.73,93.65 67.16,93.65 65.57,95.24 65.57,96.81 64.74,97.64 57.38,105.01 57.38,170.2 ; 2 cut-outs
VCC_TESTI2C_1.2V on BOTTOM: 155.93,147.14 154.94,147.14 154.84,147.24 154.84,147.75 154.71,147.88 154.18,147.88 153.92,147.62 153.92,144.4 154.3,144.02 158.14,144.02 158.34,144.22 158.34,144.8 158.09,145.06 155.19,145.06 154.99,145.26 154.99,146.28 155.42,146.71 156.66,146.71 156.92,146.96 156.92,148.41 156.84,148.49 156.11,148.49 156.03,148.41 156.03,147.24
VCCA_PLL_FPGA_1.2V on BOTTOM: 159.51,104.65 161.34,104.65 163.07,106.38 163.5,106.38 163.51,106.36 163.53,106.38 164.62,106.38 165.23,106.98 165.23,109.86 164.21,110.87 160.4,110.87 157.92,108.39 157.86,108.39 157.67,108.2 152.27,108.2 151.13,107.06 145.92,107.06 143.76,104.9 139.45,104.9 138.68,104.14 138.68,96.39 138.94,96.14 143.76,96.14 145.67,94.23 156.97,94.23 158.62,95.89 158.62,103.76
VCCA_PLL_FPGA_1.2V on ART20: 143.21,123.04 159.38,123.04 164.92,117.5 164.92,109.04 161.14,105.26 151.49,105.26 149.35,103.12 149.35,97.66 143.64,91.95 131.39,91.95 130.63,92.71 125.73,92.71 125.35,92.33 125.35,87.63 124.97,87.25 118.37,87.25 118.36,87.25 106.4,87.25 105.89,87.76 105.89,102.62 106.02,102.62 107.92,104.52 107.67,104.77 107.67,109.98 107.16,110.49 103.32,110.49 101.68,112.14 101.68,120.98 103.02,122.33 118.01,122.33 118.53,121.81 118.68,121.81 118.92,121.56 118.92,118.58 121.04,116.46 121.04,112.39 122.26,111.18 125.23,111.18 126.45,109.96 127.91,109.96 129.08,111.12 132.78,111.12 141.72,120.07 141.72,121.55
VCCA_PWRMAX_3.3V on BOTTOM: 33.88,159.13 34.64,159.13 35.79,160.27 35.79,164.97 35.91,164.97 36.29,165.35 36.29,166.62 35.79,167.13 35.79,168.15 35.68,168.25 35.28,168.25 35.28,166.88 35.15,166.75 34.39,166.75 33.63,165.99 33.63,159.38
VCCA_PWRMAX_3.3V on ART03: 37.44,161.54 36.8,160.91 33.75,160.91 33.37,161.29 33.37,164.59 33.75,164.97 33.75,176.53 34.39,177.16 36.42,177.16 37.44,176.15
VCCA_PWRMAX_3.3V on ART16: 34.64,178.94 43.15,178.94 43.41,178.69 43.41,175.89 43.03,175.51 34.77,175.51 34.26,176.02 34.26,178.56
VCCA_PWRMAX_3.3V on ART20: 35.15,169.93 41.76,169.93 42.52,169.16 42.52,168.27 42.01,167.77 38.33,167.77 36.42,165.86 35.28,165.86 34.9,166.24 34.9,169.67
VCCA_SYSMAX_3.3V on BOTTOM: 169.95,84.51 167.59,84.51 167.28,84.2 165.89,84.2 165.53,84.56 164.77,84.56 164.74,84.58 164.74,86.51 164.77,86.54 169.93,86.54 169.95,86.51
VCCA_SYSMAX_3.3V on ART07: 177.65,103 178.15,102.49 178.15,98.04 175.11,95 175.11,94.74 173.58,93.22 173.58,86.13 172.58,85.13 166.38,85.13 164.31,87.2 164.31,102.46 164.84,103
VCCBAT on BOTTOM: 114.88,30.33 131.8,30.33 132.56,31.09 132.56,33.1 132.38,33.27 131.57,33.27 131.57,32.59 131.32,32.33 117.47,32.33 114.02,35.79 114.02,37.64 114.05,37.67 114.05,39.73 114,39.78 110.97,39.78 110.97,34.24
VCCBAT_FPGA_1.8V on BOTTOM: 124.56,94.49 126.46,94.49 126.72,94.23 126.72,90.8 126.46,90.55 125.45,90.55 125.32,90.68 125.32,92.71 124.43,93.6 124.43,94.36
VCCBAT_FPGA_1.8V on ART20: 125.83,92.28 130.3,92.28 134.67,87.91 134.67,58.42 134.63,58.38 134.63,44.11 133.96,43.43 129.77,43.43 129.13,44.07 129.13,76.96 125.68,80.42 125.68,92.12
VCCCLK_GXE_FPGA_2.5V on TOP (solid shape): 55.45,132 57.02,132 57.18,131.85 57.18,129.95 57.06,129.83 55.11,129.83 55.04,129.9 55.01,129.94 54.95,129.98 54.9,129.99 54.86,130 54.61,130 54.54,130.04 54.46,130.05 54.05,130.05 54,130.04 53.94,130.02 53.88,130.02 53.87,130.03 53.79,130.06 53.7,130.07 53.57,130.05 53.46,129.98 53.1,129.98 52.73,130.35 52.73,131.95 53.1,132.32 55.13,132.32
VCCCLK_GXE_FPGA_2.5V on ART18: 101.73,115.14 100.61,114.02 100.61,105.92 100.4,105.71 100.4,104.8 100.1,104.49 94.71,104.49 94.33,104.88 94.33,111.53 93.53,112.33 93.53,117.56 93.39,117.7 77.01,117.7 74.03,120.69 71.61,120.69 64.54,127.76 63.6,128.7 53.16,128.7 52.4,129.47 52.4,131.9 53.67,133.17 74.3,133.17 77.73,129.75 79.35,129.75 81.15,131.55 103.58,131.55 105.03,130.1 105.03,115.77 104.39,115.14
VCCCLK_GXP_FPGA_1.8V on BOTTOM: 155.83,128.4 153.29,128.4 152.91,128.02 148.97,128.02 148.46,128.52 148.46,130.68 148.97,131.19 151.38,131.19 152.15,130.43 155.32,130.43 155.83,129.92
VCCCLK_GXP_FPGA_1.8V on BOTTOM: 123.19,98.93 125.98,98.93 126.49,98.42 126.49,96.14 123.95,96.14 123.95,97.16 123.44,97.66 123.19,97.66 123.06,97.79 123.06,98.81
VCCCLK_GXP_FPGA_1.8V on ART07: 120.9,117.47 120.9,97.79 121.54,97.16 125.09,97.16 126.11,98.17 126.11,106.3 124.33,108.08 124.33,113.03 141.6,130.3 149.1,130.3 149.86,131.06 149.86,134.49 148.59,135.76 139.19,135.76
VCCFUSEWR_SDM_FPGA_2.4V on TOP: 51.23,51.13 49.66,51.13 49.23,51.56 49.23,54.79 49.45,55.02 51.26,55.02 51.54,54.74 51.54,51.44
VCCFUSEWR_SDM_FPGA_2.4V on BOTTOM: 122.76,78.08 121.59,78.08 121.41,77.9 121.41,76.53 121.64,76.3 122.68,76.3 122.83,76.45 122.83,78
VCCFUSEWR_SDM_FPGA_2.4V on ART18: 123.54,93.34 126.46,93.34 127.61,92.2 127.61,87.88 126.95,87.22 124.15,87.22 123.04,86.11 123.04,74.17 121.89,73.03 109.32,73.03 107.41,71.12 84.43,71.12 75.92,62.61 75.92,59.05 77.06,57.91 77.06,54.18 73.2,50.32 70.1,50.32 68.68,48.9 63.6,48.9 63.15,49.35 48.28,49.35 47.22,50.42 47.22,54.74 70.46,77.98 76.05,77.98 77.05,78.98 93.64,78.98 95.94,81.28 108.18,81.28 117.57,90.68 120.88,90.68
VCCH_FPGA_0.9V on TOP: 146.99,174.93 147.75,175.69 147.75,180.62 148.79,181.66 152.15,181.66 152.55,181.25 152.55,175.49 153.42,174.62 157.91,174.62 158.9,175.62 158.9,181.31 159.46,181.86 164.39,181.86 165.23,181.03 165.23,175.75 166.04,174.93 169.42,174.93 169.42,174.93 169.77,174.93 170.21,174.5 170.21,171.73 170.74,171.2 171.58,171.2 171.96,170.81 171.96,169.07 171.7,168.81 137.76,168.81 137.12,169.45 137.12,174.42 137.64,174.93
VCCH_FPGA_0.9V on BOTTOM: 75.11,92.89 74.65,92.43 72.41,92.43 72.4,92.44 70.98,92.44 70.56,92.86 70.56,97.36 70.91,97.71 74.8,97.71 75.11,97.41
VCCH_FPGA_0.9V on BOTTOM: 68.68,111.51 68.68,108.2 68.04,107.57 64.49,107.57 63.47,108.58 63.47,111.63 63.98,112.14 68.04,112.14
VCCH_FPGA_0.9V on BOTTOM: 139.42,114.05 142.97,114.05 143.36,114.43 143.36,116.08 142.97,116.46 139.42,116.46 138.91,115.95 138.91,114.55
VCCH_FPGA_0.9V on BOTTOM: 171.96,169.04 171.58,168.66 137.16,168.66 136.91,168.91 136.91,174.5 137.54,175.13 147.5,175.13 148.54,176.17 148.54,181.08 149.35,181.89 152.3,181.89 152.65,181.53 152.65,177.11 152.78,176.99 158.5,176.99 158.83,177.32 158.83,181.53 159.18,181.89 164.19,181.89 165.07,181 165.07,176.25 165.91,175.41 170.99,175.41 171.96,174.45
VCCH_FPGA_0.9V on POWER09: 171.2,197.36 176.66,191.9 176.66,168.53 156.56,148.44 156.56,111.51 155.42,110.36 124.71,110.36 124.05,109.71 124.05,94.34 123.69,93.98 121.36,93.98 121.13,94.21 121.13,95.48 120.73,95.88 116.58,95.88 116.18,95.48 116.18,94.08 116.07,93.98 100.41,93.98 100.3,94.08 100.3,105.64 99.65,106.3 57.5,106.3 57.5,163.58 57.52,163.59 57.52,173.72 58.93,175.13 77.34,175.13 79.25,177.04 79.25,196.85 79.76,197.36 155.57,197.36 ; 3 cut-outs
VCCH_FPGA_0.9V on ART16: 62.58,111.63 73.12,111.63 73.51,111.25 73.51,100.33 74.9,98.93 74.9,94.36 74.65,94.11 62.58,94.11 62.2,94.49 62.2,111.25
VCCH_GXE_FPGA_1.1V on TOP: 10.41,51.05 10.41,47.04 10.59,46.86 12.67,46.86 12.8,46.99 12.8,51.03 12.52,51.31 10.67,51.31
VCCH_GXE_FPGA_1.1V on BOTTOM: 84.17,88.65 82.47,88.65 82.14,88.31 82.14,77.57 83.77,75.95 91.41,75.95 92.22,76.76 92.22,79.17 91.39,80.01 86,80.01 84.33,81.69 84.33,88.49
VCCH_GXE_FPGA_1.1V on BOTTOM: 5.41,46.53 1.35,46.53 1.17,46.71 1.17,50.19 1.4,50.42 12.17,50.42 12.73,49.86 12.73,47.09 12.4,46.76 9.25,46.76 9.19,46.81 5.69,46.81
VCCH_GXE_FPGA_1.1V on POWER09: 57.5,105.79 99.43,105.79 99.79,105.43 99.79,80.11 95.24,75.56 60.95,75.56 40.02,54.63 39.23,54.63 35.43,50.83 35.43,46.08 33.6,44.25 33.6,39.6 34.01,39.19 34.01,38.66 33.71,38.35 10.67,38.35 10.11,38.91 10.11,42.57 10.39,42.85 10.39,43.23 10.38,43.24 10.38,49.67 10.82,50.11 12.75,50.11 23.47,60.83 23.47,102.87 57.5,102.87
VCCH_GXP_FPGA_1.8V on BOTTOM: 150.34,111.51 145.26,111.51 144.75,111 144.75,109.09 145.13,108.71 150.21,108.71 150.34,108.84
VCCH_GXP_FPGA_1.8V on ART16: 123.62,97.54 125.83,95.33 141.91,95.33 150.59,104.01 150.59,110.62 148.31,112.9 135.05,112.9 131.46,109.31 129.45,109.31 127.98,110.78 127.98,111.49 126.57,112.9 121.51,112.9 120.11,111.51 120.11,97.92 120.5,97.54
VCCH_VDD33 on TOP: 169.09,179.63 169.09,176.5 169.19,176.4 170.03,176.4 170.1,176.48 170.1,179.53 169.88,179.76 169.21,179.76
VCCH_VDD33 on ART20: 167.97,180.57 166.42,182.12 157.96,182.12 157.51,181.66 157.51,179.76 158.04,179.22 165.66,179.22 171.12,173.76 173.23,173.76 173.48,174.02 173.48,175.31 172.16,176.63 172.16,178.87 170.46,180.57
VCCIO_FPGA_1.2V on TOP: 210.72,163.55 210.36,163.19 210.36,157.89 210.77,157.48 210.77,152.73 210.78,152.72 210.78,149.92 210.87,149.83 213.44,149.83 213.45,149.85 214.9,149.85 215.21,150.16 215.21,162.94 214.6,163.55
VCCIO_FPGA_1.2V on TOP: 150.72,145.34 149.3,145.34 148.84,145.8 144.88,145.8 144.55,146.13 142.19,146.13 141.86,145.8 141.86,144.63 141.91,144.58 142.09,144.58 142.11,144.6 142.11,145.36 142.21,145.47 143.08,145.47 143.51,145.03 143.51,144.15 144.4,143.26 147.6,143.26 148.03,142.82 150.7,142.82 150.95,143.08 150.95,145.11
VCCIO_FPGA_1.2V on TOP: 210.54,179.17 210.54,174.12 210.34,173.91 210.34,169.19 210.64,168.88 215.77,168.88 216.31,169.42 216.31,177.57 215.95,177.93 214.63,177.93 213.74,178.82 213.74,179.17 213.49,179.43 210.79,179.43
VCCIO_FPGA_1.2V on TOP: 159.33,102.9 159.33,101.85 159.61,101.57 160.1,101.57 160.53,101.14 160.53,100.61 160.93,100.2 162.15,100.2 162.43,100.48 162.43,101.83 161.24,103.02 159.46,103.02
VCCIO_FPGA_1.2V on BOTTOM: 162.28,95.88 160.88,95.88 160.75,96.01 160.75,99.95 160.78,99.98 160.78,100.2 160.4,100.58 159.51,100.58 159.26,100.84 159.26,103.63 161.42,103.63 162.28,102.77
VCCIO_FPGA_1.2V on BOTTOM: 168.66,103.78 169.82,103.78 170.51,103.1 172.44,103.1 172.49,103.05 172.49,102.08 172.31,101.9 168.71,101.9 168.53,102.08 168.53,103.66
VCCIO_FPGA_1.2V on BOTTOM: 148.67,144.86 148.67,143.33 148.98,143.01 150.66,143.01 150.95,143.31 150.95,144.83 150.67,145.11 148.92,145.11
VCCIO_FPGA_1.2V on BOTTOM: 46.45,175.41 42.62,175.41 42.49,175.28 42.49,173.4 42.69,173.2 45.9,173.2 46.28,173.58 48.23,173.58 48.61,173.2 48.61,172.72 48.99,172.34 49.65,172.34 49.83,172.52 49.83,174.32 50.31,174.8 50.31,175.89 50.16,176.05 48.94,176.05 48.61,175.72 48.61,175.36 48.18,174.93 46.94,174.93
VCCIO_FPGA_1.2V on BOTTOM: 210.82,157.53 210.82,149.68 211.12,149.38 213.36,149.38 213.72,149.73 213.72,157.4 213.36,157.76 211.05,157.76
VCCIO_FPGA_1.2V on BOTTOM: 210.72,179.55 210.72,174.68 211.05,174.35 212.78,174.35 214.05,175.62 216.05,175.62 216.51,176.07 216.51,177.85 216.43,177.93 214.1,177.93 213.41,178.61 213.41,179.3 213,179.71 210.87,179.71
VCCIO_FPGA_1.2V on BOTTOM: 101.22,76.73 95.63,76.73 95.48,76.58 95.48,75.69 95.6,75.56 96.31,75.56 96.67,75.21 101.19,75.21 101.39,75.41 101.39,76.55
VCCIO_FPGA_1.2V on GND08: 159.41,102.84 159.41,101.83 159.77,101.47 160.48,101.47 160.76,101.19 160.76,100.25 160.91,100.1 162.31,100.1 162.43,100.23 162.43,102.11 161.47,103.07 159.64,103.07
VCCIO_FPGA_1.2V on POWER14: 136.78,193.8 172.97,193.8 175.77,191.01 176.28,191.01 189.84,191.01 201.27,179.58 215.26,179.58 215.26,29.46 209.52,29.46 207.62,27.56 67.28,27.56 58.24,18.52 44.15,18.52 42.42,16.79 33.83,16.79 33.4,17.22 33.4,53.36 43.41,63.37 43.41,95.76 43.46,95.81 43.46,96.49 43.43,96.52 43.41,96.52 43.41,158.24 44.17,159 59.69,159 61.72,161.04 61.72,170.18 60.96,170.94 45.06,170.94 43.15,172.85 43.13,172.85 42.49,173.48 42.49,175.61 42.52,175.64 54.81,175.64 57.25,178.08 57.25,188.82 59.44,191.01 133.99,191.01 ; 9 cut-outs
VCCIO_FPGA_1.5V on TOP: 36.45,42.09 32.77,42.09 32.44,42.42 32.44,44.07 32.69,44.32 36.53,44.32 36.86,43.99 36.86,42.49
VCCIO_FPGA_1.5V on BOTTOM: 36.75,41.4 36.88,41.53 36.88,42.65 36.4,43.13 36.4,43.87 36.09,44.17 33.99,44.17 33.78,43.97 33.78,42.42 34.04,42.16 34.42,42.16 34.59,41.99 34.59,41.58 34.77,41.4
VCCIO_FPGA_1.5V on POWER09: 35.38,38.35 33.91,39.83 33.91,44.22 35.74,46.05 35.74,50.67 39.6,54.53 40.64,54.53 61.16,75.06 95.45,75.06 100.3,79.9 100.3,93.47 113.51,93.47 113.51,71.14 125.45,59.2 125.45,45.59 86.73,45.59 79.5,38.35
VCCIO_FPGA_1.8V on TOP: 31.99,139.97 32.56,139.4 34.19,139.4 34.7,139.9 36.6,139.9 36.86,140.16 36.86,141.58 36.55,141.88 32.16,141.88 31.99,141.72
VCCIO_FPGA_1.8V on TOP: 190.04,104.65 190.04,103.5 190.17,103.38 192.28,103.38 192.33,103.43 192.33,104.67 192.25,104.75 191.64,104.75 191.54,104.65
VCCIO_FPGA_1.8V on TOP: 185.27,79.25 182.73,79.25 182.47,78.99 182.47,77.85 182.73,77.6 184.63,77.6 185.27,78.23
VCCIO_FPGA_1.8V on TOP: 39.24,154.56 37.85,154.56 37.34,155.07 37.34,155.12 36.07,155.12 34.95,156.23 31.98,156.23 31.62,156.59 31.62,157.23 31.72,157.33 33.25,157.33 33.47,157.56 38.53,157.56 39.24,156.84
VCCIO_FPGA_1.8V on TOP: 185.32,104.65 183.69,104.65 183.57,104.78 183.11,104.78 182.98,104.65 182.98,103.35 183.08,103.25 185.19,103.25 185.34,103.4 185.34,104.62
VCCIO_FPGA_1.8V on TOP: 190.22,79.25 192.25,79.25 192.5,78.99 192.5,77.72 192.25,77.47 190.47,77.47 190.22,77.72
VCCIO_FPGA_1.8V on TOP: 53.47,148.84 53.47,151 53.72,151.26 55.24,151.26 55.5,151 55.5,150.52 56.16,149.86 60.91,149.86 61.26,149.5 61.26,147.95 61.06,147.75 54,147.75 53.62,148.13 53.62,148.74 53.52,148.84
VCCIO_FPGA_1.8V on BOTTOM: 35.05,175.26 35.05,174.24 34.8,173.99 33.63,173.99 33.37,174.24 31.98,174.24 31.62,174.6 31.62,176.05 31.98,176.4 33.37,176.4 33.63,176.15 33.63,175.64 33.75,175.51 34.8,175.51
VCCIO_FPGA_1.8V on BOTTOM: 123.8,94.61 124.05,94.36 124.05,91.06 123.92,90.93 120.11,90.93 119.73,91.31 119.73,92.33 119.48,92.58 119.48,93.09 121,94.61
VCCIO_FPGA_1.8V on BOTTOM: 190.4,107.09 190.4,105.92 190.63,105.69 190.63,103.5 190.75,103.38 192.25,103.38 192.38,103.5 192.38,104.95 191.47,105.87 191.47,107.09 191.41,107.14 190.45,107.14
VCCIO_FPGA_1.8V on BOTTOM: 178.51,95.2 179.96,95.2 180.01,95.25 180.01,99.06 180.16,99.21 180.16,105.28 180.09,105.36 178.66,105.36 178.57,105.27 178.57,101.84 178.26,101.52 178.26,95.45
VCCIO_FPGA_1.8V on BOTTOM: 137.39,77.8 138.22,77.8 138.45,77.57 138.45,76.05 138.35,75.95 137.31,75.95 137.23,76.02 137.23,77.65
VCCIO_FPGA_1.8V on BOTTOM: 29.79,151.89 29.16,151.26 29.16,147.98 29.44,147.7 30.71,147.7 31.34,148.34 34.39,148.34 36.17,146.56 38.05,146.56 38.88,145.72 44.1,145.72 44.3,145.52 45.44,145.52 45.64,145.72 57.81,145.72 59.28,147.19 59.28,157.17 56.11,160.35 38.81,160.35 35.36,156.89 35.36,152.63 34.62,151.89
VCCIO_FPGA_1.8V on BOTTOM: 180.59,90.4 180.59,87.76 180.47,87.63 178.79,87.63 178.53,87.88 178.53,91.31 178.79,91.57 180.57,91.57 180.69,91.44 180.69,90.5
VCCIO_FPGA_1.8V on BOTTOM: 185.19,107.62 185.19,106.5 184.73,106.05 184.73,103.45 184.53,103.25 183.24,103.25 183.03,103.45 183.03,104.62 183.87,105.46 183.87,107.57 184,107.7 185.12,107.7
VCCIO_FPGA_1.8V on BOTTOM: 183.16,77.85 184.61,77.85 184.73,77.98 184.73,80.75 185.39,81.4 185.39,82.42 184.12,82.42 183.85,82.15 183.85,80.77 183.11,80.03 183.11,77.9
VCCIO_FPGA_1.8V on BOTTOM: 190.09,81.61 190.65,81.05 190.65,78.11 190.86,77.9 192.43,77.9 192.76,78.23 192.76,83.44 192.38,83.82 190.35,83.82 190.09,83.57
VCCIO_FPGA_1.8V on ART05: 120.11,123.95 129,123.95 129.64,123.32 129.64,121.67 128.75,120.78 125.19,120.78 123.29,118.87 123.29,114.43 117.19,108.33 101.57,108.33 101.19,108.71 101.19,111.12 103.35,113.28 111.35,113.28 118.84,120.78 118.84,122.68
VCCIO_FPGA_1.8V on POWER09: 175.34,86.74 172.06,90.02 172.06,91.47 171.42,92.1 171.42,92.2 159.99,92.2 158.98,91.19 158.98,75.8 149.85,66.67 142.06,66.67 134.97,73.76 134.97,89.66 147.02,89.66 147.8,90.44 147.8,109.85 165.3,109.85 176.88,121.43 176.88,128.42 177.5,129.03 193.29,129.03 194.54,127.78 194.54,75.92 193.54,74.93 182.58,74.93 181.71,75.8 181.71,85.45 180.42,86.74
VCCIO_FPGA_1.8V on ART16: 33.75,175.11 33.75,166.95 35.1,165.61 35.1,157.17 35.99,156.29 39.01,156.29 40.28,157.56 40.28,174.17 39.16,175.28 33.93,175.28
VCCIO_FPGA_1.8V on ART18: outline of 97 points within 9.65,73.28 145.29,163.07 ; 7 cut-outs
VCCL_HPS_FPGA_0.9V on TOP: 18.01,41.45 16.33,43.13 16.33,45.09 16.51,45.26 18.87,45.26 19.1,45.03 21.59,45.03 21.82,44.81 21.82,41.96 21.31,41.45
VCCL_HPS_FPGA_0.9V on TOP: 61.29,101.62 70.18,101.62 70.71,102.16 70.71,115.14 69.33,116.52 61.99,116.52 58.83,113.36 58.83,104.09
VCCL_HPS_FPGA_0.9V on BOTTOM: 19.94,41.94 16.94,41.94 16.56,42.32 16.56,43.64 16.21,43.99 16.21,45.11 16.38,45.29 17.53,45.29 17.86,44.96 19.74,44.96 20.04,44.65 20.04,42.04
VCCL_HPS_FPGA_0.9V on BOTTOM: 67.92,101.6 69.62,101.6 69.92,101.9 69.92,106.53 69.64,106.81 67.66,106.81 67.66,101.85
