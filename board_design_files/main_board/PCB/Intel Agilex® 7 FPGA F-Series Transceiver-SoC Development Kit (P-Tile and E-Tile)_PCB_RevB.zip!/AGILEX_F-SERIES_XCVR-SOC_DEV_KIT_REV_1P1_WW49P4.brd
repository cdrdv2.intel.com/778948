# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HPS_GPIO31: length 303.8
  TOP w0.109: R494.2 179.42,96.27 v2(179.02,95.86) ; J5.34 45.61,148.36 45.26,148 v2(45.26,147.95) 45.26,147.7 45.47,147.49 R81.1
  ART03 w0.114: v2(171.57,159.59) 169.52,161.64 139.47,161.64 v2(138.28,162.84)
  ART05 w0.114: v2(183.06,95.33) 182.06,94.33 182.06,93.83 181.43,93.19 180.16,93.19 179.58,93.77 179.58,95.3 v2(179.02,95.86) 178.41,95.25 178.41,93.98 177.61,93.18 173.47,93.18 v2(173.07,92.78)
  ART16 w0.114: v2(45.26,147.95) 46.15,148.84 46.66,148.84 46.77,148.96 46.77,150 46.89,150.11 47.12,150.11 47.23,150 47.23,148.96 47.35,148.84 47.57,148.84 47.69,148.96 47.69,150 47.8,150.11 48.03,150.11 48.15,150 48.15,148.96 48.26,148.84 48.49,148.84 48.6,148.96 48.6,150 48.72,150.11 48.95,150.11 49.06,150 49.06,148.96 49.17,148.84 49.4,148.84 49.52,148.96 49.52,150 49.63,150.11 49.86,150.11 49.97,150 49.97,148.96 50.09,148.84 50.32,148.84 50.43,148.96 50.43,150 50.55,150.11 50.77,150.11 50.89,150 50.89,148.96 51,148.84 51.4,148.84 51.51,148.96 51.51,149.49 51.63,149.61 51.86,149.61 51.97,149.49 51.97,148.96 52.09,148.84 52.31,148.84 52.43,148.96 52.43,149.49 52.54,149.61 52.77,149.61 52.89,149.49 52.89,148.96 53,148.84 54.33,148.84 54.46,148.72 58.7,148.72 60.96,146.46 61.24,146.46 62.38,145.31 62.38,145.03 65.78,141.63 65.78,132.28 70.37,127.7 72.58,125.89 73.25,125.22 75.59,122.81 75.94,122.81 76.55,122.2 76.55,121.28 78.23,119.61 79.36,119.11 85.1,117.18 85.19,117.09 86.21,117.09 v2(86.21,117.1)
  ART18 w0.114: v2(138.28,162.84) 137.98,162.55 137.98,162.24 135.43,159.69 133.23,159.69 131.33,157.78 107.75,157.78 105.18,155.22 98.91,155.22 96.91,157.21 57.75,157.21 56.06,158.9 52.63,158.9 50.04,156.31 49.07,156.31 44.93,152.17 44.93,148.95 45.26,148.62 v2(45.26,147.95)
  ART20 w0.114: v2(183.06,95.33) 183.06,98.93 182.34,99.64 182.34,104.01 182.98,104.65 182.98,105.66 183.74,106.43 183.74,107.44 182.53,108.65 181.85,108.65 179.82,110.69 179.82,120.43 177.87,122.38 177.87,126.98 174.24,130.61 174.24,135.51 173.05,136.71 173.05,149.3 172.18,150.16 172.18,158.98 v2(171.57,159.59)
HPS_GPIO32: length 88.1
  TOP w0.109: J5.35 45.11,157.29 v2(44.3,158.11)
  ART20 w0.114: v2(44.3,158.11) 48.33,161.54 51.44,163.47 56.97,163.47 72.42,148.03 72.42,140.87 72.8,140.49 73.58,140.17 77.93,140.17 78.99,139.68 92.71,125.96 92.71,112.42 92.3,112.01 92.03,112.01 91.7,111.69 91.7,111.39 v2(91.41,111.1)
HPS_GPIO33: length 74
  TOP w0.109: J5.36 45.11,151.19 v2(45.44,151.51)
  ART20 w0.114: v2(45.44,151.51) 45.44,150.88 45.57,150.75 47.65,150.75 49.4,152.5 52.89,152.5 53.87,151.52 58.55,151.52 66.16,143.91 66.16,133.33 66.42,133.07 66.58,133.07 66.8,133.29 66.96,133.29 67.12,133.13 67.12,132.97 66.9,132.75 66.9,132.58 67.07,132.42 67.23,132.42 67.45,132.64 67.61,132.64 67.77,132.48 67.77,132.32 67.55,132.1 67.55,131.94 67.71,131.78 67.87,131.78 68.09,132 68.25,132 68.42,131.83 68.42,131.67 68.2,131.45 68.2,131.29 68.36,131.13 68.52,131.13 68.74,131.35 68.9,131.35 69.06,131.19 69.06,131.03 68.84,130.81 68.84,130.64 69.01,130.48 69.17,130.48 69.39,130.7 69.55,130.7 69.71,130.54 69.71,130.38 69.49,130.16 69.49,130 69.65,129.84 69.81,129.84 70.03,130.06 70.19,130.06 70.36,129.89 70.36,129.73 70.14,129.51 70.14,129.35 70.3,129.19 70.46,129.19 70.68,129.41 70.84,129.41 71,129.25 71,129.09 70.78,128.87 70.78,128.7 70.94,128.54 71.11,128.54 71.33,128.76 71.49,128.76 71.65,128.6 71.65,128.44 71.43,128.22 71.43,128.06 71.59,127.9 71.75,127.9 71.97,128.12 72.13,128.12 72.3,127.95 72.3,127.79 72.08,127.57 72.08,127.41 72.24,127.25 72.4,127.25 72.62,127.47 72.78,127.47 72.94,127.31 72.94,127.15 72.72,126.93 72.72,126.77 72.88,126.6 73.05,126.6 73.27,126.82 73.43,126.82 73.59,126.66 73.59,126.5 73.37,126.28 73.37,126.12 73.53,125.96 73.69,125.96 73.91,126.18 74.07,126.18 74.24,126.01 74.24,125.85 74.02,125.63 74.02,125.47 75.66,123.82 78.84,123.82 84.56,118.1 v2(86.21,118.1)
HPS_GPIO34: length 84.9
  TOP w0.109: J5.37 44.61,157.16 v2(44.55,157.23)
  ART20 w0.114: v2(91.41,112.1) 91.85,112.54 91.85,126.18 78.77,139.26 73.31,139.26 71.73,140.84 71.73,148.08 56.79,163.02 51.81,163.02 47.93,159.13 46.94,159.13 45.55,157.75 v2(44.55,157.23)
HPS_GPIO35: length 75.8
  TOP w0.109: v2(44.42,152.02) 44.42,151.61 44.61,151.42 J5.38
  ART20 w0.114: v2(44.42,152.02) 44.99,152.59 46.01,152.59 48.49,155.07 50.9,155.07 52.85,157.02 52.85,158.37 53.49,159 55.29,159 56.03,158.27 56.84,158.27 58.47,156.64 58.47,155.47 58.03,155.04 58.03,154.87 58.2,154.71 58.36,154.71 58.79,155.14 58.95,155.14 59.11,154.98 59.11,154.82 58.68,154.39 58.68,154.23 58.84,154.07 59,154.07 59.43,154.5 59.6,154.5 59.76,154.33 59.76,154.17 59.33,153.74 59.33,153.58 59.49,153.42 59.65,153.42 60.08,153.85 60.24,153.85 60.4,153.69 60.4,153.53 59.97,153.1 59.97,152.93 68.02,144.89 68.02,136.42 77.32,127.13 79.22,127.13 80.87,125.48 80.87,124.54 83.73,121.68 83.73,121.6 85.19,120.14 85.57,120.14 85.82,119.89 85.82,119.49 v2(86.21,119.1)
HPS_GPIO36: length 88.1
  TOP w0.109: v2(43.53,158.11) 44.11,157.53 J5.39
  ART16 w0.114: v2(92.28,110.6) 92.71,111.48 92.71,115.84 92.47,116.08 92.08,116.08 91.6,116.56 91.34,116.56 91.15,116.67 90.77,117.05 90.49,117.05 90.3,117.16 89.88,117.59 89.57,117.59 89.41,117.68 89,118.09 88.7,118.09 88.46,118.23 88.1,118.59 87.84,118.59 87.34,119.09 86.92,119.09 86.34,119.67 86.04,119.67 85.57,120.14 85.18,120.14 81.36,123.96 81.36,125.45 79.56,127.25 75.58,127.25 68.04,134.79 68.04,143.64 59.54,152.15 58.7,152.15 58.58,152.26 58.58,152.79 58.47,152.91 58.24,152.91 58.12,152.79 58.12,152.26 58.01,152.15 57.78,152.15 57.67,152.26 57.67,152.79 57.55,152.91 57.32,152.91 57.21,152.79 57.21,152.26 57.1,152.15 55.22,152.15 55.11,152.26 55.11,152.79 54.99,152.91 54.76,152.91 54.65,152.79 54.65,152.26 54.54,152.15 54.2,152.15 53.19,153.16 51.53,153.16 51.32,153.38 51.32,153.83 50.88,154.27 50.88,154.43 51.19,154.74 51.19,154.9 51.03,155.06 50.87,155.06 50.56,154.76 50.4,154.76 50.23,154.92 50.23,155.08 50.54,155.39 50.54,155.55 50.38,155.71 50.22,155.71 49.91,155.4 49.75,155.4 49.46,155.69 48.01,155.69 46.17,157.08 46.17,158.29 45.57,158.93 44.76,158.93 44.36,158.53 43.95,158.53 v2(43.53,158.11)
HPS_GPIO37: length 79.5
  TOP w0.109: v2(44.76,148.46) 44.55,148.46 44.11,148.9 J5.40
  ART20 w0.114: v2(44.76,148.46) 45.57,148.46 48.38,145.64 50.65,145.64 52.14,144.14 52.14,141.61 53.27,140.48 53.27,139.69 53.29,139.68 53.29,139.66 57.25,135.7 57.25,131.91 57.74,131.41 57.74,131.19 59.29,129.64 59.52,129.64 63.61,125.54 63.61,125.31 63.62,125.3 63.62,117.32 63.95,116.99 64.12,116.99 64.53,117.4 64.69,117.4 64.85,117.24 64.85,117.08 64.44,116.67 64.44,116.51 64.6,116.35 64.76,116.35 65.17,116.76 65.33,116.76 65.5,116.59 65.5,116.43 65.09,116.02 65.09,115.86 65.25,115.7 65.41,115.7 65.82,116.11 65.98,116.11 66.14,115.95 66.14,115.79 65.73,115.38 65.73,115.21 65.89,115.05 66.06,115.05 66.47,115.46 66.63,115.46 66.79,115.3 66.79,115.14 66.38,114.73 66.38,114.57 67.03,113.92 67.62,113.92 67.74,113.8 67.74,113.4 67.85,113.28 68.08,113.28 68.19,113.4 68.19,113.8 68.31,113.92 69.95,113.92 70.58,113.28 70.58,113.03 70.87,112.74 70.87,112.58 70.5,112.21 70.5,112.05 70.66,111.89 70.82,111.89 71.19,112.26 71.35,112.26 71.52,112.1 71.52,111.94 71.15,111.57 71.15,111.41 71.31,111.25 71.47,111.25 71.84,111.61 72,111.61 72.51,111.1 85.57,111.1 86.11,111.63 86.33,111.63 86.61,111.91 86.61,112.9 87.08,113.37 v2(87.08,113.6)
HPS_GPIO38: length 88.8
  TOP w0.109: v2(43.41,157.35) 43.61,157.14 J5.41
  ART16 w0.114: v2(92.28,111.6) 91.88,112.33 91.88,115.11 91.7,115.4 91.59,115.51 91.46,115.51 88,117.62 87.67,117.62 87.21,118.08 86.79,118.08 86.22,118.65 85.89,118.65 85.43,119.11 85.16,119.11 80.81,123.46 80.81,125.28 79.35,126.75 75.37,126.75 67.54,134.58 67.54,143.54 63.85,147.22 63.28,147.22 62.8,146.75 62.64,146.75 62.48,146.91 62.48,147.07 62.95,147.55 62.95,147.71 62.79,147.87 62.63,147.87 62.16,147.4 62,147.4 61.83,147.56 61.83,147.72 62.31,148.19 62.31,148.36 62.15,148.52 61.98,148.52 61.51,148.04 61.35,148.04 61.19,148.21 61.19,148.37 61.66,148.84 61.66,149 61.5,149.16 61.34,149.16 60.86,148.69 60.7,148.69 60.54,148.85 60.54,149.01 61.01,149.49 61.01,149.65 60.85,149.81 60.69,149.81 60.22,149.34 60.06,149.34 59.9,149.5 59.9,149.66 60.37,150.13 60.37,150.3 60.21,150.46 60.05,150.46 59.57,149.98 59.41,149.98 59.25,150.15 59.25,150.31 59.72,150.78 59.72,150.94 59.28,151.38 54.2,151.38 53.06,152.53 49.5,152.53 48.52,153.51 48.44,153.51 48.2,153.75 48.2,153.83 45.64,156.39 45.64,158.22 45.39,158.47 45.04,158.47 44.79,158.23 44.79,157.85 44.68,157.73 44.5,157.73 44.47,157.7 44.17,157.7 43.82,157.35 v2(43.41,157.35)
HPS_GPIO39: length 77.6
  TOP w0.109: v2(44.73,147.27) 44.32,147.67 44.32,147.93 43.61,148.63 J5.42
  ART20 w0.114: v2(44.73,147.27) 44.31,147.68 44.31,148.71 44.83,149.22 45.72,149.22 47.24,147.7 48.66,147.7 48.97,148.02 48.97,148.54 49.68,149.25 52.27,149.25 54.04,147.48 54.49,147.48 55.83,146.15 57.91,146.15 60.71,143.35 60.71,142.57 61.62,141.66 61.78,141.66 62.02,141.91 62.18,141.91 62.33,141.76 62.33,141.59 62.13,141.39 62.13,141.2 62.29,141.04 62.45,141.04 62.65,141.24 62.86,141.24 63.17,140.94 63.17,140.84 63.4,140.61 63.4,130.73 67.79,126.34 67.79,122.44 67.9,122.33 68.07,122.33 68.41,122.67 68.57,122.67 68.73,122.5 68.73,122.34 68.32,121.93 68.32,121.77 68.48,121.61 68.64,121.61 69.05,122.02 69.21,122.02 69.38,121.86 69.38,121.7 68.97,121.29 68.97,121.12 69.13,120.96 69.29,120.96 69.7,121.37 69.86,121.37 70.02,121.21 70.02,121.05 69.61,120.64 69.61,120.48 69.82,120.27 72.74,120.27 74.65,118.36 74.65,117.73 75.41,116.97 80.87,116.97 82.81,115.02 83.49,115.02 83.52,115.06 85.6,115.06 86.06,114.6 v2(87.08,114.6)
HPS_GPIO40: length 88.2
  TOP w0.109: J5.43 43.11,157.03 42.9,157.25 42.9,158.24 v2(43.53,158.88)
  ART16 w0.114: v2(93.14,111.1) 93.53,111.51 93.53,116.33 93.29,116.57 92.91,116.57 92.39,117.1 92.14,117.1 91.66,117.58 91.31,117.58 90.87,118.03 90.55,118.03 90.32,118.16 89.89,118.59 89.58,118.59 89.04,119.13 88.66,119.13 88.1,119.68 87.71,119.68 85.81,120.79 84.92,121.41 81.91,124.42 81.91,125.5 79.73,127.67 75.75,127.67 68.83,134.59 68.83,143.74 58.45,154.12 57.71,154.12 57.59,154.01 57.59,153.53 57.48,153.42 57.25,153.42 57.13,153.53 57.13,154.01 57.02,154.12 56.79,154.12 56.68,154.01 56.68,153.53 56.56,153.42 56.33,153.42 56.22,153.53 56.22,154.01 56.11,154.12 55.88,154.12 55.76,154.01 55.76,153.53 55.65,153.42 55.42,153.42 55.31,153.53 55.31,154.01 55.19,154.12 54.96,154.12 54.85,154.01 54.85,153.53 54.73,153.42 54.51,153.42 54.39,153.53 54.39,154.01 54.28,154.12 53.67,154.12 51.08,156.72 48.59,156.72 48.11,157.2 48.11,158.37 47.34,159.13 46.84,159.13 46.41,159.56 46.13,159.57 44.1,159.57 43.82,159.29 43.82,159.17 v2(43.53,158.88)
HPS_GPIO41: length 77
  TOP w0.109: J5.44 43.11,148.15 43.43,147.83 v2(43.68,147.83)
  ART20 w0.114: v2(43.68,147.83) 43.68,148.24 43.69,148.25 43.69,148.87 44.6,149.78 46.35,149.78 46.46,149.67 46.46,149.3 46.58,149.18 46.81,149.18 46.92,149.3 46.92,149.67 47.04,149.78 47.93,149.78 48.71,150.57 52.86,150.57 54.49,148.93 55.38,148.93 55.85,148.46 59.15,148.46 59.34,148.28 59.5,148.28 59.59,148.37 59.75,148.37 59.91,148.21 59.91,148.05 59.82,147.96 59.82,147.79 59.98,147.63 60.15,147.63 60.24,147.72 60.4,147.72 60.56,147.56 60.56,147.4 60.47,147.31 60.47,147.15 60.63,146.99 60.79,146.99 60.88,147.08 61.05,147.08 61.21,146.92 61.21,146.75 61.12,146.66 61.12,146.5 61.28,146.34 61.44,146.34 61.53,146.43 61.69,146.43 61.85,146.27 61.85,146.11 61.76,146.02 61.76,145.25 62.11,144.9 62.11,144.76 62.65,144.22 63.23,144.22 63.5,144.49 63.63,144.49 63.79,144.33 63.79,144.17 63.7,144.08 63.7,143.91 63.86,143.75 64.02,143.75 64.12,143.85 64.28,143.85 64.44,143.68 64.44,143.52 64.35,143.43 64.35,143.27 64.71,142.9 64.71,131.47 69.44,126.74 69.44,124.97 70.58,123.82 72.62,123.82 74.14,122.3 74.14,121.54 75.16,120.52 76.25,120.52 76.37,120.41 76.37,120 76.48,119.89 76.71,119.89 76.83,120 76.83,120.41 76.94,120.52 77.17,120.52 77.28,120.41 77.28,120 77.4,119.89 77.63,119.89 77.74,120 77.74,120.41 77.85,120.52 79.73,120.52 83.86,116.39 84.61,116.39 84.8,116.2 85.51,116.2 85.8,116.49 86.52,116.49 87.08,115.93 v2(87.08,115.6)
HPS_GPIO42: length 89.4
  TOP w0.109: v2(42.8,153.92) 42.61,154.11 J5.45
  ART16 w0.114: v2(42.8,153.92) 42.51,154.22 42.51,155.06 42.49,155.08 42.49,158.72 43.91,160.15 49.96,160.15 52.98,157.12 52.98,156.46 54.4,155.04 58.63,155.04 58.77,154.9 58.77,154.43 69.34,143.86 69.34,134.68 75.93,128.09 79.9,128.09 82.39,125.6 82.39,124.71 84.94,122.17 85.47,122.17 85.91,121.73 94.24,116.92 94.42,116.74 94.42,111.29 v2(94.01,110.6)
HPS_GPIO43: length 76.4
  TOP w0.109: v2(42.61,148.32) J5.46
  ART20 w0.114: v2(42.61,148.32) 42.91,148.61 42.91,148.72 44.42,150.24 47.77,150.24 49.62,152.08 52.71,152.08 53.7,151.1 58.3,151.1 65.73,143.66 65.73,132.87 70.83,127.77 70.83,127.61 70.48,127.26 70.48,127.1 70.65,126.94 70.81,126.94 71.15,127.28 71.32,127.28 71.48,127.12 71.48,126.96 70.75,126.23 70.75,126.07 70.91,125.91 71.07,125.91 71.8,126.64 71.96,126.64 72.12,126.48 72.12,126.31 71.78,125.97 71.78,125.81 71.94,125.64 72.1,125.64 72.45,125.99 72.61,125.99 73.28,125.32 73.28,125.16 73.04,124.92 73.04,124.76 73.2,124.59 73.36,124.59 73.6,124.83 73.76,124.83 73.93,124.67 73.93,124.51 73.69,124.27 73.69,124.11 73.85,123.95 74.01,123.95 74.25,124.19 74.41,124.19 74.57,124.03 74.57,123.86 74.33,123.62 74.33,123.46 74.49,123.3 74.66,123.3 74.9,123.54 75.06,123.54 75.27,123.33 75.27,123.18 75.64,122.81 78.84,122.81 84.44,117.21 85.69,117.21 85.97,117.49 86.38,117.49 87.08,116.79 v2(87.08,116.6)
HPS_GPIO44: length 91.2
  TOP w0.109: v2(41.78,153.92) 42.11,154.26 J5.47
  ART16 w0.114: v2(41.78,153.92) 41.78,154.34 42.01,154.56 42.01,159 43.66,160.65 50.52,160.65 52.27,158.9 55.37,158.9 56,158.27 57.27,158.27 59.41,156.13 59.41,154.43 69.94,143.9 69.94,134.67 76.1,128.51 80.08,128.51 85.76,122.83 91.24,119.64 91.64,119.64 92.18,119.09 92.49,119.09 93.03,118.55 93.41,118.55 93.81,118.15 94.06,118.15 94.59,117.61 95.1,117.61 95.26,117.45 95.26,112.84 v2(94.87,111.1)
HPS_GPIO45: length 74.2
  TOP w0.109: J5.48 42.11,151.11 42.52,151.51 v2(43.66,151.51)
  ART20 w0.114: v2(87.08,118.6) 86.1,118.6 85.57,119.13 85.06,119.13 79.73,124.46 79.73,125.22 78.84,126.11 77.06,126.11 76.43,126.75 75.79,126.75 70.99,131.55 70.99,131.71 71.16,131.89 71.16,132.05 71,132.21 70.84,132.21 70.66,132.04 70.5,132.04 70.34,132.2 70.34,132.36 70.52,132.54 70.52,132.7 70.35,132.86 70.19,132.86 70.02,132.68 69.85,132.68 69.69,132.84 69.69,133.01 69.87,133.18 69.87,133.34 69.71,133.51 69.55,133.51 69.37,133.33 69.21,133.33 69.05,133.49 69.05,133.65 69.22,133.83 69.22,133.99 69.06,134.15 68.9,134.15 68.72,133.98 68.56,133.98 68.4,134.14 68.4,134.3 68.58,134.48 68.58,134.64 68.41,134.8 68.25,134.8 68.08,134.62 67.91,134.62 67.75,134.78 67.75,134.95 67.93,135.12 67.93,135.28 67.77,135.45 67.61,135.45 67.43,135.27 67.27,135.27 67.03,135.51 67.03,144.53 59.2,152.36 58.37,152.36 58.26,152.47 58.26,152.79 58.14,152.91 57.92,152.91 57.8,152.79 57.8,152.47 57.69,152.36 57.46,152.36 57.34,152.47 57.34,152.79 57.23,152.91 57,152.91 56.89,152.79 56.89,152.47 56.77,152.36 55.26,152.36 55.14,152.47 55.14,152.8 55.03,152.91 54.8,152.91 54.69,152.8 54.69,152.47 54.57,152.36 54.22,152.36 53.23,153.34 48.99,153.34 47.55,151.89 46.71,151.89 46.33,151.51 46.07,151.51 45.57,152.02 45.18,152.02 44.68,151.51 v2(43.66,151.51)
HPS_GPIO46: length 92.5
  TOP w0.109: v2(41.46,157.21) 41.61,157.06 J5.49
  ART16 w0.114: v2(95.74,110.6) 95.91,110.72 96.19,112.68 96.19,118.75 95.79,119.15 95.5,119.15 95.05,119.61 94.78,119.61 94.45,119.93 94.45,121.8 93.23,123.03 84.85,124.98 84,125.18 80.25,128.93 76.27,128.93 70.36,134.85 70.36,144.25 59.83,154.77 59.83,156.31 57.41,158.72 56.23,158.72 55.62,159.33 52.6,159.33 50.16,161.78 43.57,161.78 41.63,159.84 41.56,159.59 v2(41.46,157.21)
HPS_GPIO47: length 76.5
  TOP w0.109: v2(41.61,151.38) J5.50
  ART20 w0.114: v2(87.08,119.6) 86.53,120.45 86.38,120.61 85.26,121.08 84.94,121.41 83.54,123.44 79,127.98 77.1,127.98 68.45,136.63 68.45,145.13 61.98,151.6 61.98,151.76 62.39,152.17 62.39,152.34 62.23,152.5 62.07,152.5 61.66,152.09 61.5,152.09 61.34,152.25 61.34,152.41 61.75,152.82 61.75,152.98 61.58,153.14 61.42,153.14 61.01,152.73 60.85,152.73 60.69,152.9 60.69,153.06 61.1,153.47 61.1,154.64 57.02,158.72 56.26,158.72 55.55,159.43 53.31,159.43 52.38,158.51 52.38,157.19 50.77,155.57 48.23,155.57 42.29,151.57 v2(41.61,151.38)
HPS_PROC_RSTN: length 224.1
  TOP w0.109: U23.V8 v2(45.94,171.12)
  ART03 w0.114: v2(45.94,171.12) 47.52,171.12 47.83,170.81 52.08,170.81 64.26,158.62 94.49,158.62 100.84,164.97 104.52,164.97 109.22,160.27 117.6,160.27 118.49,159.38 134.82,159.38 137.39,156.82 167.66,156.82 168.02,157.17 173.2,157.17 v2(173.53,157.5)
  ART20 w0.114: v2(171.47,91.98) 171.88,91.57 180.72,91.57 182.29,93.14 183.74,93.14 184.07,93.47 184.07,103.75 184.59,104.28 184.59,110.2 183.51,111.28 182.14,111.28 181.54,111.88 181.54,116.02 181.79,116.26 181.79,122.61 180.19,124.21 180.19,125.35 179.68,125.86 179.68,127.51 177.63,129.55 176.87,129.55 175.61,130.81 175.61,134.79 173.49,136.91 173.49,149.57 172.77,150.29 172.77,156.74 v2(173.53,157.5)
HPS_PWREN: length 39.8
  TOP w0.109: J5.51 41.11,156.93 41.04,157 41.04,157.55 41.32,157.83 41.82,157.83 R77.1 42.2,158.18 43.1,159.08 43.1,159.16 45.26,161.31 v3(45.95,161.31) ; U23.R6 v2(43.53,169.52)
  ART05 w0.114: v3(45.78,144.24) 46.16,144.24 49.07,147.14 49.07,152.7 48.16,153.62 48.16,154.13 46.1,156.18 46.1,161.16 v3(45.95,161.31) 46.2,161.57 46.2,163.42 45.82,163.8 45.82,165.35 45.28,165.89 45.03,165.89 44.73,166.19 44.73,168.33 v2(43.53,169.52)
  BOTTOM w0.109: U25.11 v3(45.78,144.24)
HPS_PWRGD: length 31.8
  TOP w0.109: v2(39.24,146.74) 39.9,146.74 39.92,146.75 R73.1 40.61,146.98 J5.54 ; U23.U5 v2(45.14,168.72)
  ART07 w0.114: v2(39.24,146.74) 39.65,147.14 39.65,148.61 39.88,148.85 39.88,149.69 40.87,150.67 40.87,153.39 40.15,154.1 40.15,156.97 41.53,158.35 41.53,160.78 42.16,161.42 42.16,164.47 41.54,165.09 41.54,167.3 41.76,167.51 43.17,167.51 44.37,168.72 v2(45.14,168.72)
I2C_3.3V_ALERTN: length 101
  ART20 w0.114: v2(165.87,91.98) 165.87,92.01 165.5,92.38 164.9,92.38 164.55,92.73 164.55,92.73 164.46,92.81 164.21,92.81 163.88,93.14 163.88,93.73 163.73,93.88 162.15,93.88 161.42,94.61 155.04,94.61 154.38,95.27 154.38,101.57 156.08,103.28 160.73,103.28 163.58,106.12 165.79,106.12 167.84,108.18 167.84,116.43 168.66,117.25 168.66,122.48 167.51,123.62 167.51,124.28 167.07,124.73 167.07,125.51 166.83,125.76 166.12,125.76 165.84,126.03 164.57,126.03 164.08,126.52 158.22,126.52 154.36,130.38 154.36,136.07 154.84,136.55 154.84,152.81 154.4,153.24 146.57,153.24 v2(145.73,152.4)
I2C_3.3V_EN: length 112.9
  TOP w0.254: U45.5 173.61,126.24 173.67,126.17 R852.1 R504.1 v4(175.51,126.9) ; U81.5 v2(166.9,126.24)
  ART03 w0.114: v2(166.9,126.24) 167.56,126.9 v4(175.51,126.9)
  ART05 w0.114: v4(175.51,126.9) 179.17,130.56 180.97,130.56 182.42,132 185.12,132 186,131.11 186,130.18 187.02,129.16 v2(192.91,129.16)
  ART18 w0.114: v2(192.91,129.16) 193.38,128.7 193.38,127.44 192.45,126.51 192.45,125.73 194.87,123.32 194.87,122.61 195.15,122.33 195.15,119.99 195.89,119.25 195.89,98.58 193.8,96.49 193.8,92.58 193.34,92.12 191.69,92.12 190.93,91.36 190.93,89.31 190.38,88.76 190.38,87.18 190.14,86.95 185.9,86.95 183.85,84.89 183.85,84.44 183.51,84.1 182.17,84.1 179.97,81.9 176.87,81.9 174.5,84.27 170.89,84.27 170.56,84.6 168.35,84.6 166.27,86.69 166.27,87.35 166.51,87.59 167.86,87.59 v2(168.27,87.18)
I2C_3.3V_SCL: length 364.2
  TOP w0.109: U31.20 171.69,115.24 v3(171.83,115.38)
  TOP w0.127: v2(172.34,127.83) 172.21,127.7 U45.7
  ART05 w0.114: v2(202.41,104.89) 202.16,105.15 202.16,113.79 198.78,117.17 195.38,117.17 194.5,116.29 192.11,116.29 190.42,117.98 189.33,117.98 188.42,117.07 185.52,117.07 184.15,115.7 179.3,115.7 178.92,115.32 173.96,115.32 173.45,114.81 172.4,114.81 v3(171.83,115.38)
  ART07 w0.114: v2(64.39,44.7) 64.39,47.68 63.73,48.34 63.73,54.36 60.63,57.45 55.35,57.45 55.14,57.25 55.14,56.79 54.31,55.96 53.21,55.96 52.48,55.22 48.97,55.22 48.01,56.18 48.01,57.02 47.24,57.78 42.29,57.78 41.43,56.92 41.43,56.03 v2(41.07,55.68) 40.62,55.68 40.41,55.88 40.41,56.34 38.91,57.83 30.73,57.83 29.41,56.52 22.73,56.52 21.46,55.24 v2(21.46,54.94)
  ART16 w0.114: v2(64.39,44.7) 63.85,44.17 63.85,43.14 64.38,42.61 64.38,32.62 66.12,30.89 90.37,30.89 93.45,27.81 104.62,27.81 109.88,33.07 126.31,33.07 128.37,35.13 138.81,35.13 v2(139.34,35.66) 139.7,35.31 139.7,34.24 137.24,31.78 137.24,29.74 139.52,27.46 151.51,27.46 153.44,25.53 163.89,25.53 166.37,28.02 187.68,28.02 196.06,36.4 196.06,44.38 201.85,50.18 201.85,104.34 v2(202.41,104.89) ; v3(171.83,115.38) 171.17,116.04 171.17,116.61 171.5,116.94 171.5,118.28 169.34,120.45 169.34,124.79 172.34,127.79 v2(172.34,127.83)
  BOTTOM w0.109: v2(41.07,55.68) 41.57,55.18 U32.2 ; v2(21.46,54.94) 21.63,54.78 U33.2 ; U46.1 139.37,35.63 v2(139.34,35.66)
I2C_3.3V_SDA: length 361.7
  TOP w0.109: v3(173.1,115.38) 172.19,114.47 U31.19
  TOP w0.127: U45.6 172.61,127.08 v2(173.35,127.83)
  ART05 w0.114: v2(202.66,105.64) 202.66,114 199.06,117.6 195.12,117.6 194.28,116.76 192.41,116.76 190.63,118.54 189.26,118.54 188.24,117.53 185.36,117.53 184.04,116.2 179.09,116.2 178.7,115.82 173.55,115.82 v3(173.1,115.38)
  ART07 w0.114: v2(64.39,43.43) 63.65,44.17 63.65,46.96 63.26,47.36 63.26,54.17 60.76,56.67 56.21,56.67 54.89,55.35 53.62,55.35 52.91,54.64 48.87,54.64 47.5,56.01 47.5,56.9 47.12,57.28 42.67,57.28 42.06,56.67 v2(42.06,55.65) 42.06,55.07 41.48,54.48 40.72,54.48 39.85,55.35 39.85,56.24 38.69,57.4 30.91,57.4 29.51,56.01 22.96,56.01 22.17,55.22 v2(22.17,54.91)
  ART16 w0.114: v3(173.1,115.38) 173.1,115.41 172.44,116.08 172.44,118.24 170.28,120.4 170.28,122.81 171.47,124 171.47,125.94 v2(173.35,127.83) ; v2(202.66,105.64) 202,105.64 201.42,105.05 201.42,50.58 195.64,44.8 195.64,36.66 187.41,28.43 166.18,28.43 163.73,25.98 153.62,25.98 151.64,27.97 139.7,27.97 137.77,29.9 137.77,31.7 140.31,34.24 140.31,35.41 139.6,36.12 138.91,36.12 v2(138.46,35.66) 127.99,35.66 126.29,33.96 109.62,33.96 103.9,28.23 93.65,28.23 90.56,31.32 66.28,31.32 64.92,32.68 64.92,42.9 v2(64.39,43.43)
  BOTTOM w0.109: U32.3 v2(42.06,55.65) ; v2(138.46,35.66) 138.43,35.63 U46.16 ; v2(22.17,54.91) 22.13,54.87 U33.3
I2C_ADI_ALERTN: length 4.4
  TOP w0.109: R996.2 R927.1
  TOP w0.114: U29.A8 163.28,91.79 162.28,91.79 161.87,92.2 R927.1
I2C_ADI_SCL: length 11.4
  TOP w0.109: U81.7 165.86,127.1 v2(165.64,127.32) 165.45,127.51 R924.1 ; R925.1 v2(170.41,132.97)
  ART05 w0.114: v2(165.64,127.32) 166.09,127.76 167.23,127.76 169.9,130.43 169.9,132.46 v2(170.41,132.97)
I2C_ADI_SDA: length 9.8
  TOP w0.109: U81.6 166.26,127.17 v2(166.41,127.32) 166.72,127.63 R923.1 ; R926.1 v2(170.41,131.7)
  ART05 w0.114: v2(170.41,131.7) 170.41,130.3 167.42,127.32 v2(166.41,127.32)
I2C_ALERTN_R: length 7.8
  ART03 w0.114: v1(202.82,189.99) 203.28,189.53 203.28,188.33 204.62,187 205.38,187 206.07,186.31 206.07,186.03 v2(206.08,186.02)
  BOTTOM w0.109: R563.1 R569.2 206.22,185.88 v2(206.08,186.02)
I2C_ALERTN_R_1: length 7.6
  ART03 w0.114: v1(201.42,124.49) 202.23,123.68 202.23,122.99 203.4,121.82 203.76,121.82 204.68,120.9 v2(204.68,120.52)
  BOTTOM w0.109: R646.1 205.63,119.77 205.61,119.8 R654.2 204.83,120.37 v2(204.68,120.52)
I2C_PCIE_SCL: length 116.5
  TOP w0.109: R235.1 v2(213.97,19.56)
  ART20 w0.114: v2(213.97,19.56) 214.49,20.08 214.49,21.04 213.81,21.72 212.04,21.72 208.89,24.87 208.89,27.46 206.08,30.27 206.08,70.1 204.79,71.39 198.58,71.39 195.9,74.07 182.6,74.07 180.81,75.86 171.99,75.86 170.53,77.32 166.27,77.32 161.92,81.67 161.92,89.74 162.26,90.07 163.49,90.07 163.73,89.84 163.73,89.32 v2(164.27,88.78)
I2C_PCIE_SDA: length 117.8
  TOP w0.109: R236.1 v2(213.97,20.83)
  ART20 w0.114: v2(166.67,90.38) 166.4,90.38 166,89.98 164.12,89.98 163.6,90.5 162.09,90.5 161.5,89.91 161.5,81.47 166.32,76.66 170.46,76.66 171.78,75.34 180.74,75.34 182.42,73.65 195.73,73.65 198.41,70.97 204.62,70.97 205.66,69.93 205.66,30.1 208.4,27.35 208.4,24.51 211.71,21.21 213.73,21.21 213.97,20.97 v2(213.97,20.83)
I2C_VID_ALERTN: length 125.2
  TOP w0.114: R5285.1 R495.2 166.05,164.4 167.1,163.35 v2(167.1,157.61)
  ART20 w0.114: v2(167.1,157.61) 162.61,153.11 157.25,153.11 156.26,152.12 156.26,148.51 156.84,147.93 156.84,143.89 155.45,142.49 155.45,136.35 154.76,135.66 154.76,130.48 158.39,126.85 166.9,126.85 167.39,126.36 167.39,125.22 168.25,124.36 168.25,123.55 169.85,121.95 169.85,120.65 171.81,118.69 171.81,116.97 168.25,113.41 168.25,107.97 165.76,105.49 165.76,104.19 165.23,103.66 162.48,103.66 160.43,101.6 160.43,100.41 160.83,100 160.83,95.79 161.85,94.77 163.29,94.77 164.08,93.98 165.27,93.98 165.48,93.78 165.48,93.17 v2(165.87,92.78)
I2C_VID_SCL: length 76.7
  TOP w0.127: U43.7 v2(180.47,128.08)
  ART03 w0.114: v2(180.47,128.08) 181.47,128.08 182.27,128.88 182.27,132.46 180.11,134.62 180.11,141.65 181.18,142.72 181.18,157.23 v2(180.77,157.63)
  ART16 w0.114: v2(180.77,157.63) 179.9,158.5 176.02,158.5 169.65,164.87 158.2,164.87 158.18,164.84 157.75,164.84 157.72,164.87 153.07,164.87 153.02,164.81 152.59,164.81 152.54,164.87 147.99,164.87 147.94,164.81 147.51,164.81 147.46,164.87 142.46,164.87 142.4,164.92 141.74,164.92 v2(141.22,164.4)
I2C_VID_SDA: length 76.8
  TOP w0.109: v2(182.6,127.96) 182.21,128.36 181.74,128.36 R484.1
  TOP w0.127: U43.6 180.87,127.21 R484.1
  ART03 w0.114: v2(181.73,157.61) 181.73,142.14 180.82,141.22 180.82,134.7 182.83,132.69 182.83,128.19 v2(182.6,127.96)
  ART16 w0.114: v2(181.73,157.61) 181.23,157.1 180.47,157.1 179.58,157.99 175.77,157.99 172.52,161.23 171.89,161.23 171.62,161.5 171.62,162.13 169.54,164.21 142.68,164.21 v2(142.49,164.4)
IREF: length 19.3
  TOP w0.199: U54.47 74.41,204.64 74.14,204.37 v2(73.36,204.37) 73.21,204.51 U54.44 ; C1718.2 70.13,209.26 R6041.1 71.44,209.26 v2(71.68,209.5) 71.94,209.76 ; U54.43 72.28,205.76 71.78,205.26 v2(71.78,205.13) ; C2113.2 74.88,203.92 v2(74.88,204.17) 74.81,204.23 U54.48
  TOP w0.203: U54.33 71.94,209.76
  ART05 w0.199: v2(71.78,205.13) 72.1,204.81 72.33,204.81 72.85,204.3 v2(72.85,204.22) 73.2,204.22 v2(73.36,204.37) 73.81,204.37 73.9,204.28 74.31,204.28 74.42,204.17 v2(74.88,204.17)
  BOTTOM w0.199: 72.69,205.13 72.69,209.15 72.34,209.5 v2(71.68,209.5) ; 72.69,205.13 72.93,204.9 72.93,204.58 72.9,204.56 72.9,204.27 v2(72.85,204.22) ; 72.69,205.13 v2(71.78,205.13)
ISENSE0: length 22.1
  TOP w0.199: R5883.2 77.04,202.11 v2(77.04,201.68) ; v2(78.75,205.98) 78.75,206.25 78.05,206.96 U54.4
  TOP w0.254: v2(84.79,199.54) 84.87,199.46 U87.33
  ART18 w0.199: v2(84.79,199.54) 83.87,199.54 82.75,200.66 78.82,200.66 77.7,201.78 77.7,203.02 78.46,203.78 78.46,205.69 v2(78.75,205.98)
  BOTTOM w0.199: v2(77.04,201.68) 77.42,202.06 77.42,203.29 78.41,204.28 78.41,205.64 v2(78.75,205.98)
ISENSE2: length 53.7
  TOP w0.199: v2(74.75,202.62) 74.7,202.56 R5881.2 ; v2(77.84,206.48) 77.68,206.48 77.6,206.56 U54.3
  TOP w0.254: v2(112.7,198.63) 112.76,198.57 U89.33
  ART05 w0.199: v2(112.7,198.63) 112.34,198.98 112.34,200.1 109.93,202.51 103.02,202.51 102.11,201.6 96.72,201.6 95.86,202.46 92.25,202.46 90.75,200.96 90.75,199.67 89.79,198.7 88,198.7 87.72,198.98 85.93,198.98 85.65,198.7 84.3,198.7 82.25,200.75 78.96,200.75 77.09,202.62 v2(74.75,202.62)
  BOTTOM w0.199: v2(74.75,202.62) 76.15,204.01 76.99,204.01 77.19,204.21 77.19,204.71 76.79,205.12 76.79,206 77.27,206.48 v2(77.84,206.48)
ISENSE3: length 72.8
  TOP w0.199: R5997.2 73.04,202.56 v2(73.48,203) ; U54.52 76.41,204.77 v2(76.71,204.47)
  TOP w0.254: U90.33 125.86,198.19 v2(125.88,198.21)
  ART18 w0.199: v2(76.71,204.47) 76.71,207.72 78.82,209.83 84.99,209.83 85.34,209.47 89.89,209.47 90.65,210.24 96.52,210.24 98.73,208.03 102.97,208.03 105.28,210.34 122.07,210.34 124.31,208.1 124.31,201.68 125.88,200.1 v2(125.88,198.21)
  BOTTOM w0.199: v2(73.48,203) 73.48,203.68 74.73,204.93 76.25,204.93 v2(76.71,204.47)
ISENSE4: length 32.4
  TOP w0.199: v2(98.99,198.79) 98.96,198.77 U88.33 ; U54.51 76.01,204.53 76.5,204.04 77.07,204.04 77.27,204.24 77.55,204.24 v2(77.65,204.34) 77.65,204.27 77.85,204.06 R5882.2
  ART07 w0.199: v2(98.99,198.79) 98.61,198.79 97.84,199.57 95.35,199.57 94.64,200.28 94.64,201.75 94.63,201.76 94.63,201.94 93.68,202.89 92.33,202.89 91.65,202.21 87.41,202.21 87.38,202.19 86.13,202.19 84.43,200.48 82.42,200.48 81.33,201.57 81.33,203.73 81.04,204.03 77.97,204.03 v2(77.65,204.34)
ISENSE_12VIN: length 200.7
  ART16 w0.254: v2(31.85,194.12) 28.06,190.33 28.06,188.08 27.08,187.1 13.97,187.1 9.63,182.75 9.63,178.51 6.91,175.79 6.91,171.02 9.7,168.22 9.7,161.01 10.08,160.63 10.08,160.52 15.74,154.86 29.1,154.86 32.06,151.9 32.06,148.48 34.16,146.38 34.9,146.38 36.98,144.3 36.98,128.22 40.87,124.33 40.87,114.81 34.42,108.35 34.42,108.34 34.26,108.18 34.26,92.69 38.48,88.47 38.48,84.18 41.15,81.51 41.15,73.85 40.28,72.98 40.28,59.49 37.44,56.64 37.44,49.83 37.87,49.4 43.92,49.4 44.64,48.68 44.87,48.68 44.94,48.6 v2(44.98,48.6)
  BOTTOM w0.254: v2(44.98,48.6) 44.97,48.6 45.06,48.7 U32.23
ISENSEN_VCCCLK_GXE_FPGA_2.5V: length 117.5
  TOP w0.254: v2(53.7,129.69) 53.74,129.64 V19.2
  ART05 w0.254: v2(53.7,129.69) 53.55,129.54 34.04,129.54 28.19,123.7 28.19,119.91 26.75,118.47 26.75,89.44 26.75,89.43 26.75,67.26 20.27,60.79 20.27,56.79 21.43,55.63 24.97,55.63 30.48,50.11 30.48,48.38 31.26,47.6 33.36,47.6 v3(33.97,46.99)
ISENSEN_VCCFUSEWR_SDM_FPGA_2.4V: length 26
  TOP w0.254: V21.2 v2(48.21,47.96)
  ART05 w0.254: v2(48.21,47.96) 48.37,48.13 48.37,48.46 48.12,48.72 47.48,48.72 46.97,49.23 44.23,49.23 40.21,45.21 38.23,45.21 37.72,44.7 36.02,44.7 35.56,45.16 32.31,45.16 31.22,44.07 27.85,44.07 27.37,44.55 27.37,44.83 v3(27,45.2)
ISENSEN_VCCH_GXE_FPGA_1.1V: length 46.4
  ART03 w0.254: v3(33.97,55.02) 33.97,55.36 34.21,55.6 34.82,55.6 35.89,56.67 35.89,59.86 34.06,61.7 20.01,61.7 11.43,53.12 11.43,51.46 11.02,51.05 10.64,51.05 8.08,48.49 8.08,46.79 7.03,45.75 6.27,45.75 6.07,45.54 6.02,45.54 v2(5.87,45.69)
  BOTTOM w0.254: V13.2 5.38,45.52 5.74,45.52 5.87,45.64 5.87,45.69 v2(5.87,45.69)
ISENSEN_VCCIO_FPGA_1.5V: length 13
  ART03 w0.254: v3(33.97,49.68) 33.97,50.21 33.77,50.42 33.43,50.42 33.05,50.03 33.05,45.92 31.5,44.37 31.5,42.09 32.29,41.3 32.76,41.3 v2(32.96,41.5)
  BOTTOM w0.254: v2(32.96,41.5) 33.1,41.35 33.45,41.35 V17.2
ISENSEN_VCCIO_FPGA_1.8V: length 154.6
  TOP w0.254: V25.2 35.56,139.22 36.02,139.22 v2(36.28,139.48)
  ART03 w0.254: v3(33.97,52.35) 33.97,52.7 34.23,52.96 35.97,52.96 39.37,56.36 39.37,63.37 20.9,81.84 20.9,96.82 22.25,98.17 22.25,120.81 21.14,121.92 19.84,121.92 18.52,123.25 18.52,124.22 18.47,124.26 18.47,130.7 19.24,131.47 19.46,131.47 20.27,132.27 20.27,135.92 17.78,138.4 15.29,138.4 14.71,138.99 14.71,150.65 16.1,152.04 16.1,153.13 18.24,155.27 27.15,155.27 29.13,153.29 30.6,153.29 36.32,147.57 36.32,145.08 37.36,144.04 37.36,139.9 36.79,139.33 36.43,139.33 v2(36.28,139.48)
ISENSEN_VCCL_HPS_FPGA_0.9V: length 27.3
  ART03 w0.254: v3(23.57,57.42) 23.14,57.11 23.14,56.44 22.4,55.7 19.76,55.7 17.32,53.26 17.32,51.33 15.27,49.28 15.27,47.61 15.98,46.89 15.98,43.56 16.99,42.55 16.99,41.71 17.78,40.92 21.64,40.92 21.72,41 v2(21.72,41.07)
  BOTTOM w0.254: V9.2 21.28,40.92 21.57,40.92 v2(21.72,41.07)
ISENSEN_VCCL_SDM_FPGA_0.8V: length 124.7
  ART05 w0.254: v2(127.61,27.19) 127.46,27.04 127.1,27.04 126.46,27.69 125.53,27.69 120.14,33.07 111.59,33.07 101.38,43.28 92.41,43.28 89.59,46.1 89.59,51.44 89,52.02 89,54.95 87.64,56.31 73.91,56.31 71.89,54.3 56.62,54.3 56.46,54.13 53.94,54.13 53.64,53.82 51.81,53.82 51.33,53.35 51.33,52 50.75,51.41 48.01,51.41 47.04,52.37 47.04,53.57 46.41,54.2 40.84,54.2 38.96,56.08 27.95,56.08 27.51,56.52 27.51,57.09 v3(27.84,57.42)
  BOTTOM w0.127: V11.2 128.12,26.96 127.83,26.96 v2(127.61,27.19)
ISENSEN_VDD_SODIMM: length 107.4
  ART05 w0.254: v3(23.52,45.15) 23.82,44.85 23.82,43.46 27.6,39.68 33.69,39.68 35.41,41.4 37.08,41.4 38.2,42.52 47.33,42.52 48.7,43.89 52.31,43.89 55.16,41.05 74.85,41.05 76.1,39.8 76.1,33.6 78.43,31.27 89.81,31.27 92.96,28.12 111.23,28.12 113.18,30.07 113.18,31.11 v2(113.4,31.33)
  BOTTOM w0.254: V23.2 v2(113.4,31.33)
ISENSEP_VCCCLK_GXE_FPGA_2.5V: length 116.2
  TOP w0.254: v2(53.72,128.98) 53.78,129.03 V18.2
  ART05 w0.254: v3(33.97,48.59) 33.36,47.98 31.42,47.98 30.86,48.54 30.86,50.27 25.13,56.01 21.59,56.01 20.65,56.95 20.65,60.63 27.13,67.11 27.13,89.28 27.13,89.28 27.13,118.31 28.57,119.76 28.57,123.54 34.19,129.16 53.54,129.16 v2(53.72,128.98)
ISENSEP_VCCFUSEWR_SDM_FPGA_2.4V: length 26
  TOP w0.254: V20.2 v2(48.92,47.96)
  ART05 w0.254: v2(48.92,47.96) 48.76,48.12 48.76,48.62 48.28,49.1 47.64,49.1 47.13,49.61 44.07,49.61 40.06,45.59 38.07,45.59 37.56,45.09 36.18,45.09 35.72,45.54 32.15,45.54 31.06,44.45 28.01,44.45 27.75,44.7 27.75,44.82 28.12,45.19 v3(28.12,45.2)
ISENSEP_VCCH_GXE_FPGA_1.1V: length 45.1
  ART03 w0.254: v3(33.97,56.62) 33.97,56.24 34.23,55.98 34.67,55.98 35.51,56.83 35.51,59.71 33.9,61.32 20.17,61.32 11.81,52.96 11.81,51.3 11.18,50.67 10.8,50.67 8.46,48.33 8.46,46.63 7.19,45.36 6.43,45.36 6.23,45.16 6.02,45.16 v2(5.84,44.98)
  BOTTOM w0.254: V12.2 5.41,45.06 5.77,45.06 v2(5.84,44.98)
ISENSEP_VCCIO_FPGA_1.5V: length 14
  ART03 w0.254: v2(33.02,40.79) 32.89,40.92 32.13,40.92 31.11,41.94 31.11,44.53 32.66,46.08 32.66,50.19 33.27,50.8 33.72,50.8 33.97,51.05 v3(33.97,51.28)
  BOTTOM w0.254: v2(33.02,40.79) 33.12,40.89 33.48,40.89 V16.2
ISENSEP_VCCIO_FPGA_1.8V: length 155.8
  TOP w0.254: v2(36.27,138.76) 36.2,138.84 35.53,138.84 V24.2
  ART03 w0.254: v3(33.97,53.95) 33.97,53.59 34.23,53.34 35.81,53.34 38.99,56.52 38.99,63.22 20.52,81.68 20.52,96.98 21.87,98.33 21.87,120.65 20.98,121.54 19.68,121.54 18.14,123.09 18.14,124.06 18.09,124.1 18.09,130.86 19.08,131.85 19.31,131.85 19.89,132.43 19.89,135.76 17.62,138.02 15.13,138.02 14.33,138.83 14.33,150.81 15.72,152.2 15.72,153.29 18.08,155.65 27.3,155.65 29.29,153.67 30.76,153.67 36.7,147.73 36.7,145.24 37.74,144.2 37.74,139.75 36.95,138.95 36.46,138.95 v2(36.27,138.76)
ISENSEP_VCCL_HPS_FPGA_0.9V: length 27.8
  ART03 w0.254: v2(21.72,40.35) 21.72,40.36 21.54,40.54 17.62,40.54 16.61,41.55 16.61,42.39 15.6,43.4 15.6,46.74 14.88,47.45 14.88,49.43 16.94,51.49 16.94,53.42 19.6,56.08 22.24,56.08 22.76,56.6 22.76,57.11 22.55,57.4 v3(22.5,57.42)
  BOTTOM w0.254: v2(21.72,40.35) 21.66,40.41 21.31,40.41 V8.2
ISENSEP_VCCL_SDM_FPGA_0.8V: length 125.4
  ART05 w0.254: v2(127.61,26.41) 127.37,26.64 126.96,26.64 126.3,27.3 125.37,27.3 119.98,32.69 111.43,32.69 101.22,42.9 92.25,42.9 89.2,45.94 89.2,51.28 88.62,51.86 88.62,54.79 87.48,55.93 74.07,55.93 72.05,53.91 56.78,53.91 56.61,53.75 54.1,53.75 53.8,53.44 51.97,53.44 51.71,53.19 51.71,51.84 50.9,51.03 47.85,51.03 46.66,52.22 46.66,53.41 46.25,53.82 40.69,53.82 38.81,55.7 27.79,55.7 27.13,56.36 27.13,57.06 v3(26.77,57.42)
  BOTTOM w0.127: v2(127.61,26.41) 127.91,26.71 128.09,26.71 V10.2
ISENSEP_VDD_SODIMM: length 106
  ART05 w0.254: v2(112.53,31.28) 112.8,31.01 112.8,30.23 111.07,28.5 93.12,28.5 89.97,31.65 78.59,31.65 76.48,33.76 76.48,39.96 75.01,41.43 55.31,41.43 52.47,44.27 48.55,44.27 47.17,42.9 38.04,42.9 36.93,41.78 35.25,41.78 33.53,40.06 27.75,40.06 24.2,43.62 24.2,44.91 v3(24.43,45.15)
  BOTTOM w0.254: V22.2 v2(112.53,31.28)
ITH0: length 3.7
  TOP w0.109: U54.9 78.91,208.96 79.36,209.4 C1720.2
ITHR0: length 4.3
  TOP w0.199: C1721.1 80.36,210.78 80.09,210.78 78.67,209.36 U54.10
JTAG_RX: length 204.1
  TOP w0.109: v2(138.05,212.09) 138.62,211.52 D15.1 ; U23.B3 v2(32.33,167.12)
  ART16 w0.114: v2(138.05,212.09) 139.01,211.12 139.01,205.19 139.21,204.99 139.21,202.52 141.86,199.87 141.86,197.23 140.34,195.71 140.34,192.91 135.13,187.71 135.13,169.16 134.49,168.53 132.16,168.53 130.51,166.88 99.95,166.88 93.22,160.15 83.1,160.15 78.23,165.02 78.23,183.39 76.45,185.17 55.63,185.17 54.61,184.15 48.9,184.15 46.93,186.12 40.58,186.12 39.37,187.32 37.34,187.32 37.08,187.07 37.08,185.93 35.94,184.78 30.99,184.78 28.01,181.81 27.38,181.81 27.06,181.49 27.06,180.05 27.44,179.67 27.44,173.16 29.64,170.97 29.64,170.13 31.12,168.66 31.26,168.66 31.51,168.41 31.86,168.41 32.33,167.94 v2(32.33,167.12)
JTAG_TX: length 199.6
  TOP w0.109: U23.A3 v2(31.53,167.92)
  ART16 w0.114: v2(31.53,167.92) 29.66,167.92 28.34,169.24 28.34,171.65 27.02,172.97 27.02,179.32 26.64,179.7 26.64,182.22 27.18,182.75 28.32,182.75 31.5,185.93 33.02,185.93 33.66,185.29 35.31,185.29 35.81,185.8 35.81,186.44 37.21,187.83 39.88,187.83 40.89,186.82 47.12,186.82 48.51,185.42 50.55,185.42 50.8,185.17 54.86,185.17 55.37,185.67 76.71,185.67 78.74,183.64 78.74,165.23 83.31,160.66 93.09,160.66 99.82,167.39 130.3,167.39 131.38,168.47 131.38,170.5 134.62,173.74 134.62,187.96 139.83,193.17 139.83,199.8 138.79,200.83 138.79,204.82 137.87,205.74 137.87,210.05 v2(136.4,211.52)
LMK05028_PDN: length 372.8
  TOP w0.109: U38.46 186.27,50.67 187.09,49.85 R850.2 186.92,49.34 186.92,48.51 187.42,48.01 R454.1 186.6,47.81 v2(186.54,47.75) ; U23.R2 v2(43.53,166.32)
  ART03 w0.114: v2(43.53,166.32) 43.13,165.92 43.13,165.2 44.3,164.04 44.3,160.7 43,159.41 43,158.42 42.8,158.22 42.8,156.11 44.78,154.13 44.78,152.35 44.9,152.22 44.9,150.47 46.67,148.7 46.67,143.88 45.34,142.54 44.22,142.54 37.85,136.17 34.01,136.17 33.14,135.3 33.14,131.08 33.35,130.87 33.35,115.77 33.06,115.49 33.06,114.89 33.09,114.86 33.09,112.95 43.69,102.36 43.72,102.36 43.82,102.26 47.5,102.26 48.71,101.04 48.71,99.03 49.43,98.32 49.43,88.01 50.6,86.84 50.6,82.83 52.35,81.08 58.7,81.08 62.71,77.06 71.45,77.06 73.86,74.65 73.86,71.6 77.6,67.87 80.78,67.87 83.41,65.23 83.41,59.92 83.82,59.51 83.82,45.47 85.6,43.69 87.12,43.69 88.57,42.24 88.57,37.82 89.2,37.19 89.2,34.67 90.27,33.6 92.84,33.6 98.04,28.39 98.04,22.63 99.54,21.13 101.35,21.13 103.28,19.2 112.55,19.2 113.26,19.91 113.26,29.67 115.77,32.18 137.11,32.18 v2(138.3,30.99) ; v2(186.54,47.75) 188.98,45.31 188.98,43.28 186.46,40.77 145.19,40.77 v2(142.16,43.79)
  ART16 w0.114: v2(138.3,30.99) 147.19,39.88 186.2,39.88 188.14,41.81 188.14,46.34 187.02,47.46 186.83,47.46 v2(186.54,47.75)
LTM4608_BSEL1: length 5.4
  ART07 w0.114: v1(25.78,37.72) 28.8,40.74 v2(29.18,40.74)
  BOTTOM w0.109: v2(29.18,40.74) 29.36,40.56 R6075.1
LTM4608_BSEL2: length 9.3
  ART07 w0.114: v2(143.4,21.86) 138.6,21.86 137.39,20.65 136.32,20.65 v1(135.61,19.94)
  BOTTOM w0.109: v2(143.4,21.86) 143.4,21.2 R6076.1
LTM4608_BSEL3: length 6.4
  ART07 w0.114: v2(12.76,43.78) 11.39,43.78 v1(8.38,40.77)
  BOTTOM w0.109: R6077.1 v2(12.76,43.78)
LTM4608_BSEL4: length 14.2
  ART20 w0.114: v2(28.9,130.69) 24.08,135.5 24.08,140.49 v1(23.39,141.17)
  BOTTOM w0.109: R6078.1 29.11,130.48 28.9,130.69 v2(28.9,130.69)
LTM4608_BSEL5: length 11.4
  ART03 w0.114: v1(43.05,39.88) 43.94,40.77 43.94,44.7 44.42,45.19 48.69,45.19 v2(49.12,44.75)
  BOTTOM w0.109: R6079.1 49.29,44.59 v2(49.12,44.75)
LTM4608_BSEL6: length 10.6
  ART05 w0.114: v2(120.42,20.29) 113.31,20.29 113.13,20.47 111.4,20.47 v1(110.87,19.94)
  BOTTOM w0.109: v2(120.42,20.29) 120.59,20.13 R6080.1
LTM4608_BSEL7: length 8.2
  ART05 w0.114: v2(162.46,14.33) 162.97,14.83 162.97,15.82 v1(158.85,19.94)
  BOTTOM w0.109: R6081.1 v2(162.46,14.33)
LTM4608_BSEL8: length 9
  ART05 w0.114: v1(90.73,19.94) 91.39,20.6 92.2,20.6 93.01,21.41 93.01,23.57 v2(95.31,25.87)
  BOTTOM w0.109: R6082.1 v2(95.31,25.87)
LTM4608_FB1: length 13.4
  ART03 w0.114: v1(25.78,33.91) 25.2,34.49 25.2,42.67 26.34,43.81 v2(26.9,43.81)
  BOTTOM w0.109: C1946.1 28.23,43.04 R684.1 v2(26.9,43.81)
LTM4608_FB2: length 12.1
  ART20 w0.114: v2(140.93,17.97) 137.99,17.97 136.7,19.25 132.49,19.25 v1(131.8,19.94)
  BOTTOM w0.109: v2(140.93,17.97) R5400.1 C1947.1
LTM4608_FB3: length 13.7
  ART05 w0.114: v1(8.38,36.96) 10.44,39.01 10.44,42.57 12.42,44.55 v2(15.06,44.55)
  BOTTOM w0.109: v2(15.06,44.55) R5409.1 14.47,45.01 14.48,45.03 C1948.1
LTM4608_FB4: length 27.6
  ART03 w0.114: v1(23.39,144.98) 24.03,144.35 24.03,139.55 24.23,139.34 24.23,137.49 24.38,137.34 24.38,122 v2(24.99,121.39)
  BOTTOM w0.109: R5418.1 23.85,121.23 24.3,120.79 C1949.1 v2(24.99,121.39)
LTM4608_FB5: length 12.5
  ART07 w0.114: v2(38.9,44.56) 40.21,43.26 40.51,43.26 42.34,41.43 42.34,36.78 v1(43.05,36.07)
  BOTTOM w0.109: C1950.1 R5427.1 v2(38.9,44.56)
LTM4608_FB6: length 16.2
  ART05 w0.114: v2(116.97,18.82) 108.18,18.82 v1(107.06,19.94)
  BOTTOM w0.109: R760.2 118.3,19.07 118.31,19.06 118.31,18.2 R759.1 118.24,17.51 C1951.1 116.66,18 116.66,18.35 R6066.1 v2(116.97,18.82)
LTM4608_FB7: length 11.2
  ART20 w0.114: v1(155.04,19.94) 155.94,19.04 v2(163.82,19.04)
  BOTTOM w0.109: v2(163.82,19.04) 163.56,19.29 R5445.1 C1954.1
LTM4608_FB8: length 12.5
  ART05 w0.254: v1(86.92,19.94) 88.04,18.82 v2(96.82,18.82)
  BOTTOM w0.254: C1957.1 96.05,17.56 R5454.1 v2(96.82,18.82)
LTM4608_MGN1: length 13.7
  ART07 w0.114: v2(34.49,35.2) 33.88,35.81 25.63,35.81 25.17,36.27 25.17,37.06 v1(24.51,37.72)
  BOTTOM w0.109: v2(34.49,35.2) 34.68,35.01 R5391.2 R5392.1
LTM4608_MGN2: length 21
  ART03 w0.114: v1(135.61,21.21) 134.95,20.55 124.1,20.55 121.81,18.25 v2(121.81,14.39)
  BOTTOM w0.109: R5398.1 R5394.2 v2(121.81,14.39)
LTM4608_MGN3: length 14
  ART07 w0.114: v2(17.23,36.92) 16.39,37.76 15.45,37.76 14.48,38.74 14.48,39.24 13.56,40.16 7.72,40.16 v1(7.11,40.77)
  BOTTOM w0.109: R5407.1 R5403.2 v2(17.23,36.92)
LTM4608_MGN4: length 23.4
  ART05 w0.114: v2(16.28,125.12) 16.28,134.9 20.37,138.99 23.62,138.99 24.05,139.42 24.05,140.56 v1(24.66,141.17)
  BOTTOM w0.109: v2(16.28,125.12) R5412.2 R5416.1
LTM4608_MGN5: length 21.1
  ART03 w0.114: v1(41.78,39.88) 41.22,39.32 41.22,33.4 41.81,32.82 50.85,32.82 v2(51.54,32.13)
  BOTTOM w0.109: v2(51.54,32.13) 52.62,31.05 R5421.2 R5425.1
LTM4608_MGN6: length 19.5
  ART20 w0.114: v1(110.87,21.21) 110.19,20.52 105.66,20.52 105.11,19.96 105.11,11.33 v2(105.96,10.48)
  BOTTOM w0.109: R5430.2 108.45,11.47 108.4,11.42 R5434.1 106.9,11.42 v2(105.96,10.48)
LTM4608_MGN7: length 17.6
  BOTTOM w0.109: v1(158.85,21.21) 158.24,20.6 154.86,20.6 154.58,20.32 154.58,19.94 154.12,19.48 153.69,19.48 153.31,19.1 153.31,18.48 153.58,18.21 153.65,18.21 154.28,17.58 154.28,14.61 153.77,14.09 152.17,14.09 151.7,13.63 R5439.2 149.3,13.63 R5443.1
LTM4608_MGN8: length 13.6
  ART20 w0.114: v2(94.69,12.12) 94.69,18.14 92.3,20.52 91.41,20.52 v1(90.73,21.21)
  BOTTOM w0.109: v2(94.69,12.12) 94.08,11.51 R5448.2 R5452.1
LTM4608_MODE1: length 3.4
  BOTTOM w0.109: R6045.2 28.36,40.27 27.84,39.75 27.84,38.2 v1(28.32,37.72)
LTM4608_MODE2: length 3.5
  BOTTOM w0.109: R6049.2 138.34,17.93 136.14,17.93 v1(135.61,17.4)
LTM4608_MODE3: length 2.6
  BOTTOM w0.109: v1(10.92,40.77) 10.41,41.27 10.41,42.29 10.81,42.68 R6053.2
LTM4608_MODE4: length 23.5
  ART20 w0.114: v1(20.85,141.17) 21.69,141.17 22.86,140 22.86,138.71 23.7,137.87 23.7,133.88 27.37,130.21 30.42,130.21 30.76,129.87 30.76,127.64 v2(29.79,126.67)
  BOTTOM w0.109: R6057.2 28.74,125.62 v2(29.79,126.67)
LTM4608_MODE5: length 3
  BOTTOM w0.109: v1(45.59,39.88) 45.06,40.41 45.06,41.76 45.5,42.2 R6061.2
LTM4608_MODE6: length 6.6
  ART03 w0.114: v1(110.87,17.4) 111.61,16.66 115.29,16.66 v2(116.05,15.9)
  BOTTOM w0.109: R6065.2 115.82,16.13 v2(116.05,15.9)
LTM4608_MODE7: length 3.5
  BOTTOM w0.109: v1(158.85,17.4) 159.33,17.88 160.68,17.88 161.48,17.08 R6070.2
LTM4608_MODE8: length 4.3
  BOTTOM w0.109: v1(90.73,17.4) 91.19,16.94 93.04,16.94 93.33,16.65 R6074.2
LTM4608_PHMODE1: length 4.3
  ART07 w0.114: v2(31.4,40.55) 30.28,39.43 30.28,38.4 v1(29.59,37.72)
  BOTTOM w0.109: v2(31.4,40.55) 31.6,40.75 R6044.1
LTM4608_PHMODE2: length 5.4
  ART07 w0.114: v2(139.04,14.73) 137.67,14.73 136.91,15.49 136.25,15.49 v1(135.61,16.13)
  BOTTOM w0.109: R6046.1 139.53,14.24 v2(139.04,14.73)
LTM4608_PHMODE3: length 9.7
  ART03 w0.114: v2(15.11,45.52) 14.83,45.8 13.34,45.8 13.03,45.49 13.03,44.58 13.39,44.22 13.39,43.33 12.9,42.85 12.9,41.48 v1(12.19,40.77)
  BOTTOM w0.109: v2(15.11,45.52) 15.82,44.81 R6050.1
LTM4608_PHMODE4: length 18.4
  ART20 w0.114: v2(30.15,129.79) 26.8,129.79 20.98,135.61 20.98,137.29 20.19,138.07 20.19,140.56 v1(19.58,141.17)
  BOTTOM w0.109: R6054.1 30.24,129.71 v2(30.15,129.79)
LTM4608_PHMODE5: length 5.9
  ART03 w0.114: v2(47.56,44.74) 47.56,40.58 v1(46.86,39.88)
  BOTTOM w0.109: R6058.1 v2(47.56,44.74)
LTM4608_PHMODE6: length 11.5
  ART05 w0.114: v1(110.87,16.13) 111.44,16.7 113.22,16.7 114.45,17.93 119.74,17.93 v2(120.59,18.78)
  BOTTOM w0.109: R6062.1 v2(120.59,18.78)
LTM4608_PHMODE7: length 7.8
  ART03 w0.114: v1(158.85,16.13) 158.19,15.47 158.19,14.1 159.44,12.85 v2(162.31,12.85)
  BOTTOM w0.109: v2(162.31,12.85) 162.46,13 R6067.1
LTM4608_PHMODE8: length 11.5
  ART07 w0.114: v2(95.29,24.5) 93.55,22.76 93.55,17.91 92.38,16.74 91.34,16.74 v1(90.73,16.13)
  BOTTOM w0.109: R6071.1 v2(95.29,24.5)
LTM4608_SVIN_1: length 8.4
  ART05 w0.203: v1(29.59,32.64) 29.59,33.78 30.38,34.57 34.57,34.57 35.03,35.03 35.03,35.36 v2(35.36,35.69)
  BOTTOM w0.203: R5390.2 v2(35.36,35.69)
LTM4608_SVIN_2: length 10.7
  ART05 w0.254: v1(130.53,16.13) 131.17,15.49 139.85,15.49 v3(140.02,15.66)
  BOTTOM w0.254: v3(140.02,15.66) R5401.2
LTM4608_SVIN_3: length 7.4
  ART05 w0.203: v1(12.19,35.69) 12.83,35.05 16.66,35.05 v2(18.14,33.58)
  BOTTOM w0.254: R5410.2 v2(18.14,33.58)
LTM4608_SVIN_4: length 24.7
  ART03 w0.114: v1(19.58,146.25) 20.39,145.45 21.13,145.45 21.59,144.98 21.59,139.88 21.13,139.42 21.13,136.57 21.46,136.23 21.46,132.01 20.05,130.6 v2(20.05,124.55)
  BOTTOM w0.109: R5419.2 v2(20.05,124.55)
LTM4608_SVIN_5: length 12
  ART05 w0.203: v1(46.86,34.8) 47.45,34.21 48.31,34.21 48.84,33.68 48.84,26.8 v2(50.14,25.5)
  BOTTOM w0.203: R5428.2 v2(50.14,25.5)
LTM4608_SVIN_6: length 11.7
  ART05 w0.254: v3(115.02,13.4) 114.27,14.15 106.81,14.15 106.5,14.45 106.5,15.42 v1(105.79,16.13)
  BOTTOM w0.254: v3(115.02,13.4) R5437.2
LTM4608_SVIN_7: length 10
  ART05 w0.203: v2(162.43,15.67) 161.34,16.76 154.41,16.76 v1(153.77,16.13)
  BOTTOM w0.254: R5446.2 v2(162.43,15.67)
LTM4608_SVIN_8: length 11.5
  ART05 w0.254: v1(85.65,16.13) 86.31,16.79 93.27,16.79 v2(95.21,14.85)
  BOTTOM w0.254: R5455.2 v2(95.21,14.85)
LTM4608_TRACK1: length 11.1
  ART07 w0.114: v1(28.32,33.91) 28.85,34.44 34.39,34.44 34.92,34.98 34.92,37.57 v2(35.36,38)
  BOTTOM w0.109: R5390.1 v2(35.36,38)
LTM4608_TRACK2: length 9.5
  ART05 w0.114: v1(131.8,17.4) 132.31,16.89 139.65,16.89 v2(139.99,16.55)
  BOTTOM w0.109: R5401.1 v2(139.99,16.55)
LTM4608_TRACK3: length 11.7
  ART05 w0.114: v3(18.14,31.52) 18.14,32 17.09,33.05 12.5,33.05 11.48,34.06 11.48,36.4 v1(10.92,36.96)
  BOTTOM w0.109: R5410.1 v3(18.14,31.52)
LTM4608_TRACK4: length 22.6
  ART03 w0.114: v1(20.85,144.98) 20.24,144.37 20.24,139.73 20.82,139.15 20.82,136.44 21.06,136.2 21.06,132.08 19.16,130.19 v2(19.16,124.55)
  BOTTOM w0.109: R5419.1 v2(19.16,124.55)
LTM4608_TRACK5: length 12.1
  ART05 w0.114: v1(45.59,36.07) 46.35,35.31 46.35,32.99 46.76,32.59 47.35,32.59 48.18,31.75 v3(48.18,26.34)
  BOTTOM w0.109: R5428.1 48.43,26.1 v3(48.18,26.34)
LTM4608_TRACK6: length 10.6
  ART05 w0.114: v2(115,14.29) 113.72,15.57 107.95,15.57 107.06,16.46 v1(107.06,17.4)
  BOTTOM w0.109: R5437.1 v2(115,14.29)
LTM4608_TRACK7: length 11
  ART07 w0.114: v1(155.04,17.4) 155.65,16.79 162.18,16.79 163.3,15.67 v2(164.64,15.67)
  BOTTOM w0.109: R5446.1 v2(164.64,15.67)
LTM4608_TRACK8: length 13.4
  ART05 w0.114: v1(86.92,17.4) 87.66,18.14 94.03,18.14 94.56,17.6 94.56,16.64 95.76,15.44 95.76,14.5 v3(95.21,13.96)
  BOTTOM w0.109: v3(95.21,13.96) R5455.1
LTM4623_INTVCC_1: length 26.5
  TOP w0.254: R6027.1 60.51,178.8 v2(60.55,178.84) ; R6028.1 v2(73.61,177.67) ; R1125.1 v3(67.74,179.45) ; C2110.2 v2(73.6,178.97)
  BOTTOM w0.381: v2(60.55,178.84) 60.55,179.71 60.93,180.09 66.37,180.09 67.01,179.45 v3(67.74,179.45) 68.78,179.45 69.09,179.76 72.82,179.76 v2(73.6,178.97) 73.6,177.68 v2(73.61,177.67) 73.61,175.82 70.92,173.13 69.79,173.13 v1(69.18,172.52)
LTM4623_INTVCC_2: length 11.2
  TOP w0.254: R6020.1 175.18,197.75 v2(175.15,197.78)
  ART05 w0.381: v2(175.15,197.78) 175.22,197.78 175.9,198.45 175.9,201.83 177.47,203.4 178.79,203.4 v3(179.4,204.01)
  BOTTOM w0.254: C1895.2 179.88,203.67 179.74,203.67 v3(179.4,204.01) ; R5995.1 v2(175.15,197.78)
LTM4623_INTVCC_3: length 21.2
  TOP w0.254: v2(50.57,139.42) 50.59,139.44 50.59,139.97 50.9,140.28 R6023.1 ; R5999.1 50.42,141.6 v2(50.22,141.4) ; 59.05,141.6 60.54,141.6 C1970.2 v2(62.14,140.65)
  ART16 w0.254: v2(50.57,139.42) 50.58,139.43 50.58,139.59 50.6,139.6 50.6,141.02 v2(50.22,141.4) 54.08,141.4 54.89,142.21 58.39,142.21 58.72,141.88 59.21,141.88 60.44,140.65 v2(62.14,140.65)
LTM4623_INTVCC_4: length 12.5
  TOP w0.254: R6022.1 R6009.1 v3(53.67,54.66) ; v3(54.8,53.2) 55.07,53.46 C2086.2
  BOTTOM w0.254: v2(57.35,48.84) 55.65,48.84 54.15,50.34 54.15,52.55 v3(54.8,53.2) 53.67,54.33 v3(53.67,54.66)
LTM4623_INTVCC_5: length 32.7
  TOP w0.203: v2(51.27,13.73) 51.56,14.02 51.56,15.19 51.31,15.44 46.17,15.44 45.9,15.16 45.9,12.47 45.72,12.29 U72.E4
  TOP w0.254: v3(51.24,12.38) C2062.2 ; R6021.1 v2(51.27,13.73)
  ART03 w0.305: v2(51.27,13.73) 51.27,12.41 v3(51.24,12.38)
  ART05 w0.254: v2(39.75,20.76) 40.28,20.23 40.28,14.02 41.25,13.06 44.58,13.06
  ART05 w0.305: v3(51.24,12.38) 50.57,13.06 44.58,13.06
LTM4677_INTVCC: length 11.8
  TOP w0.109: TP193.1 195.02,165.13 v2(195.33,164.82)
  ART05 w0.254: v1(203.15,165.48) v1(203.15,166.75)
  ART07 w0.114: v2(195.33,164.82) 196.34,165.84 196.34,166.34 196.8,166.8 197.97,166.8 198.65,166.12 202.62,166.12 203.15,165.58 v1(203.15,165.48)
LTM4678_1_VDD33: length 5.4
  BOTTOM w0.109: R5319.2 v2(196.7,199.92)
  BOTTOM w0.254: R5317.2 203.05,186.81 203.41,186.81 v2(203.66,186.56) ; R5316.2 205.14,186.7 v2(205.03,186.59) ; R5318.2 208.58,186.13 v2(208.84,185.88) ; v2(200.51,183.72) R566.2 R564.2 ; R563.2 207.49,183.61 v2(207.53,183.57)
  vias: v1(206.63,193.8)
LTM4678_2_VDD33: length 5.9
  BOTTOM w0.254: R5341.2 198.96,121.4 198.46,121.4 v2(198.3,121.56) ; R647.2 199.72,118.91 199.75,118.88 R648.2 201.03,118.88 v2(201.05,118.9) ; v2(203.63,121.08) 203.82,121.27 R5338.2 ; R5339.2 201.94,121.06 v2(202.26,121.06) ; R646.2 206.1,118.1 v2(206.13,118.07) ; R5340.2 207.19,120.62 v2(207.44,120.37)
  vias: v1(205.23,128.3)
LTM4680_FAULT0N: length 19.1
  TOP w0.109: R5463.2 v2(170.6,173.78)
  ART03 w0.114: v4(155.73,176.17) v4(154.46,174.9)
  ART18 w0.114: v4(154.46,174.9) 155.59,173.78 v2(170.6,173.78)
