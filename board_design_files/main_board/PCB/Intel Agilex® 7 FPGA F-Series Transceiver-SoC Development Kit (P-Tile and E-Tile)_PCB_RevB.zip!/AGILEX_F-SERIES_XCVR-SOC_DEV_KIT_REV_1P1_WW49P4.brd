# Allegro board AGILEX_F-SERIES_XCVR-SOC_DEV_KIT_REV_1P1_WW49P4.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N20604615: length 2.5
  TOP w0.089: U35.12 162.15,135.76 162.02,135.64 160.72,135.64 R429.2
N20604632: length 2.5
  TOP w0.089: R430.2 160.7,135.35 162.05,135.35 162.15,135.26 U35.13
N20604649: length 2.2
  TOP w0.089: U35.17 163.42,133.02 163.42,132.61 162.77,131.96 162.77,131.75 R431.2
N20604666: length 2.2
  TOP w0.089: R432.2 163.06,131.75 163.06,131.84 163.8,132.59 163.8,133.04 U35.18
N20604729: length 2
  TOP w0.089: R968.2 165.79,131.72 165.79,131.85 165.45,132.18 165.45,132.46 165.35,132.56 U35.21
N20604746: length 2.1
  TOP w0.089: R969.2 166.08,131.77 166.08,131.96 165.74,132.3 165.74,132.49 165.85,132.6 U35.22
N20605183: length 11.6
  TOP w0.254: v2(164.44,131.38) 164.44,132.57 164.35,132.65 U35.19 ; 169.26,135.76 U35.29
  ART03 w0.508: v2(169.96,135.25) 169.96,133.51 167.83,131.38 v2(164.44,131.38)
N20633771: length 1.2
  TOP w0.109: D36.2 9.12,186.56 v3(9.12,186.56)
  BOTTOM w0.109: R520.1 v3(9.12,186.56)
N20675466: length 4.6
  TOP w0.109: v2(26.29,20.73) 26.29,20.98 26.77,21.46 R976.2 ; U15.8 v2(26.39,18.08)
  ART05 w0.114: v2(26.39,18.08) 26.39,20.62 v2(26.29,20.73)
N20675700: length 2.1
  TOP w0.109: R977.2 18.75,173.78 U21.13
N20718622: length 2.5
  BOTTOM w0.254: R985.1 43.87,55.64 43.87,55 44.06,54.8 U32.7
  BOTTOM w0.508: R984.1 R985.1
N20723038: length 4.3
  BOTTOM w0.109: R987.1 154.79,203.52 R988.2 156.41,202.91 156.41,202.23 157.1,201.55 U82.4
N20723060: length 2.3
  BOTTOM w0.109: U82.14 165.24,199.6 R992.1
N20723062: length 2.3
  BOTTOM w0.109: U82.13 165.4,200.25 R993.1
N20723064: length 2.4
  BOTTOM w0.109: R994.1 165.31,202.26 164.59,201.55 U82.11
N20723066: length 2.7
  BOTTOM w0.109: U82.9 165.08,202.85 165.8,203.58 R995.1
N20723111: length 4.3
  BOTTOM w0.109: U82.6 156.88,202.85 156.77,202.96 156.77,203.86 156.22,204.41 R988.1 154.79,204.41 R989.2
N20759675: length 10.1
  TOP w0.305: v3(204.24,5.74) 204.16,5.82 U84.3
  ART03 w0.305: v3(204.24,5.74) 204.24,9.45 202.89,10.8 v3(199.07,10.8)
N20841727: length 2.8
  TOP w0.109: R1001.2 212.05,28.65 J14.B12
N20876118: length 7.2
  BOTTOM w0.109: R1003.2 93.9,35.18 91.44,35.18 91.31,35.05 90.4,35.05 90.1,34.75 U34.13
N20976353: length 1.9
  TOP w0.109: U48.6 33.36,188.2 33.76,187.8 33.76,187.48 33.75,187.48 C957.2
N21145502: length 1.3
  TOP w0.254: U3.T7 v2(86.14,153.71)
  BOTTOM w0.254: v2(86.14,153.71) 86.54,153.31 R1006.2
N21146103: length 1.4
  TOP w0.254: U4.T7 v2(97.57,153.71)
  BOTTOM w0.254: R1007.2 98,153.29 v2(97.57,153.71)
N21146535: length 1.3
  TOP w0.254: U5.T7 v2(109,153.71)
  BOTTOM w0.254: v2(109,153.71) 109.4,153.31 R1008.2
N21146960: length 1.4
  TOP w0.254: U6.T7 v2(120.43,153.71)
  BOTTOM w0.254: R1009.2 120.83,153.31 v2(120.43,153.71)
N21147395: length 1.3
  TOP w0.254: U7.T7 v2(74.71,153.71)
  BOTTOM w0.254: v2(74.71,153.71) 75.11,153.31 R1010.2
N21454939: length 2.8
  TOP w0.109: R1053.1 190.29,58.38 U38.61
N21652883: length 3.2
  TOP w0.109: TP21.1 169.06,132.43 169.06,133.27 168.57,133.76 U35.25
N21652886: length 2.7
  TOP w0.109: U35.26 168.73,134.26 169.57,133.43 TP22.1
N22210877: length 3.3
  BOTTOM w0.109: v2(167,45.24) 168.14,46.37 R1065.2 R1064.2
N22372085: length 2.6
  TOP w0.109: D37.2 v3(9.83,184.02)
  BOTTOM w0.109: R529.2 8.67,184.02 v3(9.83,184.02)
N22589790:
  vias: v2(131.25,92.1)
N22603807: length 13.1
  BOTTOM w0.109: R60.1 130.06,86.28 130.21,86.14 130.47,86.14 130.96,85.65 131.46,85.65 132.54,84.57 132.54,79.84 R59.1 R940.2
  vias: v2(129.51,86.1)
N22603824: length 13.7
  BOTTOM w0.109: v2(127.78,89.1) 128.19,88.69 128.19,88.39 128.45,88.14 128.74,88.14 129.25,87.63 129.64,87.63 130.15,87.12 130.56,87.12 131.19,86.49 131.57,86.49 131.95,86.11 132.21,86.11 132.59,85.72 132.59,84.91 132.92,84.58 133.1,84.58 133.45,84.23 133.45,81.12 R61.2 R1025.2
N22614955:
  vias: v2(119.99,116.6)
N22614989: length 7.2
  BOTTOM w0.109: R949.1 114.83,119.62 R1026.2
  BOTTOM w0.127: v2(119.12,117.1) 119.12,117.53 118.59,118.06 118.18,118.06 117.44,118.8 117.44,119.36 117.18,119.62 R949.1 116.43,119.67 R948.2
N22615026: length 3.1
  BOTTOM w0.109: v2(117.39,114.1) 117.27,113.98 R69.2 115.86,114.55 115.35,114.55 R1027.2
N22627676:
  vias: v2(101.8,106.1)
N22627752:
  vias: v2(96.6,108.1)
N22627766:
  vias: v2(96.6,107.1)
N22627780:
  vias: v2(98.34,105.1)
N22627794:
  vias: v2(98.34,106.1)
N22627808:
  vias: v2(98.34,108.1)
N22627822:
  vias: v2(98.34,107.1)
N22627836:
  vias: v2(97.47,108.6)
N22627850:
  vias: v2(97.47,107.6)
N22627864:
  vias: v2(99.2,108.6)
N22627870:
  vias: v2(99.2,107.6)
N22633196:
  vias: v2(126.92,98.6)
N22633206:
  vias: v2(121.72,96.6)
N22823355:
  vias: v2(132.11,116.6)
N22823445: length 1.9
  BOTTOM w0.109: R1028.2 127.73,113.98 R71.2 R72.1
  vias: v2(129.51,114.1)
N23258622: length 3.3
  BOTTOM w0.109: J35.9 167.75,161.23 167.81,161.29 TP32.1
N23258640: length 4.9
  BOTTOM w0.109: TP33.1 163.96,153.03 164.72,153.03 164.97,153.29 J35.10
N23628441: length 3.4
  BOTTOM w0.089: R145.2 120.87,148.51 120.13,148.51 C519.2 119.62,148.92 118.76,148.06 R146.2
N24167599: length 1.3
  BOTTOM w0.254: 42.57,48.08 U32.28
N24972008: length 5.3
  TOP w0.109: U53.D12 208.26,188.36 208.26,188.28 209.98,186.56 TP191.1
N24972013: length 4.8
  TOP w0.254: U53.H1 202.34,203.17 202.34,203.89 200.98,205.24 200.98,205.6 R5312.1
  vias: v4(200.28,202.69) v4(202.77,213.54) v4(202.79,212.62) v4(202.82,201.42) v4(202.82,200.15) v4(202.82,198.88) v4(202.95,207.04) v4(202.95,206.15) v4(203.1,205.13) v4(203.1,204.24) v4(203.2,210.44) v4(203.23,209.52) v4(203.5,211.84) v4(204.09,202.69) v4(204.09,201.42) v4(204.09,200.15) v4(204.09,198.88) v4(204.19,205.1) v4(204.19,204.22) v4(204.42,211.84) v4(204.42,210.95) v4(204.42,210.11) v4(204.42,209.22) v4(204.5,208.25) v4(204.52,207.31) v4(205.36,202.69) v4(205.36,201.42) v4(205.36,200.15) v4(205.36,198.88) v4(205.49,211.15) v4(205.49,210.26) v4(205.66,212.01) v4(205.74,209.3) v4(205.76,208.24) v4(205.78,207.26) v4(205.77,205.28) v4(205.77,204.39) v4(206.63,202.69) v4(206.63,201.42) v4(206.63,200.15) v4(206.63,198.88)
N24972044: length 3.4
  TOP w0.109: R553.1 205.36,186.28 205.66,186.59 205.66,188.42 205.36,188.72
N24972552: length 398
  ART03 w0.254: v1(197.74,188.72) 197.35,189.11 194.19,189.11 192.92,187.84 192.09,187.84 v2(191.88,187.64) ; v2(193.29,163.96) 193.43,164.09 193.69,164.09 193.88,163.91 193.88,162.2 190.98,159.31 190.98,157.86 191.58,157.26 193.99,157.26 194.6,157.87 196.05,157.87 196.71,157.21 196.71,155.72 193.75,152.76 193.75,142.39 194.46,141.67 194.46,138.79 196.09,137.16 196.09,135.99 194.9,134.81 194.9,123.27 195.99,122.18 198.36,122.18 198.78,121.76 198.78,121.36 198.38,120.97 198.38,118.61 200.41,116.59 200.41,115.41 209.31,106.52 209.31,100.57 206.58,97.85 206.58,30.56 204.14,28.12 200.77,28.12 198.89,30 195.96,30 192.53,26.57 180.66,26.57 178.98,24.89 178.98,20.08 175.49,16.59 171.3,16.59 164.44,9.73 161.22,9.73 159.31,7.82 146.71,7.82 142.95,11.58 126.82,11.58 125.63,10.39 123.47,10.39 122.41,11.45 120.34,11.45 118.49,9.6 110.03,9.6 107.86,7.43 78.49,7.43 73.94,11.99 57.68,11.99 51.05,18.62 51.05,22.63 47.04,26.64 43.52,26.64 v2(42.85,25.97)
  ART07 w0.254: v2(190.45,187.68) 190.37,187.76 190.01,187.76 189.86,187.61 189.86,187.11 190.03,186.93 192.94,186.93 193.52,186.35 193.53,186.35 194.64,185.24 194.64,182.32 193.38,181.07 193.38,179.41 194.26,178.54 194.26,169.11 194.77,168.6 194.77,165.44 v2(193.29,163.96) ; v1(197.74,188.72) 197.74,188.42 198.62,187.54 210.85,187.54 211.71,188.4 v1(211.71,188.72)
  BOTTOM w0.254: v2(191.88,187.64) C987.1 190.49,187.64 v2(190.45,187.68)
N24972568: length 399.7
  ART03 w0.254: v2(43.99,25.97) 44.19,26.17 46.88,26.17 50.61,22.45 50.61,18.43 57.5,11.54 73.75,11.54 78.31,6.99 108.04,6.99 110.15,9.09 118.62,9.09 120.5,10.98 122.25,10.98 123.28,9.94 125.81,9.94 127.01,11.14 142.71,11.14 146.51,7.34 159.51,7.34 161.42,9.25 164.64,9.25 171.5,16.1 175.69,16.1 179.47,19.88 179.47,24.74 180.85,26.12 192.71,26.12 196.14,29.55 198.7,29.55 200.58,27.67 204.32,27.67 207.03,30.37 207.03,97.66 209.75,100.39 209.75,106.7 200.86,115.6 200.86,116.77 198.83,118.8 198.83,120.78 199.23,121.18 199.23,121.95 198.55,122.63 196.17,122.63 195.35,123.45 195.35,134.62 196.53,135.8 196.53,137.35 194.91,138.97 194.91,141.86 194.2,142.57 194.2,152.57 197.16,155.53 197.16,157.45 196.29,158.32 194.41,158.32 193.8,157.71 191.77,157.71 191.43,158.05 191.43,159.12 194.33,162.02 194.33,164.09 193.88,164.54 193.44,164.54 v2(193.27,164.72) ; v2(191.91,188.53) 192.15,188.29 192.69,188.29 193.95,189.56 197.31,189.56 v1(197.74,189.99)
  ART07 w0.254: v2(190.37,188.44) 190.14,188.21 189.66,188.21 189.41,187.95 189.41,186.92 189.84,186.49 192.75,186.49 193.31,185.93 193.32,185.93 194.2,185.05 194.2,182.56 192.94,181.3 192.94,179.17 193.78,178.34 193.78,168.91 194.28,168.4 194.28,165.74 v2(193.27,164.72) ; v1(197.74,189.99) 198.3,189.43 198.3,188.49 198.8,187.99 210.66,187.99 211.18,188.5 211.18,189.03 211.71,189.56 v1(211.71,189.99)
  BOTTOM w0.254: v2(191.91,188.53) C987.2 190.46,188.53 v2(190.37,188.44)
N24972677: length 4.2
  ART05 w0.114: v1(201.55,193.8) 201.04,193.29 201.04,190.5 v1(201.55,189.99)
N24972695: length 9.2
  ART03 w0.114: v1(201.55,191.26) 200.96,191.85 200.96,192.94 201.22,193.19 207.29,193.19 v1(207.9,193.8)
N24972725: length 5
  TOP w0.109: R5322.2 208.08,186 206.63,187.45 U53.E12 U53.E11
N24972803: length 12.8
  ART03 w0.114: v1(206.63,195.07) 205.87,195.83 205.87,196.56 205.5,196.93 197.56,196.93 196.85,197.64 v2(196.85,198.35)
  BOTTOM w0.109: v2(196.85,198.35) 196.62,198.58 C988.1
N24972848: length 5.9
  BOTTOM w0.109: v1(206.63,192.53) 206.1,192 206.1,188.68 R5320.2
N24972862: length 17.7
  ART03 w0.203: v1(201.55,192.53) 202.21,191.87 202.93,191.87 203.33,191.47 203.33,191.31 204.01,190.63 207.26,190.63 v1(207.9,191.26) 208.48,190.68 208.48,187.73 210.26,185.95 210.26,185.22 v2(211.94,183.54)
  BOTTOM w0.203: C1900.2 v2(211.94,183.54)
N24972885: length 14
  ART03 w0.203: v2(210.72,185.67) 210.72,186.33 209.78,187.27 209.78,190.65 v1(209.17,191.26) 208.56,191.87 203.91,191.87 203.25,192.53 v1(202.82,192.53)
  BOTTOM w0.203: v2(210.72,185.67) 210.72,185.33 C1899.2
N24973349: length 0.1
  TOP w0.109: D39.2 v2(187.58,214.53)
  BOTTOM w0.109: R573.2 v2(187.58,214.53)
N24979883: length 10.8
  TOP w0.109: TP192.1 205.36,113.79 v2(205.08,114.07)
  ART03 w0.114: v1(206.5,123.22) 206.5,120.15 205.28,118.93 205.28,115.54 205.08,115.34 v2(205.08,114.07)
N24979885: length 4.7
  TOP w0.254: R5323.1 200.28,140.2 200.28,138.81 200.96,138.13 200.96,137.65 U58.H1
  vias: v4(198.88,137.19) v4(201.42,135.92) v4(201.42,134.65) v4(201.42,133.38) v4(201.7,138.73) v4(201.8,144.93) v4(201.83,144.02) v4(201.9,148.36) v4(201.9,147.22) v4(202.11,146.33) v4(202.26,141.53) v4(202.26,140.64) v4(202.69,137.19) v4(202.69,135.92) v4(202.69,134.65) v4(202.69,133.38) v4(202.79,138.71) v4(203.96,137.19) v4(203.96,135.92) v4(203.96,134.65) v4(203.96,133.38) v4(204.42,139.9) v4(204.37,138.89) v4(204.83,148.31) v4(204.83,147.42) v4(204.83,145.69) v4(204.83,144.81) v4(205.08,142.57) v4(205.08,141.68) v4(205.23,137.19) v4(205.23,135.92) v4(205.23,134.65) v4(205.23,133.38)
N24979910: length 3.4
  TOP w0.109: R5324.1 203.96,120.78 204.27,121.08 204.27,122.91 U58.F12
N24980412: length 124
  ART05 w0.254: v2(154.43,126.75) 154.43,127 154.62,127.19 160.78,127.19 161.38,127.79 161.38,129.18 161.41,129.22 161.41,129.23 162.03,129.84 162.03,129.87 162.31,130.15 162.35,130.15 164.8,132.6 166.8,132.6 168.2,134 172.8,134 174.27,135.47 185.61,135.47 187.87,133.21 187.87,130.19 188.5,129.57 192.64,129.57 192.71,129.64 193.11,129.64 193.4,129.36 193.4,128.07 189.92,124.59 189.92,122.99 190.43,122.47 190.52,122.47 v2(190.78,122.21) 190.88,122.31 194.29,122.31 195.49,123.51 196.05,123.51 v1(196.34,123.22)
  ART07 w0.254: v1(196.34,123.22) 196.34,122.97 197.23,122.08 209.5,122.08 210.31,122.9 v1(210.31,123.22)
  BOTTOM w0.109: C1105.1 190.55,122.44 v2(190.78,122.21)
  BOTTOM w0.254: R644.2 123.09,111.07 123.52,111.51 125.77,111.51 126.4,112.14 127.11,112.14 127.55,112.58 127.97,112.58 128.44,112.11 130.57,112.11 131.1,111.58 131.85,111.58 132.8,112.53 133.11,112.53 133.68,113.11 134.01,113.11 134.49,113.59 134.87,113.59 135.38,114.1 135.76,114.1 136.27,114.6 136.78,114.6 137.34,115.17 137.44,115.17 137.94,115.67 138.51,115.67 139.06,116.22 139.06,116.41 139.7,117.05 139.7,125.32 140.5,126.12 148.46,126.12 149.05,125.53 153.7,125.53 154.43,126.26 v2(154.43,126.75)
N24980428: length 124.7
  ART05 w0.254: v1(196.34,124.49) 195.81,123.95 195.3,123.95 194.11,122.76 190.94,122.76 v2(190.78,122.92) 190.62,122.92 190.36,123.18 190.36,124.41 193.84,127.89 193.84,129.54 193.3,130.09 192.53,130.09 192.49,130.05 188.64,130.05 188.32,130.37 188.32,133.39 185.8,135.92 174.09,135.92 172.61,134.44 168.02,134.44 166.62,133.05 164.61,133.05 162.16,130.6 162.12,130.6 161.58,130.05 161.58,130.03 160.97,129.42 160.97,129.4 160.93,129.37 160.93,127.97 160.6,127.64 154.4,127.64 v2(153.77,127.01)
  ART07 w0.254: v1(210.31,124.49) 210.31,124.05 209.78,123.52 209.78,122.99 209.31,122.53 197.42,122.53 196.9,123.05 196.9,123.93 v1(196.34,124.49)
  BOTTOM w0.109: v2(190.78,122.92) 190.37,123.33 C1105.2
  BOTTOM w0.254: R643.2 125.6,111.96 126.73,113.09 130.54,113.09 131.02,112.62 131.43,112.62 131.9,113.09 132.27,113.09 132.77,113.59 133.15,113.59 133.65,114.1 134.04,114.1 134.54,114.6 134.9,114.6 135.41,115.11 135.8,115.11 136.27,115.58 136.68,115.58 137.13,116.03 137.34,116.03 137.48,116.17 137.49,116.17 137.93,116.61 138.58,116.61 139.27,117.3 139.27,125.6 140.29,126.63 148.67,126.63 149.26,126.03 153.48,126.03 153.77,126.32 v2(153.77,127.01)
N24980537: length 4.2
  ART07 w0.114: v1(200.15,124.49) 199.69,124.94 199.69,125.56 199.69,125.56 199.69,127.22 199.69,127.22 199.69,127.84 v1(200.15,128.3)
N24980555: length 7.9
  ART03 w0.114: v1(206.5,128.3) 206.04,127.83 206.04,126.97 205.59,126.52 200.91,126.52 v1(200.15,125.76)
N24980585: length 5
  TOP w0.109: R5330.2 206.68,120.5 205.23,121.95 U58.E12 U58.E11
N24980595: length 8.1
  TOP w0.109: v1(207.77,123.22) 207.77,122.17 R6038.2
  ART03 w0.114: v1(205.23,125.76) 205.23,124.74 206.2,123.77 207.21,123.77 v1(207.77,123.22)
N24980663: length 17.2
  ART03 w0.114: v2(197.13,138.18) 197.33,137.97 204.11,137.97 204.48,137.61 204.48,130.32 v1(205.23,129.57)
  BOTTOM w0.109: v2(197.13,138.18) 196.89,137.93 C1921.1
N24980708: length 5.5
  BOTTOM w0.109: R5333.2 205.99,126.26 v1(205.23,127.03)
N24980722: length 41.9
  ART03 w0.203: v1(206.5,125.76) 207.19,126.44 210.62,126.44 210.87,126.18 210.87,122.98 211.2,122.65 211.2,116.26 v2(208.18,113.23)
  ART20 w0.254: v1(200.15,127.03) 199.54,126.42 199.54,122.12 198.36,120.93 198.36,120.03 198.88,119.51 198.88,117.88 204.23,112.53 207.48,112.53 v2(208.18,113.23)
  BOTTOM w0.305: C1922.2 208.2,113.26 v2(208.18,113.23)
N24980745: length 33.9
  ART03 w0.203: v1(207.77,125.76) 208.43,125.09 208.43,119.08 207.62,118.26 207.62,114.12 v2(206.81,113.31)
  ART20 w0.254: v2(206.81,113.31) 204.19,113.31 199.36,118.14 199.36,119.68 198.81,120.24 198.81,120.75 200.81,122.75 200.81,126.42 v1(201.42,127.03)
  BOTTOM w0.305: C1923.1 206.86,113.36 v2(206.81,113.31)
N24984146: length 4.3
  TOP w0.254: U67.7 75.6,51.38 75.49,51.49 74.54,51.49 R747.2
  TOP w0.381: R747.2 R746.1 R744.2
N24984160: length 41.4
  TOP w0.305: U67.1 v2(79.07,49.25)
  ART20 w0.114: v2(113.73,46.86) 113.73,46.24 112.14,44.65 90.96,44.65 86.36,49.25 v2(79.07,49.25)
  BOTTOM w0.508: R1151.2 114.49,46.8 114.43,46.86 v2(113.73,46.86) C1779.1
N24985018: length 3.2
  TOP w0.254: U69.7 140.98,141.64 140.86,141.52 140.86,140.76 R767.2
  TOP w0.381: R767.2 141.31,140.36 v3(142.48,140.36)
N24985032: length 45.5
  TOP w0.305: v2(143.03,144.65) 142.75,144.93 U69.1
  BOTTOM w0.381: C1782.1 115.61,156.4 116.73,157.52 129.17,157.52 131.85,160.2 136.93,160.2 138.2,158.93 138.2,154.08 138.76,153.52 141.27,153.52 143.03,151.76 v2(143.03,144.65)
  BOTTOM w0.508: C1782.1 R1154.1 113.35,156.4 R1153.2
N24985212: length 1.8
  TOP w0.254: U69.5 138.77,144.93 R5388.2
N25067542: length 4
  BOTTOM w0.254: R681.1 18.59,40.16 18.88,40.45 20.41,40.45 V8.1
  vias: v1(20.7,36.45) v1(20.7,35.18) v1(20.7,33.91) v1(20.7,32.64) v1(20.7,31.37) v1(21.97,36.45) v1(21.97,35.18) v1(21.97,33.91) v1(21.97,32.64) v1(21.97,31.37) v1(23.24,33.91) v1(23.24,32.64) v1(23.24,31.37) v4(19.43,28.7) v4(19.43,27.26) v4(19.43,25.91) v4(20.32,27.18) v4(21.21,28.7) v4(21.21,25.91) v4(21.25,27.17)
N25071143: length 5.2
  TOP w0.109: v2(30.26,41.5) 30.52,41.76 TP39.1
  ART03 w0.114: v1(30.86,37.72) 30.28,38.3 30.28,41.48 v2(30.26,41.5)
N25071146: length 18
  TOP w0.109: TP40.1 v2(24.36,42.09)
  ART03 w0.114: v1(32.13,32.64) 31.52,33.25 24.38,33.25 23.83,33.81 23.83,41.55 v2(24.36,42.09)
N25073319: length 13.3
  BOTTOM w0.109: R5393.1 24.5,40.11 C1937.2 24.52,39.74 23.98,39.19 23.98,35.92 24.13,35.76 24.71,35.76 25.12,35.36 25.12,32.49 25.48,32.13 27.81,32.13 v1(28.32,32.64)
N25073405: length 8.6
  BOTTOM w0.109: v1(27.05,32.64) 26.24,33.45 26.24,35.53 25.91,35.86 25.48,35.86 25.17,36.17 25.17,39.84 C1937.1
N25074810: length 19.8
  ART03 w0.114: v1(33.4,32.64) 31.6,34.44 27.84,34.44 26.75,35.53 26.75,42.53 v2(26.24,43.04)
  BOTTOM w0.109: v2(26.24,43.04) R686.1 R680.1 22.25,43.04 R682.1
N25075439: length 3.9
  BOTTOM w0.109: v1(30.86,33.91) 30.2,34.57 27.7,34.57 27.69,34.56 R6090.1
N25076947: length 21.9
  ART20 w0.114: v2(141.5,20.09) 138.1,20.09 137.62,20.57 131.78,20.57 130.99,19.79 130.99,12.78 v1(130.53,12.32)
  BOTTOM w0.109: R693.1 R695.1 141.38,21 141.3,20.92 141.3,20.9 140.93,20.54 R694.1 v2(141.5,20.09)
N25077139: length 12.5
  BOTTOM w0.109: v1(130.53,17.4) 130,17.93 130,20.06 130.69,20.75 137.08,20.75 137.53,21.2 C1939.2 138,21.22 R5402.1
N25077159: length 8.3
  BOTTOM w0.109: v1(130.53,18.67) 130.99,19.13 134.26,19.13 134.87,19.74 134.87,19.94 135.34,20.4 137.07,20.4 137.16,20.31 C1939.1
N25077254: length 5.8
  TOP w0.109: TP41.1 v2(139.93,14.61)
  ART03 w0.114: v1(135.61,14.86) 136.12,15.37 139.17,15.37 v2(139.93,14.61)
N25077268: length 17.5
  TOP w0.109: v2(141.71,19.41) 141.07,19.41 TP42.1
  ART03 w0.114: v1(130.53,13.59) 130.99,14.05 137.07,14.05 137.54,13.59 140,13.59 141.34,14.93 141.34,18.14 141.3,18.19 141.3,19 v2(141.71,19.41)
N25077282: length 2.5
  BOTTOM w0.127: V10.1 129.07,26.67 130.38,26.67 130.53,26.51 R690.2
  vias: v1(129.26,25.02) v1(129.26,23.75) v1(129.26,22.48) v1(130.53,25.02) v1(130.53,23.75) v1(130.53,22.48) v1(131.8,25.02) v1(131.8,23.75) v1(131.8,22.48) v1(133.07,25.02) v1(133.07,23.75) v1(134.34,25.02) v1(134.34,23.75) v4(123.75,25.81) v4(123.75,24.03) v4(123.83,26.75) v4(124.99,26.75) v4(125.02,24.92) v4(125.15,25.86) v4(125.06,24.04) v4(126.11,26.67) v4(126.54,25.81) v4(126.54,24.03)
N25080456: length 21.1
  ART03 w0.114: v2(9.37,46.43) 9.37,36.88 10.21,36.04 10.21,35.23 10.46,34.98 15.29,34.98 v1(16,35.69)
  BOTTOM w0.109: v2(9.37,46.43) R702.1 8.61,45.71 R704.1 R701.1
N25080712: length 4.2
  BOTTOM w0.109: R6088.1 10.27,37.64 12.78,37.64 v1(13.46,36.96)
N25080763: length 5.8
  TOP w0.109: TP43.1 v2(13.46,45.26)
  ART03 w0.114: v1(13.46,40.77) 13.97,41.27 13.97,44.75 v2(13.46,45.26)
N25080777: length 14.7
  TOP w0.109: TP44.1 9.93,44.98 v2(10.39,45.44)
  ART03 w0.114: v1(14.73,35.69) 14.66,35.76 14.66,36.86 14.02,37.49 10.79,37.49 10.39,37.9 v2(10.39,45.44)
N25080791: length 4
  BOTTOM w0.254: V12.1 4.48,45.07 2.96,45.07 2.67,44.78 R703.1
  vias: v1(3.3,39.5) v1(3.3,38.23) v1(3.3,36.96) v1(3.3,35.69) v1(3.3,34.42) v1(4.57,39.5) v1(4.57,38.23) v1(4.57,36.96) v1(4.57,35.69) v1(4.57,34.42) v1(5.84,36.96) v1(5.84,35.69) v1(5.84,34.42) v4(2.03,31.75) v4(2.03,30.31) v4(2.03,28.96) v4(2.92,30.23) v4(3.81,31.75) v4(3.81,28.96) v4(3.85,30.22)
N25083983: length 32.3
  ART07 w0.114: v1(15.77,146.25) 14.86,145.34 14.86,139.22 17.22,136.86 17.22,131.72 23.09,125.86 23.09,123.39 24.33,122.15 v2(24.99,122.15)
  BOTTOM w0.109: v2(24.99,122.15) R1018.1 25.34,122.69 25.78,122.25 R1013.1 R1014.1
N25084239: length 26.1
  ART03 w0.114: v2(23.8,126.44) 23.8,138.28 22.68,139.4 22.68,144.37 21.26,145.79 20.53,145.79 20.32,146 20.32,146.46 19.99,146.79 19.15,146.79 18.87,146.51 18.87,145.54 v1(18.31,144.98)
  BOTTOM w0.109: R6087.1 v2(23.8,126.44)
N25084282: length 15.7
  TOP w0.109: v2(28.22,136.22) 28.83,135.61 TP45.1
  ART07 w0.114: v1(18.31,141.17) 18.85,140.64 18.85,139.8 19.84,138.81 25.63,138.81 v2(28.22,136.22)
N25084289: length 25.6
  TOP w0.109: TP46.1 26.62,130.89 v2(27.56,130.89)
  ART07 w0.114: v2(27.56,130.89) 25.12,130.89 19.38,136.63 18.26,136.63 15.21,139.67 15.21,145.14 15.72,145.64 16.43,145.64 v1(17.04,146.25)
N25084297: length 1.9
  TOP w0.254: R1024.2 33.51,138.46 33.86,138.81 34.8,138.81 34.81,138.82 34.9,138.73 V24.1
  vias: v1(25.93,147.52) v1(25.93,146.25) v1(25.93,144.98) v1(27.2,147.52) v1(27.2,146.25) v1(27.2,144.98) v1(27.2,143.71) v1(27.2,142.44) v1(28.47,147.52) v1(28.47,146.25) v1(28.47,144.98) v1(28.47,143.71) v1(28.47,142.44) v4(25.96,153.67) v4(25.96,152.23) v4(25.96,150.88) v4(26.85,152.15) v4(27.74,153.67) v4(27.74,150.88) v4(27.78,152.14)
N25087496: length 26.6
  ART07 w0.114: v1(50.67,34.8) 50.04,35.43 39.19,35.43 38.73,35.89 38.73,43.74 v2(36.83,45.64)
  BOTTOM w0.109: v2(36.83,45.64) R724.1 36.36,44.54 35.92,44.98 R719.1 R722.1
N25087752: length 3.7
  BOTTOM w0.109: R6086.1 45.09,36.56 45.1,36.58 47.62,36.58 v1(48.13,36.07)
N25087795: length 4.2
  TOP w0.109: TP47.1 v2(49,43.21)
  ART03 w0.114: v2(49,43.21) 49,41.5 48.72,41.22 48.72,40.46 v1(48.13,39.88)
N25087802: length 16.3
  TOP w0.109: TP48.1 v2(41.17,44.22)
  ART03 w0.114: v1(49.4,34.8) 49.4,35.94 48.56,36.78 44.27,36.78 43.25,37.8 42.84,37.8 42.37,38.28 42.37,43.03 v2(41.17,44.22)
N25087810: length 2.4
  BOTTOM w0.254: V16.1 34.38,40.88 35.69,40.88 35.94,40.63 R718.2
  vias: v1(37.97,38.61) v1(37.97,37.34) v1(37.97,36.07) v1(37.97,34.8) v1(37.97,33.53) v1(39.24,38.61) v1(39.24,37.34) v1(39.24,36.07) v1(39.24,34.8) v1(39.24,33.53) v1(40.51,36.07) v1(40.51,34.8) v1(40.51,33.53) v4(36.68,30.84) v4(36.7,29.42) v4(36.68,28.04) v4(37.57,29.31) v4(38.46,30.84) v4(38.52,29.33) v4(38.46,28.04)
N25089948: length 1
  BOTTOM w0.109: Q5.3 118.63,16.53 118.62,16.54 R759.2
N25089950: length 1.4
  BOTTOM w0.109: R760.1 119.19,20.88 Q4.3
N25093122: length 19.2
  ART20 w0.114: v1(105.79,12.32) 107.52,14.05 113.6,14.05 115.51,15.96 115.51,18.3 v2(116.97,19.76)
  BOTTOM w0.109: v2(116.97,19.76) 116.64,20.09 R756.1 116.19,20.43 116.64,20.88 R751.1 R754.1
N25093395: length 4
  BOTTOM w0.109: R6085.1 107.67,17.92 107.67,15.47 v1(107.06,14.86)
N25093446: length 5.2
  TOP w0.109: TP49.1 v2(114.91,15.95)
  ART20 w0.114: v1(110.87,14.86) 111.51,15.49 112.47,15.49 112.92,15.95 v2(114.91,15.95)
N25093460: length 17.6
  TOP w0.109: v2(117.22,20.73) 116.97,20.98 TP50.1
  ART20 w0.114: v2(117.22,20.73) 114.27,20.73 112.42,18.87 107.47,18.87 106.25,17.66 106.25,14.05 v1(105.79,13.59)
N25093474: length 3.9
  BOTTOM w0.254: V22.1 112.72,30.04 112.72,28.47 112.47,28.22 R750.1
  vias: v1(104.52,25.02) v1(104.52,23.75) v1(104.52,22.48) v1(105.79,25.02) v1(105.79,23.75) v1(105.79,22.48) v1(107.06,25.02) v1(107.06,23.75) v1(107.06,22.48) v1(108.33,25.02) v1(108.33,23.75) v1(109.6,25.02) v1(109.6,23.75) v4(99.03,27) v4(98.98,25.91) v4(98.98,24.13) v4(100.25,25.02) v4(100.33,24.16) v4(100.38,27.03) v4(100.41,25.99) v4(101.83,27) v4(101.78,25.91) v4(101.78,24.13)
N25097889: length 23.3
  ART20 w0.114: v1(153.77,12.32) 154.46,13 160.48,13 162.81,15.34 163.22,15.34 164.83,16.95 164.83,21.3 v2(164.02,22.11)
  BOTTOM w0.109: R770.1 R771.1 R775.1 163.77,22.36 v2(164.02,22.11)
N25098162: length 3.8
  BOTTOM w0.109: R6084.1 155.56,17.3 155.55,17.29 155.55,15.37 v1(155.04,14.86)
N25098205: length 5.8
  TOP w0.109: v2(162.51,13.59) 163.04,13.06 TP51.1
  ART03 w0.114: v1(158.85,14.86) 159.54,14.17 160.53,14.17 161.11,13.59 v2(162.51,13.59)
N25098212: length 16.2
  TOP w0.109: TP52.1 v2(164.41,18.59)
  ART03 w0.114: v2(164.41,18.59) 157.76,18.59 157,17.83 157,14.53 156.51,14.05 154.23,14.05 v1(153.77,13.59)
N25103528: length 22
  ART05 w0.114: v1(85.65,12.32) 86.33,11.64 92.79,11.64 94.54,13.39 95.68,13.39 97.1,14.8 97.1,16.85 97.25,17.01 97.25,19.61 v2(96.77,20.09)
  BOTTOM w0.109: R779.1 R780.1 96.49,20.88 96.05,20.43 R784.1 v2(96.77,20.09)
N25103769: length 3.9
  BOTTOM w0.109: v1(86.92,14.86) 87.66,15.6 87.66,17.97 87.64,17.98 R6083.1
N25103808: length 5
  TOP w0.109: TP53.1 94.46,13.59 v2(94.16,13.89)
  ART20 w0.114: v1(90.73,14.86) 91.54,14.05 92.19,14.05 92.35,13.89 v2(94.16,13.89)
N25103813: length 14.2
  TOP w0.109: TP54.1 94.39,17.86 v2(93.88,17.35)
  ART20 w0.114: v2(93.88,17.35) 92.81,18.41 86.92,18.41 86.21,17.7 86.21,14.15 v1(85.65,13.59)
N25185713: length 7.8
  ART07 w0.114: v4(153.19,177.44) 153.85,178.1 157.51,178.1 157.63,178.23 157.63,178.99 157.91,179.27 158.83,179.27 v4(159.54,179.98)
N25191935: length 29.7
  TOP w0.254: R1134.2 v2(182.52,167.13)
  ART05 w0.114: v2(182.52,167.13) 170.69,167.13 167.61,170.21 167.61,170.23 166.83,171.02 166.83,171.6 164.49,173.94 157.96,173.94 v4(157,174.9)
N25191949: length 26.2
  TOP w0.109: R5964.2 v2(175.72,168.25)
  ART03 w0.114: v4(158.27,178.71) 158.93,179.37 163.65,179.37 165.61,177.42 165.61,175.67 167.49,173.79 167.49,170.46 169.7,168.25 v2(175.72,168.25)
N25191963: length 25.8
  TOP w0.109: R5963.2 v2(174.5,165.25)
  ART03 w0.114: v2(174.5,165.25) 171.88,167.87 169.64,167.87 167.16,170.36 167.16,173.63 165.2,175.59 165.2,177.06 164.19,178.08 158.9,178.08 v4(158.27,177.44)
N25191977: length 15.1
  ART07 w0.114: v4(160.81,174.9) 161.98,173.74 165.33,173.74 167.64,171.42 171.65,171.42 171.81,171.27 v2(173.15,171.27)
  BOTTOM w0.109: R5692.2 v2(173.15,171.27)
N25192006: length 22.2
  ART07 w0.114: v4(158.27,174.9) v4(158.27,176.17) 158.78,176.69 158.78,177.6 159.28,178.1 165.53,178.1 168.48,175.16 174.19,175.16 v2(175.26,174.09)
  BOTTOM w0.109: R5690.2 175.26,174.56 v2(175.26,174.09)
N25192932: length 27.7
  TOP w0.254: v2(179.23,166.33) 178.96,166.6 R5461.2
  ART07 w0.114: v4(160.81,176.17) 160.22,175.59 160.22,174.5 161.59,173.13 161.59,168.91 162.38,168.12 171.6,168.12 173.4,166.33 v2(179.23,166.33)
N25195277: length 26.9
  TOP w0.109: v2(138.1,181.76) 138.1,181.76 137.76,182.1 TP56.1
  ART07 w0.114: v4(159.54,174.9) 158.5,173.87 149.48,173.87 146.08,177.27 142.6,177.27 138.13,181.74 138.13,181.74 v2(138.1,181.76)
N25195480: length 35.4
  TOP w0.254: C1962.2 v2(181.93,166.42)
  ART07 w0.114: v4(160.81,177.44) 161.56,176.69 161.56,175.96 161.75,175.78 161.75,175.3 161.56,175.12 161.56,174.63 162.15,174.04 165.46,174.04 165.81,173.69 169.69,173.69 170.19,173.19 170.19,172.76 170.17,172.75 170.17,172.35 170.79,171.73 174.2,171.73 174.65,171.28 174.65,171 176.44,169.21 177.17,169.21 177.65,168.73 177.65,168.48 179.72,166.42 v2(181.93,166.42)
  ART18 w0.114: v4(160.81,177.44) 160.1,178.16 155.02,178.16 v4(154.46,178.71)
N25195483: length 37.9
  TOP w0.254: C1961.1 181.9,163.87 v2(181.64,163.6)
  ART03 w0.114: v2(181.64,163.6) 176.96,163.6 176.76,163.4 175.08,163.4 171.4,167.08 170,167.08 166.63,170.45 166.63,173.02 164.06,175.59 164.06,176.44 163.63,176.87 160.12,176.87 v4(159.54,177.44)
  ART20 w0.114: v4(153.19,178.71) 153.9,178 158.98,178 v4(159.54,177.44)
N25196395: length 32.1
  ART03 w0.114: v4(158.27,181.25) 158.8,181.79 164.39,181.79 166.32,179.86 166.32,175.79 168.4,173.71 169.98,173.71 174.88,168.81 176.07,168.81 176.38,168.5 176.38,165.21 v2(175.15,163.98)
  BOTTOM w0.109: C2063.1 v2(175.15,163.98)
N25201801: length 17.7
  ART03 w0.305: v4(166.14,190.98) 166.75,190.98 166.84,190.9 167.4,190.9 167.62,191.11 167.62,191.59 167.4,191.81 155.99,191.81 154.08,189.89 154.08,189.26 v4(154.46,188.87)
  vias: v4(146.08,191.34) v4(146.08,190.32) v4(146.08,188.42) v4(146.08,187.4) v4(146.84,191.34) v4(146.84,190.32) v4(146.84,188.42) v4(146.84,187.4) v4(151.92,188.87) v4(154.46,187.6) v4(154.46,186.33) v4(154.46,185.06) v4(155.73,188.87) v4(155.73,187.6) v4(155.73,186.33) v4(155.73,185.06) v4(157,188.87) v4(157,187.6) v4(157,186.33) v4(157,185.06) v4(158.27,188.87) v4(158.27,187.6) v4(158.27,186.33) v4(158.27,185.06) v4(165.43,191.01) v4(165.43,190.12) v4(165.48,187.22) v4(165.48,186.33) v4(165.46,184.28) v4(165.46,183.39) v4(166.14,190.09) v4(166.19,187.2) v4(166.19,186.31) v4(166.22,184.28) v4(166.22,183.39)
N25221363: length 1.3
  BOTTOM w0.254: v1(213.31,166.75) v1(212.04,166.75)
N25221372: length 1.3
  BOTTOM w0.254: v1(213.31,168.02) v1(212.04,168.02)
N25221411: length 15.1
  TOP w0.109: TP60.1 v2(191.01,165.99)
  ART03 w0.114: v1(203.15,169.29) 202.51,168.66 192.33,168.66 191.01,167.34 v2(191.01,165.99)
N25221426: length 10.1
  BOTTOM w0.109: v1(208.23,170.56) 208.89,171.22 208.89,173.28 209.52,173.91 213.41,173.91 213.93,174.43 R5466.2
N25221435: length 9.8
  BOTTOM w0.109: v1(208.23,169.29) 208.99,170.05 208.99,170.89 209.42,171.32 209.71,171.32 210.13,171.74 210.13,172.17 210.41,172.44 213.61,172.44 214.72,173.55 R5466.1
N25222718: length 22.9
  ART07 w0.114: v1(208.23,173.1) 209.78,174.65 209.78,179 206.53,182.25 204.11,182.25 203.23,181.36 199.9,181.36 199.06,180.52 196.16,180.52 v2(196.09,180.59)
  BOTTOM w0.109: R5467.2 v2(196.09,180.59)
N25223016: length 7.9
  BOTTOM w0.109: v1(208.23,159.13) 208.94,159.84 214.17,159.84 214.95,159.07 R5468.2
N25223355: length 1.3
  BOTTOM w0.254: v1(213.31,164.21) v1(212.04,164.21)
N25223364: length 1.3
  BOTTOM w0.254: v1(213.31,165.48) v1(212.04,165.48)
N25223394: length 14.3
  TOP w0.109: TP62.1 v2(190.88,163.45)
  ART03 w0.114: v2(190.88,163.45) 191.63,164.2 192.22,164.2 192.67,164.65 192.67,164.7 193.1,165.13 193.73,165.13 194.77,166.17 195.86,166.17 196.29,165.74 196.29,165.35 198.02,163.63 201.29,163.63 v1(201.88,164.21)
N25223409: length 14.6
  TOP w0.109: TP63.1 193.09,168.15 v2(195.53,165.71)
  ART03 w0.114: v2(195.53,165.71) 195.53,165.28 198.55,162.26 201.22,162.26 201.88,162.92 v1(201.88,162.94)
N25223521: length 8.8
  ART07 w0.114: v2(197.41,164.97) 198.77,163.6 203.76,163.6 v1(204.42,162.94)
  BOTTOM w0.109: R5470.2 v2(197.41,164.97)
N25223524: length 43.7
  ART03 w0.114: v2(183.07,164.91) 185.79,164.91 188.59,167.72 189.41,167.72 190.91,169.21 196.75,169.21 197.41,169.88 203.33,169.88 203.86,169.34 203.86,168.58 v1(204.42,168.02)
  ART05 w0.114: v1(204.42,168.02) 204.92,167.52 204.92,164.71 v1(204.42,164.21)
  ART07 w0.114: v1(204.42,164.21) 203.86,164.77 198.54,164.77 v2(197.45,165.86)
  BOTTOM w0.109: R5472.2 v2(183.07,164.91) ; v2(197.45,165.86) R5470.1 196.47,166.42 196.25,166.64 C1967.1 196.25,168.57 197.03,169.34 C1966.1
N25223625: length 3
  BOTTOM w0.109: C1967.2 195.36,168.85 194.97,169.24 R5469.1
N25223886: length 1.3
  BOTTOM w0.254: v1(208.23,162.94) v1(208.23,161.67)
N25223987: length 27.3
  ART03 w0.114: v1(205.69,169.29) 205.1,169.88 205.1,171.98 204.67,172.42 198.78,172.42 197.66,171.3 184.99,171.3 183.91,170.22 v2(183.91,168.77)
  BOTTOM w0.109: R670.1 v2(183.91,168.77)
N25224168: length 22.8
  ART03 w0.114: v1(208.23,164.21) 207.67,164.77 206.73,164.77 206.38,165.13 206.38,165.51 205.84,166.04 199.01,166.04 197.99,167.06 194.79,167.06 193.48,165.74 191.78,165.74 191.27,165.24 190.06,165.24 v2(189.75,165.54)
  BOTTOM w0.109: v2(189.75,165.54) R676.1 187.83,165.54 R671.1
N25224802: length 24.2
  ART03 w0.114: v1(205.69,164.21) 205.05,164.85 198.81,164.85 198.48,165.18 198.48,165.81 197.54,166.75 194.92,166.75 193.61,165.44 192.41,165.44 192.36,165.38 192.36,164.78 192.09,164.51 190.75,164.51 189.41,163.17 186.94,163.17 v2(186.28,162.51)
  BOTTOM w0.254: v2(186.28,162.51) 185.43,162.51 R5473.1
N25224806: length 21.7
  ART03 w0.114: v1(205.69,168.02) 205.1,167.44 192.14,167.44 191.42,166.72 191.42,165.82 191.18,165.58 190.66,165.58 190.2,166.04 189.28,166.04 189.08,165.84 189.08,164.21 v2(188.59,163.73)
  BOTTOM w0.109: v2(188.59,163.73) 188.37,163.96 R5474.1
N25224899: length 18
  TOP w0.109: TP64.1 200.18,181.48 v2(201.17,180.49)
  ART07 w0.114: v2(201.17,180.49) 203,180.49 203.71,179.78 203.71,178.64 204.37,177.98 205.16,177.98 206.22,176.91 206.22,173.11 206.75,172.59 207.37,172.59 207.71,172.24 207.71,171.62 207.77,171.57 207.77,170.1 v1(206.96,169.29)
N25225151: length 220.8
  ART03 w0.114: v2(196.14,173.86) 197.79,173.86 198.32,174.4 206.83,174.4 207.59,173.63 207.59,166.12 v1(206.96,165.48)
  ART05 w0.114: v2(196.14,173.86) 196.14,172.09 194.79,170.74 188.17,170.74 187.07,169.64 187.07,165.15 178,156.08 178,155.68 177.01,154.69 143.89,154.69 140.84,157.73 140.84,158.88 137.29,162.43 v2(136.14,162.43)
  ART07 w0.114: v1(206.96,165.48) v1(208.23,165.48)
  ART18 w0.114: v2(136.14,162.43) 134.87,161.16 132.79,161.16 130.65,159.03 106.96,159.03 104.39,156.46 100.46,156.46 97.92,159 59.05,159 55.98,162.08 47.62,162.08 45.69,160.15 43.84,160.15 42.62,158.93 42.62,156.51 43.43,155.7 43.43,153.95 40.97,151.48 40.97,147.67 40.46,147.17 38.4,147.17 37.56,146.33 v2(37.56,145.54)
  BOTTOM w0.109: R661.1 R662.2 34.07,147.26 35.79,145.54 v2(37.56,145.54) ; R663.1 v2(196.14,173.86)
N25225249: length 14.5
  ART07 w0.114: v2(196.15,175.29) 197.88,175.29 198.93,174.24 202.97,174.24 203.9,173.31 203.9,171.48 204.31,171.08 206.44,171.08 v1(206.96,170.56)
  BOTTOM w0.109: R5475.2 v2(196.15,175.29)
N25225605: length 6.3
  BOTTOM w0.109: R668.2 214.13,166.94 213.77,167.31 210.06,167.31 v1(209.5,166.75)
N25225851: length 8.7
  BOTTOM w0.109: R5476.2 214.24,170.68 213.74,171.17 210.52,171.17 210.21,170.87 210.21,168.73 v1(209.5,168.02)
N25225898: length 24.1
  TOP w0.109: U59.G5 v1(206.96,166.75)
  ART07 w0.114: v1(206.96,166.75) 206.96,167.34 206.32,167.97 206.32,169.54 206.63,169.85 206.9,169.85 207.46,170.4 207.46,171.03 207.17,171.32 206.75,171.32 206.44,171.62 206.44,172.04 205.9,172.59 205.48,172.59 205.17,172.89 205.17,173.31 205.54,173.68 205.54,176.45 204.88,177.11 198.75,177.11 197.94,177.93 v2(196.14,177.93)
  BOTTOM w0.109: R5479.1 v2(196.14,177.93)
N25226074: length 29
  ART07 w0.114: v2(196.19,179.32) 196.35,179.48 199.28,179.48 200.8,181 203.48,181 204.16,181.68 205.25,181.68 205.26,181.69 205.69,181.69 206.12,181.25 206.12,180.52 206.73,179.91 208.28,179.91 209.04,179.15 209.04,174.8 207.76,173.53 207.76,172.74 208.16,172.35 208.44,172.35 208.76,172.03 208.76,170.44 208.42,170.1 208.3,170.1 207.73,169.53 207.73,168.79 v1(206.96,168.02)
  BOTTOM w0.109: R5480.2 v2(196.19,179.32)
N25559442: length 0.7
  BOTTOM w0.109: R2298.1 179.62,198.93 v1(179.4,198.93)
N25559469: length 4.1
  TOP w0.109: R5994.1 C2047.2 184.71,200.66 184.25,200.2 U52.B1
N25559519: length 2.9
  TOP w0.109: U52.A2 183.14,197.73 C1827.2
N25560953: length 4.9
  TOP w0.109: R544.1 U52.A3 ; R544.1 R547.2 ; R544.1 R543.1
N25561938: length 7.1
  ART05 w0.114: v2(177.38,197.78) 180.97,197.78 181.25,198.07 181.25,199.52 v1(181.94,200.2)
  BOTTOM w0.109: R5995.2 v2(177.38,197.78)
N25724466: length 17.4
  TOP w0.109: U54.7 77.23,208.21 77.84,208.21 77.9,208.27 78.38,208.27 78.42,208.23
  TOP w0.254: v2(76.44,198.99) R1074.2 ; C1636.2 79.08,208.03 78.88,208.23 78.42,208.23
  BOTTOM w0.254: v2(76.44,198.99) 77.5,200.05 79.76,200.05 81.6,201.9 81.6,206.3 80.75,207.15 80.49,207.15 79.81,207.83 v2(79.81,208.08)
N25726246: length 4.5
  TOP w0.109: U54.28 71.05,211.76 70.74,212.07 70.74,213.86 C2001.1
N25726251: length 3
  TOP w0.109: U54.30 71.39,210.96 70.51,211.84 70.51,211.89 C2000.1
N25726256: length 2.2
  TOP w0.109: U54.31 71.02,210.56 C2002.1
N25727503: length 2.3
  TOP w0.109: U54.22 74.81,213.07 74.73,213.16 74.73,214.46 R5978.2
N25727508: length 2.3
  TOP w0.109: U54.23 74.41,212.82 74.41,214.37 R5979.2
N25727513: length 2.6
  TOP w0.109: U54.24 74.01,212.82 74.01,213.53 R5980.2
N25727518: length 3.3
  TOP w0.109: U54.25 73.61,213.26 72.92,213.94 72.37,213.94 R5981.2
N25727970: length 2.8
  TOP w0.199: R6042.2 75.96,214.4 75.51,214.4 75.21,214.1 U54.21
N25730178: length 13.1
  TOP w0.199: v2(72.75,203.45) 72.16,203.45 72.12,203.42 C2114.1 71.45,204.17 71.03,204.59 R6041.2
  TOP w0.203: R5882.1 v2(78.38,202.5)
  ART07 w0.199: v2(78.38,202.5) R5882.1 76.9,203.45 v2(76.59,203.45) 76.13,203.45 76.01,203.33 74.24,203.33 v2(74.12,203.45) 74.08,203.48 72.79,203.48 v2(72.75,203.45)
N25855201: length 1.5
  TOP w0.254: U87.35 83.87,198.81 83.44,199.24 R1100.2
N25856429: length 7.8
  TOP w0.254: U87.30 86.37,198.86 86.46,198.96 86.46,199.8 84.98,201.28 R1098.1 84.98,201.75 C1652.1 85.14,203.19 85.14,204.3 R6092.2
N25863309: length 1.5
  TOP w0.254: R1105.2 97.54,198.73 97.96,198.3 U88.35
N25864351: length 7.2
  TOP w0.254: U88.30 100.46,198.36 100.56,198.45 100.56,199.19 99.07,200.67 R5971.1 C1978.1 97.94,203.47 R6099.2
N25870219: length 7.5
  TOP w0.254: U89.30 114.26,198.36 114.44,198.54 114.44,199.28 113.79,199.92 113.12,199.92 112.86,200.18 R5972.1 C1997.1 111.63,203.26 R6097.2
N25870304: length 1.5
  TOP w0.254: U89.35 111.75,198.2 111.33,198.63 R1111.2
N25876113: length 1.5
  TOP w0.254: U90.35 124.86,197.72 124.43,198.15 R5894.2
N25876514: length 9
  TOP w0.254: U90.30 127.36,197.77 127.46,197.87 127.46,198.88 126.62,199.72 125.37,199.72 124.98,200.11 R5973.1 C2016.1 124.96,202.03 R6098.2
N25909303: length 20.3
  TOP w0.127: R728.1 57.71,130.76 57.58,130.63 57.58,129.51 57.28,129.21 54.89,129.21 V18.1
  TOP w0.254: 59.66,130.48 59.66,129.41 57.96,127.71 53.47,127.71 52.25,128.93 52.25,132.68 C2076.1
N25909350: length 4.3
  TOP w0.109: R5999.2 53.37,140.5 53.37,140.04 53.78,139.62 54.69,139.62 U65.B2
N25909438: length 3.7
  TOP w0.254: C2076.2 53.52,135.6 R6006.1 54.06,136.61 U65.B1
N25909453: length 17.5
  TOP w0.109: v2(49.23,142.9) 49.61,142.52 51.13,142.52 51.44,142.21 52.45,142.21 53.98,140.69 U65.A3
  TOP w0.254: R734.2 56.14,145.92 56.07,145.85 R732.1 55.53,145.08 55.51,145.06 R731.1 55.85,144.53 v2(56.23,144.91)
  BOTTOM w0.109: v2(56.23,144.91) 55.55,144.23 52.96,144.23 52.27,143.54 49.86,143.54 v2(49.23,142.9)
N25909472: length 7.5
  TOP w0.109: U65.A2 53.26,138.35 v2(53.26,136.68)
  BOTTOM w0.109: C2079.2 53.29,136.7 v2(53.26,136.68)
N25909496: length 2.2
  TOP w0.109: R6005.1 52.74,142.52 53.06,142.52 53.98,141.6
N25913434: length 18.5
  TOP w0.127: R736.1 50.37,50.62 50.24,50.75 48.92,50.75 48.69,50.52 48.69,49.32 V20.1
  ART05 w0.305: v2(51.71,49.78) 55.35,49.78 56.95,48.18 61.72,48.18 62.89,49.35 v2(65.04,49.35)
N25913473: length 6.6
  TOP w0.109: U66.A3 62.84,50.52 64.67,50.52 65.09,50.94 R742.2 R740.1 R739.1
N25913475: length 9.3
  TOP w0.109: R6009.2 v2(53.05,52.72)
  ART03 w0.114: v2(61.16,51.38) 61.04,51.51 54.38,51.51 53.17,52.72 v2(53.05,52.72)
N25913538: length 9.6
  TOP w0.109: R5970.1 C1976.2 v2(64.15,49.94)
  BOTTOM w0.109: v2(64.15,49.94) 64.15,50.33 63.22,51.26 63.22,52.6 62.66,53.16 61.67,53.16 v2(61.16,52.65) 60.22,53.6 60.22,53.93 59.86,54.29 Q7.3
N25913563: length 3.3
  TOP w0.109: U66.A2 63.5,52.45 63.5,53.21 63.86,53.57 C1975.2
N25913583: length 3
  TOP w0.109: R6013.1 63.25,47.48 63.25,48.03 U66.A4
N25915448: length 2.7
  BOTTOM w0.109: R6040.1 55.92,55.47 57.05,55.47 57.26,55.26 58.04,55.26
N25917150: length 4.7
  TOP w0.109: U72.A3 44.3,17.6 R6015.1 45.72,18.99 R791.1 R6019.2
N25917152: length 5.5
  TOP w0.109: U72.B2 42.13,16.78 41.34,16.78 40.49,17.63 40.49,19.14 R6016.2
N25917215: length 3.6
  TOP w0.254: v2(41.53,16.1) 41.26,16.1 C2091.2
  BOTTOM w0.254: v2(41.53,16.1) 41.41,15.99 R794.1
N25917240: length 1.6
  TOP w0.109: C2094.2 U72.A2
N25917264: length 3.4
  TOP w0.109: U72.A4 46,18.03 R5484.1
N26156636: length 4.9
  TOP w0.109: U52.C4 178.74,200.81 178.74,200.08 178.16,199.49 176.95,199.49 R6020.2
N26156701: length 3.1
  TOP w0.109: U52.A1 183.77,198.37 183.77,197.47 C2097.1
N26158546: length 1.5
  TOP w0.109: U72.A1 41.38,17.53 C2098.1
N26159018: length 7
  TOP w0.109: R6021.2 v2(51.12,14.62)
  ART03 w0.114: v2(45.34,14.83) 45.9,14.27 50.77,14.27 v2(51.12,14.62)
N26162210: length 2.9
  BOTTOM w0.109: v2(62.43,52.65) 62.43,50.25 C2099.1
N26162577: length 9.5
  TOP w0.109: v2(52.4,51.99) R6022.2
  ART03 w0.114: v2(59.89,48.84) 59.28,49.45 56.72,49.45 55.42,50.75 53.64,50.75 v2(52.4,51.99)
N26162974: length 4.8
  TOP w0.254: R6023.2 v2(52.86,140.28)
  ART16 w0.114: v2(56.52,141.6) 55.75,140.84 54.15,140.84 53.59,140.28 v2(52.86,140.28)
N26163028: length 0.7
  BOTTOM w0.109: v2(53.98,137.79) 54.06,137.88 C2100.1
N26226036: length 3.8
  BOTTOM w0.109: R6089.1 132.42,17.54 132.41,17.53 132.41,15.47 v1(131.8,14.86)
N26297360: length 4.4
  ART07 w0.114: v4(153.19,179.98) 152.45,179.25 152.45,176.91 v4(153.19,176.17)
N26399332: length 7.2
  TOP w0.254: v2(113.26,199.42) U89.32
  ART05 w0.199: v2(111.29,204.15) 112.17,203.27 112.17,201.68 113.26,200.59 v2(113.26,199.42)
N26399369: length 9.4
  TOP w0.254: v2(126.36,198.86) U90.32
  ART05 w0.199: v2(123.27,204.61) 124.32,204.61 126.54,202.39 126.54,199.04 v2(126.36,198.86)
N26399427: length 7.3
  TOP w0.254: U88.32 99.46,199.42 v2(99.29,199.59)
  ART07 w0.199: v2(97.48,204.36) 99.29,202.54 v2(99.29,199.59)
N26399451: length 7.7
  TOP w0.254: U87.32 85.37,199.88 v2(85.01,200.23)
  ART05 w0.199: v3(84.73,205.6) 85.22,205.11 85.22,200.43 v2(85.01,200.23)
N26497673: length 6.2
  TOP w0.109: R1125.2 69.58,179.11 68.63,178.16 68.63,176 68.35,175.72 67.3,175.72 U49.C2
N26497696: length 7.8
  TOP w0.109: R6027.2 v2(59.89,177.38)
  BOTTOM w0.109: v1(66.64,176.33) 66.23,176.73 60.54,176.73 v2(59.89,177.38)
N26497698: length 4.5
  TOP w0.109: R6028.2 71.42,177.67 70.71,176.96 70.26,176.96 69.93,176.63 69.93,175.81 U49.C4
N26497767: length 3.9
  TOP w0.109: R1121.1 C489.2 64.27,177.42 U49.B1
N26497799: length 3.8
  TOP w0.109: R1119.2 66.48,180.77 R1126.2 66.48,179.02 U49.A3
N26497801: length 4.4
  TOP w0.109: U49.A2 65.7,178.54 64.99,178.54 C497.2
N26497825: length 4.5
  TOP w0.109: U49.A4 70.79,179.21 70.79,179.91 71.2,180.32 R6034.1
N26497837: length 5.6
  TOP w0.109: C2108.1 v2(61.3,179.49)
  BOTTOM w0.109: v1(65.37,177.6) 63.47,179.49 v2(61.3,179.49)
N26695392: length 1.1
  TOP w0.109: R6036.2 71.74,212.36 71.94,212.16 U54.27
N26845113: length 9.9
  TOP w0.109: TP65.1 140.31,17.07 v2(139.9,17.48)
  ART03 w0.114: v2(139.9,17.48) 139.17,18.21 135.15,18.21 v1(134.34,17.4) v1(134.34,16.13) v1(134.34,14.86)
N26845603: length 10.6
  TOP w0.109: U49.B5 73.53,176.33 74.35,177.14 74.35,182.47 TP73.1
N26845606: length 9.1
  TOP w0.109: U49.A5 71.21,178.36 73.68,178.36 74.04,178.72 74.04,181.92 TP72.1
N26846478: length 24.1
  TOP w0.109: TP79.1 v2(185.52,165.86)
  ART07 w0.114: v2(185.52,165.86) 185.52,166.7 187.53,168.71 189.33,168.71 189.69,168.35 189.69,166.57 190.78,165.48 190.78,164.19 191.87,163.09 194.64,163.09 196.7,161.04 201.24,161.04 v1(201.88,160.4)
N26847129: length 14.1
  ART20 w0.114: v1(206.63,181.23) 205.99,181.86 203.84,181.86 203.25,181.28 203.25,180.52 202.18,179.45 202.18,174.04 202.39,173.83 202.39,172.35 v1(201.88,171.83)
N26848007: length 7.1
  TOP w0.109: TP91.1 194.89,204.27 197.74,201.42 ; 197.74,202.69 197.74,201.42 ; 197.74,201.42 U53.L2
N26848031: length 8.4
  TOP w0.109: U53.B2 U53.A2 v4(211.71,202.69) ; v2(214.66,205.33) 214.38,205.61 TP92.1
  ART03 w0.114: v4(211.71,202.69) 211.71,204.11 212.93,205.33 v2(214.66,205.33)
N26848630: length 6.6
  TOP w0.109: TP97.1 193.34,137.16 194.59,135.92 U58.M2 ; U58.L2 U58.M2 ; U58.M2 U58.M1
N26848647: length 8
  TOP w0.109: TP98.1 v2(214.88,137.29) ; U58.B2 U58.A2 v4(210.31,137.19)
  ART03 w0.114: v2(214.88,137.29) 214.63,137.03 210.46,137.03 v4(210.31,137.19)
N26850674: length 13.3
  TOP w0.109: U57.M1 v2(149.38,187.6) U57.L2
  ART03 w0.114: v2(139.24,186.11) 147.88,186.11 v2(149.38,187.6)
N26850713: length 13
  TOP w0.109: v2(169.98,192.89) 170.43,193.34 TP108.1 ; v2(163.35,188.87) U57.A2 U57.B2
  ART05 w0.114: v2(169.98,192.89) 169.7,192.61 165.28,192.61 163.35,190.68 v2(163.35,188.87)
N26850842: length 9.9
  TOP w0.109: TP109.1 27.3,42.06 v2(27.71,42.47)
  ART03 w0.114: v1(30.86,36.45) v1(29.59,36.45) v1(28.32,36.45) 27.71,37.06 v2(27.71,42.47)
N26851640: length 11.8
  TOP w0.109: v2(12.47,46.54) 12.93,46.54 TP122.1
  ART03 w0.114: v2(12.47,46.54) 11.89,45.95 11.89,44.73 11.53,44.37 11.53,40.11 v1(10.92,39.5) v1(12.19,39.5) v1(13.46,39.5)
N26851765: length 12.6
  TOP w0.109: v2(25.32,138.33) 25.88,137.77 TP123.1
  ART05 w0.114: v2(25.32,138.33) 25.32,141.2 24.69,141.83 21.46,141.83 v1(20.85,142.44) v1(19.58,142.44) v1(18.31,142.44)
N26852289: length 8.9
  TOP w0.109: TP132.1 v2(45.26,43.48)
  ART03 w0.114: v2(45.26,43.48) 44.81,43.03 44.81,39.4 v1(45.59,38.61) v1(46.86,38.61) v1(48.13,38.61)
N26852333: length 11.3
  TOP w0.109: TP133.1 47.37,140.84 47.37,141.99 48.74,143.36 51.09,143.36 51.99,144.26 53.12,144.26 53.46,143.92 54.13,143.92 54.2,143.85 54.21,143.85 54.44,143.62 54.44,143.34 U65.A5
N26852348: length 15.3
  TOP w0.109: TP134.1 45.85,139.06 45.85,141.33 48.12,143.59 50.91,143.59 51.81,144.5 52.2,144.5 52.25,144.55 53.56,144.55 53.92,144.2 54.19,144.2 54.29,144.09 54.56,144.09 55.24,143.41 U65.B5
N26852460: length 5.8
  TOP w0.109: TP138.1 60.6,43.51 v2(60.6,43.69) ; v2(61.34,46.71) 61.16,46.89 U66.B5
  ART03 w0.114: v2(60.6,43.69) 61.43,44.51 61.43,46.62 v2(61.34,46.71)
N26852462: length 6.1
  TOP w0.109: TP139.1 62.69,43.43 v2(62.36,43.43) ; U66.A5 62.43,47.24 v2(62.92,46.76)
  ART03 w0.114: v2(62.92,46.76) 62.87,46.71 62.87,43.94 v2(62.36,43.43)
N26853301: length 9.6
  TOP w0.109: v2(115.09,17.27) 115.09,17.93 TP154.1
  ART20 w0.114: v1(109.6,14.86) v1(109.6,16.13) v1(109.6,17.4) 110.16,17.4 110.77,16.79 112.73,16.79 113.21,17.27 v2(115.09,17.27)
N26854304: length 10
  TOP w0.109: v2(163.42,16.33) 163.86,16.76 TP163.1
  ART03 w0.114: v2(163.42,16.33) 161.04,16.33 160.6,16.76 158.22,16.76 v1(157.58,17.4) v1(157.58,16.13) v1(157.58,14.86)
N26854498: length 9.4
  TOP w0.109: v2(94.16,14.76) 94.46,15.06 TP164.1
  ART20 w0.114: v1(89.46,17.4) v1(89.46,16.13) v1(89.46,14.86) 90.07,15.47 91.01,15.47 91.54,14.94 91.54,14.67 91.81,14.4 93.8,14.4 v2(94.16,14.76)
N26999540: length 10.9
  TOP w0.109: U72.A5 50.19,17.37 50.65,17.83 50.65,20.22 TP187.1
N26999551: length 11.5
  TOP w0.109: U72.B5 49.68,16.1 51.21,17.63 51.21,21.67 TP188.1
N27071338: length 29.8
  ART03 w0.114: v1(204.42,169.29) 203.86,169.85 203.86,170.79 203.45,171.2 198.63,171.2 198.32,170.89 185.42,170.89 184.86,170.33 184.86,168.15 182.3,165.58 182.3,164.8 v2(183.07,164.02)
  BOTTOM w0.109: R5472.1 v2(183.07,164.02)
N27114897: length 34.5
  ART07 w0.114: v1(208.23,168.02) 208.98,168.78 209.71,168.78 210.19,169.25 210.19,179.25 206.88,182.55 203.86,182.55 203.07,181.76 195.94,181.76 195.45,181.28 195.45,177.24 v2(196.04,176.66)
  BOTTOM w0.109: R5478.2 v2(196.04,176.66)
N27378058: length 5
  TOP w0.109: TP189.1 175.03,200.2 U52.B5
N27378060: length 3.6
  TOP w0.109: TP190.1 178.13,197.56 U52.A5
N27525479: length 13.8
  BOTTOM w0.109: R5411.1 7.1,43.15 C1941.2 6.58,42.58 6.58,36.6 6.86,36.32 8.64,36.32 8.92,36.04 8.92,35.2 9.19,34.92 10.16,34.92 v1(10.92,35.69)
N27525532: length 9
  BOTTOM w0.109: C1941.1 7.77,42.89 7.77,37.92 8.13,37.57 9.27,37.57 9.65,37.19 v1(9.65,35.69)
N27527172: length 28
  ART03 w0.114: v1(20.85,146.25) 21.23,146.25 21.89,145.59 24.71,145.59 25.25,145.05 25.25,139.45 26.06,138.63 26.06,126.58 27.01,125.63 v2(27.1,125.63)
  BOTTOM w0.109: C1943.2 27.99,126.21 27.41,125.63 v2(27.1,125.63) 26.71,125.63 R5420.1
N27527188: length 24.6
  ART03 w0.114: v1(22.12,146.25) 22.76,146.89 26.11,146.89 26.54,146.46 26.54,140.31 26.47,140.23 26.47,129.84 v2(28.02,128.3)
  BOTTOM w0.109: C1943.1 27.99,128.27 v2(28.02,128.3)
N27529227: length 13.4
  BOTTOM w0.109: v1(45.59,34.8) 44.96,34.16 42.9,34.16 42.37,34.7 42.37,37.49 41.99,37.87 41.55,37.87 41.2,38.23 41.2,41.33 41.8,41.92 C1945.2 41.77,42.27 R5429.1
N27529243: length 8.7
  BOTTOM w0.109: C1945.1 42.68,41.85 42.47,41.63 42.47,38.33 42.85,37.95 43.55,37.95 43.66,37.84 43.66,35.46 v1(44.32,34.8)
N27530223: length 13.6
  BOTTOM w0.109: C1953.2 113.23,22.31 R5438.1 112.81,22.34 112.22,21.74 106.65,21.74 106.43,21.51 106.43,20.88 106.1,20.55 105.44,20.55 105.16,20.27 105.16,18.03 v1(105.79,17.4)
N27530239: length 8.7
  BOTTOM w0.109: C1953.1 112.42,20.31 112.21,20.52 108.18,20.52 107.65,19.99 107.65,19.38 106.98,18.72 105.84,18.72 v1(105.79,18.67)
N27532729: length 13.4
  BOTTOM w0.109: v1(153.77,17.4) 153.01,18.16 153.01,19.91 153.5,20.4 153.96,20.4 154.25,20.69 154.25,21.07 154.95,21.77 160.12,21.77 160.69,22.34 R5447.1 161.21,22.31 C1956.2
N27532745: length 8.5
  BOTTOM w0.109: C1956.1 160.69,20.31 160.5,20.5 158.76,20.5 158.29,20.03 158.29,19.68 157.91,19.3 154.41,19.3 v1(153.77,18.67)
N27536476: length 13.4
  BOTTOM w0.109: v1(85.65,17.4) 84.99,18.06 84.99,20.09 85.39,20.5 86.94,20.5 87.45,21.01 87.45,21.46 87.81,21.82 92.1,21.82 92.62,22.34 R5456.1 93.12,21.22 C1959.2
N27536492: length 8.3
  BOTTOM w0.109: v1(85.65,18.67) 86.46,18.67 87.53,19.74 87.53,19.93 88.02,20.42 92.23,20.42 92.34,20.31 C1959.1
N27875059: length 4.5
  TOP w0.254: R6093.2 84.46,201.99 84.15,201.68 84.15,199.36 84.37,199.15 U87.34
N27875090: length 3.9
  TOP w0.254: U88.34 98.46,200.38 R6094.2
N27875121: length 3.8
  TOP w0.254: R6095.2 112.14,200.33 112.14,198.32 112.26,198.21 U89.34
N27875145: length 5.5
  TOP w0.254: U90.34 v2(125.36,198.72)
  ART05 w0.199: v2(123.37,201.63) 123.37,201.54 123.69,201.22 124.28,201.22 125.36,200.14 v2(125.36,198.72)
N28019144: length 1.5
  TOP w0.137: U3.F9 v2(84.53,144.92)
  BOTTOM w0.089: v2(84.53,144.92) 84.25,144.92 83.95,145.22
  BOTTOM w0.109: R116.1 83.95,145.22
N28022993: length 1.5
  TOP w0.137: U4.F9 v2(95.96,144.92)
  BOTTOM w0.127: R117.1 95.69,144.92 v2(95.96,144.92)
N30715060: length 1.5
  TOP w0.137: U5.F9 v2(107.39,144.92)
  BOTTOM w0.127: v2(107.39,144.92) 107.11,144.92 R120.1
N30715756: length 1.3
  TOP w0.137: U6.F9 v2(118.82,144.92)
  BOTTOM w0.254: v2(118.82,144.92) 118.24,144.92 118.24,144.92
  BOTTOM w0.305: R121.1 118.24,144.92
N30729048: length 2.1
  TOP w0.137: U7.F9 v2(73.1,144.92)
  BOTTOM w0.127: v2(73.1,144.92) 72.65,144.92 72.2,144.46 R135.1
N30732060: length 1.9
  TOP w0.137: U7.A3 v2(77.9,140.92)
  BOTTOM w0.127: R124.2 78.42,140.4 v2(77.9,140.92)
N30732063: length 0.6
  TOP w0.137: U7.B8 v2(73.9,141.72)
N30732066: length 1.3
  TOP w0.137: U7.C3 v2(77.9,142.52)
  BOTTOM w0.203: v2(77.9,142.52) 77.64,142.52 R126.2
